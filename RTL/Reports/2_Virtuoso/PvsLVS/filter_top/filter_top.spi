* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                          *
*                                                       *
* Cell Name  : filter_top                               *
* Netlisted  : Sat Mar  5 18:20:18 2022                 *
* PVS Version: 15.22-s262 Thu Dec 15 17:04:58 PST 2016 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MN(ne) ne ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 1 MN(nel) nel ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 2 MN(ne5) nem ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 3 MP(pe) pe pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 4 MP(pel) pel pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 5 MP(pe5) pem pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 6 MN(nn) nn ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 7 MN(nn5) nnm ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 8 MN(nd5) ndm ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 9 MP(peti) peti pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 10 MP(pe5ti) pemti pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 11 LDDN(nmva) nmva nwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 12 LDDP(pmva) pmva bulk(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 13 MOSVC() mosvc p1trm(G) nwtrm(NW) bulk(SB)
*.DEVTMPLT 14 MOSVCTI() mosvci p1trm(G) bulk(PW)
*.DEVTMPLT 15 MOSVC5() mosvcm p1trm(G) nwtrm(NW) bulk(SB)
*.DEVTMPLT 16 MOSVC5TI() mosvcim p1trm(G) bulk(PW)
*.DEVTMPLT 17 NHSJ1_7() nhsj1_7 nhv1_d(D) p1trm(G) nsd_mv(S) bulk(B) hwafer(HW)
*.DEVTMPLT 18 NHSJ1_10() nhsj1_10 nhv1_d(D) p1trm(G) nsd_mv(S) bulk(B) hwafer(HW)
*.DEVTMPLT 19 NHSJ1_16C() nhsj1_16c nhv1_d(D) p1trm(G) nsd_mv(S) bulk(B) hwafer(HW)
*.DEVTMPLT 20 PHSJ1_7() phsj1_7 phv1_d(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer(HW)
*.DEVTMPLT 21 PHSJ1_10() phsj1_10 phv1_d(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer(HW)
*.DEVTMPLT 22 PHSJ1_16C() phsj1_16c phv1_d(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer(HW)
*.DEVTMPLT 23 PE_5() pe_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 24 PEL_5() pel_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 25 PE5_5() pem_5 pdiff(D) p1trm(G) pdiff(S) nwtrm(B) bulk(SB)
*.DEVTMPLT 26 NHVTA() nhvta ndftrm(D) p1trm(G) nsd_mv(S) bulk(B) hwafer1(HW)
*.DEVTMPLT 27 NHVTB() nhvtb ndftrm(D) p1trm(G) nsd_mv(S) bulk(B) hwafer1(HW)
*.DEVTMPLT 28 NHVU() nhvu ndftrm(D) p1trm(G) nsd_mv(S) bulk(B) hwafer1(HW)
*.DEVTMPLT 29 NDHVT() ndhvt ndftrm(D) p1trm(G) nsd_mv(S) bulk(B) hwafer1(HW)
*.DEVTMPLT 30 NDHVTA() ndhvta ndftrm(D) p1trm(G) nsd_mv(S) bulk(B) hwafer1(HW)
*.DEVTMPLT 31 PHVTA() phvta pdftrm(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer1(HW)
*.DEVTMPLT 32 PHVTB() phvtb pdftrm(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer1(HW)
*.DEVTMPLT 33 PHVU() phvu pdftrm(D) p1trm(G) psd_mv(S) nwtrm(B) hwafer1(HW)
*.DEVTMPLT 34 NISJ1_16() nisj1_16 nisj_d(C) p1trm(G) nsd_mv(E) hwafer(HW)
*.DEVTMPLT 35 Q(qpva) qpva bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 36 Q(qpvb) qpvb bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 37 Q(qpvc) qpvc bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 38 Q(qpve) qpve bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 39 Q(qpvf) qpvf bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 40 Q(qpvg) qpvg bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 41 Q(qpva5) qpvma bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 42 Q(qpvb5) qpvmb bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 43 Q(qpvc5) qpvmc bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 44 Q(qpve5) qpvme bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 45 Q(qpvf5) qpvmf bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 46 Q(qpvg5) qpvmg bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 47 Q(qnv5) qnv5 nwtrm(C) bulk(B) nsd_mv(E)
*.DEVTMPLT 48 Q(qpv5) qpv5 bulk(C) nbase(B) psd_mv(E)
*.DEVTMPLT 49 R(rnw) rnw nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 50 R(rnw_scr) rnw_scr nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 51 R(rnw5) rnwm nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 52 R(rnw5_scr) rnwm_scr nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 53 R(rdn) rdn ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 54 R(rdn) rdn_g ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 55 R(rdn5) rdnm ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 56 R(rdn5) rdnm_g ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 57 R(rdn5_pw4) rdnm_pw4 ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 58 R(rdn5_dpc) rdnm_dpc ndiff(POS) ndiff(NEG) bulk(SUB)
*.DEVTMPLT 59 R(rdp) rdp pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 60 R(rdp) rdp_g pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 61 R(rdp5) rdpm pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 62 R(rdp5) rdpm_g pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 63 R(rnp1) rnp1_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 64 R(rnp1_3) rnp1_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 65 R(rnp1_3) rnp1_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 66 R(rpp1) rpp1_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 67 R(rpp1_3) rpp1_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 68 R(rpp1_3) rpp1_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 69 R(rnp1h) rnp1h_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 70 R(rnp1h_3) rnp1h_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 71 R(rnp1h_3) rnp1h_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 72 R(rpp1k1) rpp1k1_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 73 R(rpp1k1_3) rpp1k1_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 74 R(rpp1k1_3) rpp1k1_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 75 R(rpp1k1a) rpp1k1a_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 76 R(rpp1k1a_3) rpp1k1a_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 77 R(rpp1k1a_3) rpp1k1a_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 78 R(rpp1s) rpp1s_1 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 79 R(rpp1s_3) rpp1s_3_pw p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 80 R(rpp1s_3) rpp1s_3_nw p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 81 R(rxw2ti) rxw2ti nwtrm(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 82 R(pfuse) pfuse p1trm(POS) p1trm(NEG)
*.DEVTMPLT 83 R(rm1) rm1 m1trm(POS) m1trm(NEG)
*.DEVTMPLT 84 R(rm2) rm2 m2trm(POS) m2trm(NEG)
*.DEVTMPLT 85 R(rm3) rm3 m3trm(POS) m3trm(NEG)
*.DEVTMPLT 86 R(rm4) rm4 m4trm(POS) m4trm(NEG)
*.DEVTMPLT 87 R(rmtp) rmtp mttrm(POS) mttrm(NEG)
*.DEVTMPLT 88 R(rmtpl) rmtpl mltrm(POS) mltrm(NEG)
*.DEVTMPLT 0 D(dn) d_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(dn) d_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(dnn) d_dnn bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(dnn) d_dnn bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(dp) d_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(dp) d_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(dn5) d_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(dn5) d_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(dnn5) d_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(dnn5) d_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(dp5) d_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(dp5) d_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(dnw) d_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(dnw) d_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(dnw5) d_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(dnw5) d_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 105 D(dnpa) dnpa bulk(POS) nsd_mv(NEG)
*.DEVTMPLT 106 D(dnpati) dnpati bulk(POS) nsd_mv(NEG)
*.DEVTMPLT 107 D(dza) dza bulk(POS) nsd_mv(NEG)
*.DEVTMPLT 108 D(dzati) dzati bulk(POS) nsd_mv(NEG)
*.DEVTMPLT 109 D(dfwdn5) dfwdn5 bulk(POS) nsd_mv(NEG)
*.DEVTMPLT 110 D(dzbti) dzb psd_mv(POS) nwtrm(NEG) bulk(SUB)
*.DEVTMPLT 111 D(dhw2) dhw2_dev hwafer(POS) dhw_nbur(NEG)
*.DEVTMPLT 112 D(dhw2a) dhw2a_dev hwafer(POS) dhw_nbur(NEG)
*.DEVTMPLT 113 D(dhw3) dhw3_dev hwafer(POS) dhw_nbur(NEG)
*.DEVTMPLT 114 D(dpp6) dpp6 pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 115 D(dpp7) dpp7 pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 116 D(dnp7) dnp7 bulk(POS) ndiff(NEG)
*.DEVTMPLT 117 D(ds5a) ds5a d_dsdf(POS) nwtrm(NEG)
*.DEVTMPLT 118 D(dfwnsj1_7) dfwnsj1_7 bulk(POS) ndiff(NEG)
*.DEVTMPLT 119 D(dfwnsj1_10) dfwnsj1_10 bulk(POS) ndiff(NEG)
*.DEVTMPLT 120 D(dfwnsj1_16c) dfwnsj1_16c bulk(POS) ndiff(NEG)
*.DEVTMPLT 121 D(dfwdpa) dfwdp1f psd_mv(POS) nwtrm(NEG)
*.DEVTMPLT 122 D(dfwdpa) dfwdp2f psd_mv(POS) nwtrm(NEG)
*.DEVTMPLT 123 D(dfwdnt) dfwdnt bulk(POS) ndftrm(NEG)
*.DEVTMPLT 124 D(dfwdnu) dfwdnu bulk(POS) ndftrm(NEG)
*.DEVTMPLT 0 D(p_dn) p_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(p_dn) p_dn bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(p_dnn) p_dnn bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(p_dnn) p_dnn bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(p_dp) p_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(p_dp) p_dp pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(p_dn5) p_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(p_dn5) p_dnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(p_dnn5) p_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 1 D(p_dnn5) p_dnnm bulk(POS) ndiff(NEG)
*.DEVTMPLT 0 D(p_dpn5) p_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(p_dp5) p_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(p_dnw) p_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(p_dnw) p_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(p_dnw5) p_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(p_dnw5) p_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 0 D(p_dnw5mva) p_dnwmmva bulk(POS) nwtrm(NEG)
*.DEVTMPLT 1 D(p_dnw5mva) p_dnwmmva bulk(POS) nwtrm(NEG)
*.DEVTMPLT 143 C(csf2p) d_csf2p m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 144 C(csf3) d_csf3 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 145 C(csf3p) d_csf3p m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 146 C(csf3a) d_csf3a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 147 C(csf4) d_csf4 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 148 C(csf4a) d_csf4a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 149 C(csft5) d_csft5 m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 150 C(csft5a) d_csft5a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 151 C(csandwt3) d_cswt3 m1trm(POS) p1trm(NEG)
*.DEVTMPLT 152 C(csandwt4) d_cswt4 m1trm(POS) p1trm(NEG)
*.DEVTMPLT 153 C(cmm3) cmim23f capm23f(POS) m2trm(NEG)
*.DEVTMPLT 154 C(cmmh3) cmimh23f capmh23f(POS) m2trm(NEG)
*.DEVTMPLT 155 C(cmm4) cmim34f capm34f(POS) m3trm(NEG)
*.DEVTMPLT 156 C(cmmh4) cmimh34f capmh34f(POS) m3trm(NEG)
*.DEVTMPLT 157 C(cdmm4) cdmm capm2_b(POS) m2trm(NEG)
*.DEVTMPLT 158 C(cdmmh4) cdmmh capmh2_b(POS) m2trm(NEG)
*.DEVTMPLT 159 C(cmm5t) cmim capm(POS) m4trm(NEG)
*.DEVTMPLT 160 C(cmmh5t) cmimh capmh(POS) m4trm(NEG)
*.DEVTMPLT 161 C(cdmm5t) cdmma capm2a_b(POS) m3trm(NEG)
*.DEVTMPLT 162 C(cdmmh5t) cdmmha capmh2a_b(POS) m3trm(NEG)
*.DEVTMPLT 163 C(ctmm5t) ctmm capm3_b(POS) m2trm(NEG)
*.DEVTMPLT 164 C(ctmmh5t) ctmmh capmh3_b(POS) m2trm(NEG)
*.DEVTMPLT 165 tag_200v() tp1_200 p1_vlbl(N1)
*.DEVTMPLT 166 tag_100v() tp1_100 p1_vlbl(N1)
*.DEVTMPLT 167 tag_60v() tp1_60 p1_vlbl(N1)
*.DEVTMPLT 168 tag_25v() tp1_25 p1_vlbl(N1)
*.DEVTMPLT 169 tag_m200v() tp1_m200 p1_vlbl(N1)
*.DEVTMPLT 170 tag_m100v() tp1_m100 p1_vlbl(N1)
*.DEVTMPLT 171 tag_m60v() tp1_m60 p1_vlbl(N1)
*.DEVTMPLT 172 tag_m25v() tp1_m25 p1_vlbl(N1)
*.DEVTMPLT 173 tag_200v() tm1_200 m1_vlbl(N1)
*.DEVTMPLT 174 tag_100v() tm1_100 m1_vlbl(N1)
*.DEVTMPLT 175 tag_60v() tm1_60 m1_vlbl(N1)
*.DEVTMPLT 176 tag_25v() tm1_25 m1_vlbl(N1)
*.DEVTMPLT 177 tag_m200v() tm1_m200 m1_vlbl(N1)
*.DEVTMPLT 178 tag_m100v() tm1_m100 m1_vlbl(N1)
*.DEVTMPLT 179 tag_m60v() tm1_m60 m1_vlbl(N1)
*.DEVTMPLT 180 tag_m25v() tm1_m25 m1_vlbl(N1)
*.DEVTMPLT 181 tag_200v() tm2_200 m2_vlbl(N1)
*.DEVTMPLT 182 tag_100v() tm2_100 m2_vlbl(N1)
*.DEVTMPLT 183 tag_60v() tm2_60 m2_vlbl(N1)
*.DEVTMPLT 184 tag_25v() tm2_25 m2_vlbl(N1)
*.DEVTMPLT 185 tag_m200v() tm2_m200 m2_vlbl(N1)
*.DEVTMPLT 186 tag_m100v() tm2_m100 m2_vlbl(N1)
*.DEVTMPLT 187 tag_m60v() tm2_m60 m2_vlbl(N1)
*.DEVTMPLT 188 tag_m25v() tm2_m25 m2_vlbl(N1)
*.DEVTMPLT 189 tag_200v() tm3_200 m3_vlbl(N1)
*.DEVTMPLT 190 tag_100v() tm3_100 m3_vlbl(N1)
*.DEVTMPLT 191 tag_60v() tm3_60 m3_vlbl(N1)
*.DEVTMPLT 192 tag_25v() tm3_25 m3_vlbl(N1)
*.DEVTMPLT 193 tag_m200v() tm3_m200 m3_vlbl(N1)
*.DEVTMPLT 194 tag_m100v() tm3_m100 m3_vlbl(N1)
*.DEVTMPLT 195 tag_m60v() tm3_m60 m3_vlbl(N1)
*.DEVTMPLT 196 tag_m25v() tm3_m25 m3_vlbl(N1)
*.DEVTMPLT 197 tag_200v() tm4_200 m4_vlbl(N1)
*.DEVTMPLT 198 tag_100v() tm4_100 m4_vlbl(N1)
*.DEVTMPLT 199 tag_60v() tm4_60 m4_vlbl(N1)
*.DEVTMPLT 200 tag_25v() tm4_25 m4_vlbl(N1)
*.DEVTMPLT 201 tag_m200v() tm4_m200 m4_vlbl(N1)
*.DEVTMPLT 202 tag_m100v() tm4_m100 m4_vlbl(N1)
*.DEVTMPLT 203 tag_m60v() tm4_m60 m4_vlbl(N1)
*.DEVTMPLT 204 tag_m25v() tm4_m25 m4_vlbl(N1)
*.DEVTMPLT 205 tag_200v() tmt_200 mt_vlbl(N1)
*.DEVTMPLT 206 tag_100v() tmt_100 mt_vlbl(N1)
*.DEVTMPLT 207 tag_60v() tmt_60 mt_vlbl(N1)
*.DEVTMPLT 208 tag_25v() tmt_25 mt_vlbl(N1)
*.DEVTMPLT 209 tag_m200v() tmt_m200 mt_vlbl(N1)
*.DEVTMPLT 210 tag_m100v() tmt_m100 mt_vlbl(N1)
*.DEVTMPLT 211 tag_m60v() tmt_m60 mt_vlbl(N1)
*.DEVTMPLT 212 tag_m25v() tmt_m25 mt_vlbl(N1)
*.DEVTMPLT 213 tag_200v() tml_200 ml_vlbl(N1)
*.DEVTMPLT 214 tag_100v() tml_100 ml_vlbl(N1)
*.DEVTMPLT 215 tag_60v() tml_60 ml_vlbl(N1)
*.DEVTMPLT 216 tag_25v() tml_25 ml_vlbl(N1)
*.DEVTMPLT 217 tag_m200v() tml_m200 ml_vlbl(N1)
*.DEVTMPLT 218 tag_m100v() tml_m100 ml_vlbl(N1)
*.DEVTMPLT 219 tag_m60v() tml_m60 ml_vlbl(N1)
*.DEVTMPLT 220 tag_m25v() tml_m25 ml_vlbl(N1)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHVTA                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHVTA D G S B HW
.ends PHVTA

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NDHVTA                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NDHVTA D G S B HW
.ends NDHVTA

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHVTA                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHVTA D G S B HW
.ends NHVTA

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHSJ1_10                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHSJ1_10 D G S B HW
.ends PHSJ1_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHSJ1_10                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHSJ1_10 D G S B HW
.ends NHSJ1_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LDDN                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LDDN D G S B
.ends LDDN

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_25v                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_25v N1
.ends tag_25v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_60v                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_60v N1
.ends tag_60v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHVTB                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHVTB D G S B HW
.ends PHVTB

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHVTB                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHVTB D G S B HW
.ends NHVTB

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PE5_5                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PE5_5 D G S B SB
.ends PE5_5

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PEL_5                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PEL_5 D G S B SB
.ends PEL_5

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PE_5                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PE_5 D G S B SB
.ends PE_5

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHSJ1_16C                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHSJ1_16C D G S B HW
.ends PHSJ1_16C

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MOSVC5                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MOSVC5 G NW SB
.ends MOSVC5

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_m100v                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_m100v N1
.ends tag_m100v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_m200v                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_m200v N1
.ends tag_m200v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LDDP                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LDDP D G S B
.ends LDDP

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MOSVC                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MOSVC G NW SB
.ends MOSVC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHSJ1_7                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHSJ1_7 D G S B HW
.ends PHSJ1_7

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHSJ1_7                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHSJ1_7 D G S B HW
.ends NHSJ1_7

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_m25v                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_m25v N1
.ends tag_m25v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_m60v                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_m60v N1
.ends tag_m60v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_100v                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_100v N1
.ends tag_100v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: tag_200v                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt tag_200v N1
.ends tag_200v

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NISJ1_16                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NISJ1_16 C G E HW
.ends NISJ1_16

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NDHVT                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NDHVT D G S B HW
.ends NDHVT

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PHVU                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PHVU D G S B HW
.ends PHVU

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHVU                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHVU D G S B HW
.ends NHVU

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MOSVCTI                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MOSVCTI G PW
.ends MOSVCTI

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NHSJ1_16C                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NHSJ1_16C D G S B HW
.ends NHSJ1_16C

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MOSVC5TI                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MOSVC5TI G PW
.ends MOSVC5TI

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX1 vdd5! gnd! A Q
** N=5 EP=4 FDC=4
M0 gnd! A 5 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.27267e-13 AS=2.016e-13 PD=1.44667e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 Q 5 gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=3.168e-13 AS=3.57133e-13 PD=2.28e-06 PS=2.27333e-06 $X=1680 $Y=890 $dt=2
M2 vdd5! A 5 vdd5! pe5 L=5e-07 W=1.045e-06 AD=3.84777e-13 AS=5.016e-13 PD=2.01368e-06 PS=3.05e-06 $X=620 $Y=2410 $dt=5
M3 Q 5 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=5.19173e-13 PD=3.78e-06 PS=2.71703e-06 $X=1680 $Y=2410 $dt=5
.ends BU_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX2 vdd5! gnd! A Q
** N=5 EP=4 FDC=6
M0 gnd! A 5 gnd! ne5 L=5e-07 W=5.4e-07 AD=2.8089e-13 AS=2.592e-13 PD=1.66873e-06 PS=2.04e-06 $X=620 $Y=1010 $dt=2
M1 Q 5 gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=1.782e-13 AS=3.4331e-13 PD=1.2e-06 PS=2.03956e-06 $X=1720 $Y=890 $dt=2
M2 gnd! 5 Q gnd! ne5 L=5e-07 W=6.6e-07 AD=5.868e-13 AS=1.782e-13 PD=3.52e-06 PS=1.2e-06 $X=2760 $Y=890 $dt=2
M3 vdd5! A 5 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.19972e-13 AS=6.768e-13 PD=2.38713e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M4 Q 5 vdd5! vdd5! pe5 L=5.00041e-07 W=1.41828e-06 AD=3.617e-13 AS=5.23028e-13 PD=1.93828e-06 PS=2.40115e-06 $X=1740 $Y=2410 $dt=5
M5 vdd5! 5 Q vdd5! pe5 L=5.00041e-07 W=1.41828e-06 AD=8.668e-13 AS=3.617e-13 PD=4.54828e-06 PS=1.93828e-06 $X=2780 $Y=2410 $dt=5
.ends BU_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX0                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX0 vdd5! gnd! A Q
** N=5 EP=4 FDC=4
M0 gnd! A 5 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.802e-13 AS=2.016e-13 PD=1.86e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 Q 5 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=2.802e-13 PD=1.8e-06 PS=1.86e-06 $X=1680 $Y=1130 $dt=2
M2 vdd5! A 5 vdd5! pe5 L=5e-07 W=1.12e-06 AD=4.73118e-13 AS=5.376e-13 PD=2.56885e-06 PS=3.2e-06 $X=620 $Y=2410 $dt=5
M3 Q 5 vdd5! vdd5! pe5 L=5e-07 W=9.4e-07 AD=4.512e-13 AS=3.97082e-13 PD=2.84e-06 PS=2.156e-06 $X=1680 $Y=2410 $dt=5
.ends BU_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY2_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY2_5VX1 vdd5! gnd! A Q
** N=11 EP=4 FDC=12
M0 gnd! A 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.885e-13 AS=2.016e-13 PD=1.87e-06 PS=1.8e-06 $X=620 $Y=660 $dt=2
M1 5 8 gnd! gnd! ne5 L=8.9e-07 W=4.2e-07 AD=1.904e-13 AS=3.885e-13 PD=1.585e-06 PS=1.87e-06 $X=2220 $Y=660 $dt=2
M2 5 8 9 gnd! ne5 L=8.9e-07 W=4.2e-07 AD=1.904e-13 AS=2.016e-13 PD=1.585e-06 PS=1.8e-06 $X=2220 $Y=1360 $dt=2
M3 gnd! 9 6 gnd! ne5 L=1.26e-06 W=4.2e-07 AD=3.55349e-13 AS=1.932e-13 PD=1.65115e-06 PS=1.59e-06 $X=4125 $Y=660 $dt=2
M4 7 9 6 gnd! ne5 L=1.26e-06 W=4.2e-07 AD=2.00088e-13 AS=1.932e-13 PD=1.76778e-06 PS=1.59e-06 $X=4125 $Y=1360 $dt=2
M5 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=7.53001e-13 PD=2.74e-06 PS=3.49885e-06 $X=6720 $Y=660 $dt=2
M6 vdd5! A 8 vdd5! pe5 L=5e-07 W=7e-07 AD=5.41625e-13 AS=3.36e-13 PD=2.6875e-06 PS=2.36e-06 $X=620 $Y=3120 $dt=5
M7 10 8 9 vdd5! pe5 L=9.25e-07 W=4.2e-07 AD=2.8095e-13 AS=2.0035e-13 PD=1.785e-06 PS=1.77071e-06 $X=2185 $Y=2640 $dt=5
M8 10 8 vdd5! vdd5! pe5 L=8.9e-07 W=4.2e-07 AD=2.8095e-13 AS=3.24975e-13 PD=1.785e-06 PS=1.6125e-06 $X=2220 $Y=3400 $dt=5
M9 7 9 11 vdd5! pe5 L=1.26e-06 W=4.2e-07 AD=2.016e-13 AS=2.624e-13 PD=1.8e-06 PS=1.74e-06 $X=4380 $Y=2660 $dt=5
M10 vdd5! 9 11 vdd5! pe5 L=1.42e-06 W=4.2e-07 AD=2.19226e-13 AS=2.624e-13 PD=1.23016e-06 PS=1.74e-06 $X=4380 $Y=3400 $dt=5
M11 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=7.35974e-13 PD=3.78e-06 PS=4.12984e-06 $X=6720 $Y=2410 $dt=5
.ends DLY2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY4_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY4_5VX1 vdd5! gnd! A Q
** N=13 EP=4 FDC=14
M0 gnd! A 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=2.016e-13 PD=9.6e-07 PS=1.8e-06 $X=620 $Y=660 $dt=2
M1 6 8 gnd! gnd! ne5 L=1.17e-06 W=4.2e-07 AD=1.652e-13 AS=1.134e-13 PD=1.54e-06 PS=9.6e-07 $X=1660 $Y=660 $dt=2
M2 6 8 5 gnd! ne5 L=1.17e-06 W=4.2e-07 AD=1.652e-13 AS=2.00088e-13 PD=1.54e-06 PS=1.76778e-06 $X=1660 $Y=1360 $dt=2
M3 10 8 5 gnd! ne5 L=1.15e-06 W=4.2e-07 AD=2.016e-13 AS=2.016e-13 PD=1.8e-06 PS=1.8e-06 $X=3910 $Y=1400 $dt=2
M4 gnd! 10 9 gnd! ne5 L=2.915e-06 W=4.2e-07 AD=3.8547e-13 AS=2.016e-13 PD=1.61588e-06 PS=1.8e-06 $X=5310 $Y=660 $dt=2
M5 7 10 9 gnd! ne5 L=1.815e-06 W=4.2e-07 AD=2.00088e-13 AS=2.016e-13 PD=1.76778e-06 PS=1.8e-06 $X=6310 $Y=1400 $dt=2
M6 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.4055e-13 AS=8.1683e-13 PD=2.77e-06 PS=3.42412e-06 $X=9505 $Y=660 $dt=2
M7 vdd5! A 8 vdd5! pe5 L=5e-07 W=7e-07 AD=4.61125e-13 AS=3.36e-13 PD=2.6375e-06 PS=2.36e-06 $X=620 $Y=2680 $dt=5
M8 13 8 vdd5! vdd5! pe5 L=9e-07 W=4.2e-07 AD=2.016e-13 AS=2.76675e-13 PD=1.8e-06 PS=1.5825e-06 $X=1740 $Y=2680 $dt=5
M9 10 8 11 vdd5! pe5 L=9e-07 W=4.2e-07 AD=2.016e-13 AS=1.674e-13 PD=1.8e-06 PS=1.56e-06 $X=3720 $Y=2680 $dt=5
M10 13 8 11 vdd5! pe5 L=9e-07 W=4.2e-07 AD=2.016e-13 AS=1.674e-13 PD=1.8e-06 PS=1.56e-06 $X=3720 $Y=3400 $dt=5
M11 7 10 12 vdd5! pe5 L=2.4e-06 W=4.2e-07 AD=3.192e-13 AS=1.779e-13 PD=2.36e-06 PS=1.61e-06 $X=5725 $Y=2680 $dt=5
M12 vdd5! 10 12 vdd5! pe5 L=2.4e-06 W=4.2e-07 AD=2.78026e-13 AS=1.779e-13 PD=1.44131e-06 PS=1.61e-06 $X=5725 $Y=3400 $dt=5
M13 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.9795e-13 AS=9.33374e-13 PD=3.81e-06 PS=4.83869e-06 $X=9505 $Y=2410 $dt=5
.ends DLY4_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY8_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY8_5VX1 vdd5! gnd! A Q
** N=17 EP=4 FDC=20
M0 gnd! A 11 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=2.016e-13 PD=9.6e-07 PS=1.8e-06 $X=620 $Y=660 $dt=2
M1 8 11 gnd! gnd! ne5 L=2.25e-06 W=4.2e-07 AD=1.652e-13 AS=1.134e-13 PD=1.54e-06 PS=9.6e-07 $X=1660 $Y=660 $dt=2
M2 8 11 5 gnd! ne5 L=2.25e-06 W=4.2e-07 AD=1.652e-13 AS=2.00088e-13 PD=1.54e-06 PS=1.76778e-06 $X=1660 $Y=1360 $dt=2
M3 gnd! 5 6 gnd! ne5 L=1.85e-06 W=4.2e-07 AD=4.424e-13 AS=1.652e-13 PD=2.01e-06 PS=1.54e-06 $X=4830 $Y=660 $dt=2
M4 12 5 6 gnd! ne5 L=1.85e-06 W=4.2e-07 AD=2.016e-13 AS=1.652e-13 PD=1.8e-06 PS=1.54e-06 $X=4830 $Y=1360 $dt=2
M5 9 12 gnd! gnd! ne5 L=1.78e-06 W=4.2e-07 AD=1.652e-13 AS=4.424e-13 PD=1.54e-06 PS=2.01e-06 $X=7920 $Y=660 $dt=2
M6 9 12 13 gnd! ne5 L=1.78e-06 W=4.2e-07 AD=1.652e-13 AS=2.016e-13 PD=1.54e-06 PS=1.8e-06 $X=7920 $Y=1360 $dt=2
M7 gnd! 13 7 gnd! ne5 L=1.04e-06 W=4.2e-07 AD=4.9233e-13 AS=1.652e-13 PD=1.93649e-06 PS=1.54e-06 $X=10620 $Y=660 $dt=2
M8 10 13 7 gnd! ne5 L=1.04e-06 W=4.2e-07 AD=2.00088e-13 AS=1.652e-13 PD=1.76778e-06 PS=1.54e-06 $X=10620 $Y=1360 $dt=2
M9 Q 10 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.04327e-12 PD=2.74e-06 PS=4.10351e-06 $X=13440 $Y=660 $dt=2
M10 vdd5! A 11 vdd5! pe5 L=5e-07 W=6.7e-07 AD=3.18957e-13 AS=3.216e-13 PD=2.10835e-06 PS=2.3e-06 $X=620 $Y=2640 $dt=5
M11 15 11 vdd5! vdd5! pe5 L=1.78e-06 W=4.2e-07 AD=1.718e-13 AS=1.99943e-13 PD=1.6e-06 PS=1.32165e-06 $X=2165 $Y=2640 $dt=5
M12 15 11 5 vdd5! pe5 L=1.78e-06 W=4.2e-07 AD=1.718e-13 AS=2.0035e-13 PD=1.6e-06 PS=1.77071e-06 $X=2165 $Y=3400 $dt=5
M13 12 5 14 vdd5! pe5 L=2.425e-06 W=4.2e-07 AD=2.016e-13 AS=1.696e-13 PD=1.8e-06 PS=1.58e-06 $X=4865 $Y=2640 $dt=5
M14 vdd5! 5 14 vdd5! pe5 L=2.425e-06 W=4.2e-07 AD=4.528e-13 AS=1.696e-13 PD=2.03e-06 PS=1.58e-06 $X=4865 $Y=3380 $dt=5
M15 16 12 13 vdd5! pe5 L=1.57e-06 W=4.2e-07 AD=1.696e-13 AS=2.016e-13 PD=1.58e-06 PS=1.8e-06 $X=8530 $Y=2640 $dt=5
M16 16 12 vdd5! vdd5! pe5 L=1.57e-06 W=4.2e-07 AD=1.696e-13 AS=4.528e-13 PD=1.58e-06 PS=2.03e-06 $X=8530 $Y=3380 $dt=5
M17 10 13 17 vdd5! pe5 L=1.34e-06 W=4.2e-07 AD=2.016e-13 AS=1.674e-13 PD=1.8e-06 PS=1.56e-06 $X=11020 $Y=2640 $dt=5
M18 vdd5! 13 17 vdd5! pe5 L=1.34e-06 W=4.2e-07 AD=2.53561e-13 AS=1.674e-13 PD=1.30361e-06 PS=1.56e-06 $X=11020 $Y=3360 $dt=5
M19 Q 10 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=8.51239e-13 PD=3.78e-06 PS=4.37639e-06 $X=13440 $Y=2410 $dt=5
.ends DLY8_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX3                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX3 vdd5! gnd! A Q
** N=5 EP=4 FDC=9
M0 5 A gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=3.88487e-13 AS=4.31e-13 PD=2.70778e-06 PS=2.76e-06 $X=620 $Y=660 $dt=2
M1 Q 5 gnd! gnd! ne5 L=5e-07 W=6.7e-07 AD=1.809e-13 AS=5.44687e-13 PD=1.21e-06 PS=3.48778e-06 $X=2320 $Y=880 $dt=2
M2 gnd! 5 Q gnd! ne5 L=5e-07 W=6.7e-07 AD=3.274e-13 AS=1.809e-13 PD=1.86e-06 PS=1.21e-06 $X=3360 $Y=880 $dt=2
M3 Q 5 gnd! gnd! ne5 L=5e-07 W=6.7e-07 AD=3.216e-13 AS=3.274e-13 PD=2.3e-06 PS=1.86e-06 $X=4480 $Y=880 $dt=2
M4 5 A vdd5! vdd5! pe5 L=5.00179e-07 W=1.12899e-06 AD=2.543e-13 AS=8.002e-13 PD=1.59899e-06 PS=4.51899e-06 $X=590 $Y=2410 $dt=5
M5 vdd5! A 5 vdd5! pe5 L=5.00179e-07 W=1.12899e-06 AD=3.61857e-13 AS=2.543e-13 PD=2.05076e-06 PS=1.59899e-06 $X=1630 $Y=2410 $dt=5
M6 Q 5 vdd5! vdd5! pe5 L=5.0016e-07 W=1.44314e-06 AD=3.111e-13 AS=4.62543e-13 PD=1.90314e-06 PS=2.62138e-06 $X=2560 $Y=2410 $dt=5
M7 vdd5! 5 Q vdd5! pe5 L=5.0016e-07 W=1.44314e-06 AD=3.2325e-13 AS=3.111e-13 PD=1.91814e-06 PS=1.90314e-06 $X=3600 $Y=2410 $dt=5
M8 Q 5 vdd5! vdd5! pe5 L=5.0016e-07 W=1.44314e-06 AD=6.072e-13 AS=3.2325e-13 PD=3.73314e-06 PS=1.91814e-06 $X=4480 $Y=2410 $dt=5
.ends BU_5VX3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY1_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY1_5VX1 vdd5! gnd! A Q
** N=7 EP=4 FDC=8
M0 gnd! A 5 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.0255e-13 AS=2.016e-13 PD=2.32e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 7 5 gnd! gnd! ne5 L=9.4e-07 W=4.2e-07 AD=2.016e-13 AS=5.0255e-13 PD=1.8e-06 PS=2.32e-06 $X=1930 $Y=1400 $dt=2
M2 gnd! 7 6 gnd! ne5 L=1.24e-06 W=4.2e-07 AD=2.08974e-13 AS=2.016e-13 PD=1.19267e-06 PS=1.8e-06 $X=3180 $Y=660 $dt=2
M3 Q 6 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.42826e-13 PD=2.74e-06 PS=2.52733e-06 $X=5040 $Y=660 $dt=2
M4 vdd5! A 5 vdd5! pe5 L=5e-07 W=6.7e-07 AD=4.493e-13 AS=3.216e-13 PD=2.59394e-06 PS=2.3e-06 $X=620 $Y=2680 $dt=5
M5 7 5 vdd5! vdd5! pe5 L=1.24e-06 W=4.2e-07 AD=2.00088e-13 AS=2.8165e-13 PD=1.76778e-06 PS=1.62606e-06 $X=1735 $Y=2680 $dt=5
M6 vdd5! 7 6 vdd5! pe5 L=9.4e-07 W=4.2e-07 AD=2.11652e-13 AS=2.00088e-13 PD=1.09246e-06 PS=1.76778e-06 $X=3480 $Y=3400 $dt=5
M7 Q 6 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=7.10548e-13 PD=3.78e-06 PS=3.66754e-06 $X=5040 $Y=2410 $dt=5
.ends DLY1_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX12                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX12 vdd5! gnd! A Q
** N=5 EP=4 FDC=31
M0 5 A gnd! gnd! ne5 L=5e-07 W=7.5e-07 AD=2.025e-13 AS=5.958e-13 PD=1.29e-06 PS=3.52e-06 $X=660 $Y=800 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=7.5e-07 AD=3.354e-13 AS=2.025e-13 PD=1.86e-06 PS=1.29e-06 $X=1700 $Y=800 $dt=2
M2 5 A gnd! gnd! ne5 L=5e-07 W=7.5e-07 AD=2.025e-13 AS=3.354e-13 PD=1.29e-06 PS=1.86e-06 $X=2820 $Y=800 $dt=2
M3 gnd! A 5 gnd! ne5 L=5e-07 W=7.5e-07 AD=6.454e-13 AS=2.025e-13 PD=3.6e-06 PS=1.29e-06 $X=3860 $Y=800 $dt=2
M4 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=4.224e-13 PD=1.86e-06 PS=2.72e-06 $X=6510 $Y=670 $dt=2
M5 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=7630 $Y=670 $dt=2
M6 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=8670 $Y=670 $dt=2
M7 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=9790 $Y=670 $dt=2
M8 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=10830 $Y=670 $dt=2
M9 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=11950 $Y=670 $dt=2
M10 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=12990 $Y=670 $dt=2
M11 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=14110 $Y=670 $dt=2
M12 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=6.398e-13 AS=2.376e-13 PD=3.57e-06 PS=1.42e-06 $X=15150 $Y=670 $dt=2
M13 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=5.83087e-13 PD=1.86506e-06 PS=3.71506e-06 $X=475 $Y=2410 $dt=5
M14 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1515 $Y=2410 $dt=5
M15 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2265 $Y=2410 $dt=5
M16 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=3305 $Y=2410 $dt=5
M17 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4055 $Y=2410 $dt=5
M18 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.09212e-13 AS=2.43675e-13 PD=1.90506e-06 PS=1.86506e-06 $X=5095 $Y=2410 $dt=5
M19 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=3.09212e-13 PD=1.86506e-06 PS=1.90506e-06 $X=5885 $Y=2410 $dt=5
M20 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.81263e-13 AS=2.46937e-13 PD=1.87506e-06 PS=1.86506e-06 $X=6925 $Y=2410 $dt=5
M21 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.03337e-13 AS=2.81263e-13 PD=1.94506e-06 PS=1.87506e-06 $X=7675 $Y=2410 $dt=5
M22 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.28912e-13 AS=3.03337e-13 PD=1.93506e-06 PS=1.94506e-06 $X=8795 $Y=2410 $dt=5
M23 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=3.28912e-13 PD=1.86506e-06 PS=1.93506e-06 $X=9615 $Y=2410 $dt=5
M24 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.75463e-13 AS=2.46937e-13 PD=2.37006e-06 PS=1.86506e-06 $X=10655 $Y=2410 $dt=5
M25 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=4.75463e-13 PD=1.86506e-06 PS=2.37006e-06 $X=11560 $Y=2410 $dt=5
M26 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.12988e-13 AS=2.46937e-13 PD=2.30006e-06 PS=1.86506e-06 $X=12600 $Y=2410 $dt=5
M27 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=4.12988e-13 PD=1.86506e-06 PS=2.30006e-06 $X=13435 $Y=2410 $dt=5
M28 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.09462e-13 AS=2.46937e-13 PD=2.29506e-06 PS=1.86506e-06 $X=14475 $Y=2410 $dt=5
M29 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=4.09462e-13 PD=1.86506e-06 PS=2.29506e-06 $X=15305 $Y=2410 $dt=5
M30 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=7.79062e-13 AS=2.46937e-13 PD=4.47506e-06 PS=1.86506e-06 $X=16345 $Y=2410 $dt=5
.ends BU_5VX12

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX3                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX3 vdd5! gnd! A Q
** N=4 EP=4 FDC=6
M0 Q A gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=1.782e-13 AS=5.672e-13 PD=1.2e-06 PS=3.52e-06 $X=640 $Y=890 $dt=2
M1 gnd! A Q gnd! ne5 L=5e-07 W=6.6e-07 AD=3.264e-13 AS=1.782e-13 PD=1.86e-06 PS=1.2e-06 $X=1680 $Y=890 $dt=2
M2 Q A gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=3.168e-13 AS=3.264e-13 PD=2.28e-06 PS=1.86e-06 $X=2800 $Y=890 $dt=2
M3 Q A vdd5! vdd5! pe5 L=5.0002e-07 W=1.41414e-06 AD=3.7165e-13 AS=8.9065e-13 PD=1.94414e-06 PS=4.57414e-06 $X=660 $Y=2410 $dt=5
M4 vdd5! A Q vdd5! pe5 L=5.0002e-07 W=1.41414e-06 AD=5.0345e-13 AS=3.7165e-13 PD=2.37414e-06 PS=1.94414e-06 $X=1700 $Y=2410 $dt=5
M5 Q A vdd5! vdd5! pe5 L=5.0002e-07 W=1.41414e-06 AD=6.6775e-13 AS=5.0345e-13 PD=3.77414e-06 PS=2.37414e-06 $X=2800 $Y=2410 $dt=5
.ends IN_5VX3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX1 vdd5! gnd! A Q
** N=4 EP=4 FDC=2
M0 Q A gnd! gnd! ne5 L=5e-07 W=5e-07 AD=2.4e-13 AS=4.89238e-13 PD=1.96e-06 PS=3.48778e-06 $X=560 $Y=1050 $dt=2
M1 Q A vdd5! vdd5! pe5 L=5.00205e-07 W=1.41142e-06 AD=5.716e-13 AS=8.042e-13 PD=3.64142e-06 PS=4.50142e-06 $X=560 $Y=2410 $dt=5
.ends IN_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX2 vdd5! gnd! A Q
** N=4 EP=4 FDC=4
M0 Q A gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=1.782e-13 AS=3.272e-13 PD=1.2e-06 PS=2.32e-06 $X=630 $Y=660 $dt=2
M1 gnd! A Q gnd! ne5 L=5e-07 W=6.6e-07 AD=3.272e-13 AS=1.782e-13 PD=2.32e-06 PS=1.2e-06 $X=1670 $Y=660 $dt=2
M2 Q A vdd5! vdd5! pe5 L=5.00061e-07 W=1.42243e-06 AD=3.5235e-13 AS=8.5995e-13 PD=1.93243e-06 PS=4.54243e-06 $X=630 $Y=2410 $dt=5
M3 vdd5! A Q vdd5! pe5 L=5.00061e-07 W=1.42243e-06 AD=8.5995e-13 AS=3.5235e-13 PD=4.54243e-06 PS=1.93243e-06 $X=1670 $Y=2410 $dt=5
.ends IN_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO2_5VX1 vdd5! gnd! B A Q
** N=9 EP=5 FDC=10
M0 6 B gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.628e-13 PD=9.6e-07 PS=3.52e-06 $X=660 $Y=1130 $dt=2
M1 gnd! A 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.30196e-13 AS=1.134e-13 PD=1.36723e-06 PS=9.6e-07 $X=1700 $Y=1130 $dt=2
M2 7 B gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=6.5e-14 AS=2.85004e-13 PD=7.7e-07 PS=1.69277e-06 $X=3210 $Y=1030 $dt=2
M3 Q A 7 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=3960 $Y=1030 $dt=2
M4 gnd! 6 Q gnd! ne5 L=5e-07 W=5.2e-07 AD=5.728e-13 AS=1.404e-13 PD=3.52e-06 PS=1.06e-06 $X=5000 $Y=1030 $dt=2
M5 9 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=6.806e-13 PD=1.66e-06 PS=3.8e-06 $X=620 $Y=2410 $dt=5
M6 6 A 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.184e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=1370 $Y=2410 $dt=5
M7 vdd5! B 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.8775e-13 AS=5.648e-13 PD=1.96e-06 PS=3.78e-06 $X=2950 $Y=2410 $dt=5
M8 8 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=3.8775e-13 PD=1.95e-06 PS=1.96e-06 $X=4000 $Y=2410 $dt=5
M9 Q 6 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=5040 $Y=2410 $dt=5
.ends EO2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HA_5VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HA_5VX1 vdd5! gnd! S B A CO
** N=11 EP=6 FDC=14
M0 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=5.106e-13 AS=4.272e-13 PD=3.42627e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 gnd! A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.52e-13 PD=1.43e-06 PS=2.74e-06 $X=2240 $Y=660 $dt=2
M2 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.70969e-13 AS=2.403e-13 PD=1.71986e-06 PS=1.43e-06 $X=3280 $Y=660 $dt=2
M3 8 9 7 gnd! ne5 L=5e-07 W=5.9e-07 AD=3.632e-13 AS=1.79631e-13 PD=2.84284e-06 PS=1.14014e-06 $X=4320 $Y=960 $dt=2
M4 gnd! 9 CO gnd! ne5 L=5e-07 W=5.5e-07 AD=1.73288e-13 AS=2.4195e-13 PD=1.13056e-06 PS=2.03071e-06 $X=6000 $Y=1000 $dt=2
M5 10 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.80412e-13 PD=1.14e-06 PS=1.82944e-06 $X=7090 $Y=660 $dt=2
M6 9 A 10 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=7840 $Y=660 $dt=2
M7 vdd5! 8 S vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.72583e-13 AS=6.768e-13 PD=2.91809e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M8 11 A vdd5! vdd5! pe5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=3.61417e-13 PD=1.14e-06 PS=1.84191e-06 $X=1740 $Y=2630 $dt=5
M9 8 B 11 vdd5! pe5 L=5e-07 W=8.9e-07 AD=3.95525e-13 AS=1.1125e-13 PD=1.895e-06 PS=1.14e-06 $X=2490 $Y=2630 $dt=5
M10 vdd5! 9 8 vdd5! pe5 L=5e-07 W=8.9e-07 AD=5.93e-13 AS=3.95525e-13 PD=3.44e-06 PS=1.895e-06 $X=3775 $Y=2630 $dt=5
M11 vdd5! 9 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=4.092e-13 AS=5.328e-13 PD=2.04e-06 PS=3.18e-06 $X=5580 $Y=2410 $dt=5
M12 9 B vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=4.092e-13 PD=1.65e-06 PS=2.04e-06 $X=6700 $Y=2410 $dt=5
M13 vdd5! A 9 vdd5! pe5 L=5e-07 W=1.11e-06 AD=9.558e-13 AS=2.997e-13 PD=4.68e-06 PS=1.65e-06 $X=7740 $Y=2410 $dt=5
.ends HA_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO3_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO3_5VX1 vdd5! gnd! C B A Q
** N=15 EP=6 FDC=20
M0 7 C gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.628e-13 PD=9.6e-07 PS=3.52e-06 $X=660 $Y=1130 $dt=2
M1 gnd! B 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.30196e-13 AS=1.134e-13 PD=1.36723e-06 PS=9.6e-07 $X=1700 $Y=1130 $dt=2
M2 9 C gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=6.5e-14 AS=2.85004e-13 PD=7.7e-07 PS=1.69277e-06 $X=3210 $Y=1030 $dt=2
M3 11 B 9 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=3960 $Y=1030 $dt=2
M4 gnd! 7 11 gnd! ne5 L=5e-07 W=5.2e-07 AD=8.05779e-13 AS=1.404e-13 PD=2.83787e-06 PS=1.06e-06 $X=5000 $Y=1030 $dt=2
M5 8 11 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=6.50821e-13 PD=9.6e-07 PS=2.29213e-06 $X=6825 $Y=1130 $dt=2
M6 gnd! A 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.60128e-13 AS=1.134e-13 PD=1.68894e-06 PS=9.6e-07 $X=7865 $Y=1130 $dt=2
M7 10 A gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=6.5e-14 AS=4.45872e-13 PD=7.7e-07 PS=2.09106e-06 $X=9365 $Y=1030 $dt=2
M8 Q 11 10 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=10115 $Y=1030 $dt=2
M9 gnd! 8 Q gnd! ne5 L=5e-07 W=5.2e-07 AD=5.728e-13 AS=1.404e-13 PD=3.52e-06 PS=1.06e-06 $X=11155 $Y=1030 $dt=2
M10 14 C vdd5! vdd5! pe5 L=5e-07 W=1.3e-06 AD=1.625e-13 AS=6.278e-13 PD=1.55e-06 PS=3.58e-06 $X=620 $Y=2520 $dt=5
M11 7 B 14 vdd5! pe5 L=5e-07 W=1.3e-06 AD=4.832e-13 AS=1.625e-13 PD=3.56e-06 PS=1.55e-06 $X=1370 $Y=2520 $dt=5
M12 vdd5! C 12 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.8775e-13 AS=5.512e-13 PD=1.96e-06 PS=3.78e-06 $X=2950 $Y=2410 $dt=5
M13 12 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=3.8775e-13 PD=1.95e-06 PS=1.96e-06 $X=4000 $Y=2410 $dt=5
M14 11 7 12 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.7445e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=5040 $Y=2410 $dt=5
M15 15 11 vdd5! vdd5! pe5 L=5e-07 W=1.3e-06 AD=1.625e-13 AS=7.7835e-13 PD=1.55e-06 PS=4.56e-06 $X=6705 $Y=2410 $dt=5
M16 8 A 15 vdd5! pe5 L=5e-07 W=1.3e-06 AD=4.832e-13 AS=1.625e-13 PD=3.56e-06 PS=1.55e-06 $X=7455 $Y=2410 $dt=5
M17 vdd5! A 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.106e-13 AS=5.512e-13 PD=2.38e-06 PS=3.78e-06 $X=9035 $Y=2410 $dt=5
M18 13 11 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.84225e-13 AS=5.106e-13 PD=1.955e-06 PS=2.38e-06 $X=10155 $Y=2410 $dt=5
M19 Q 8 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=3.84225e-13 PD=3.78e-06 PS=1.955e-06 $X=11200 $Y=2410 $dt=5
.ends EO3_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: FA_5VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt FA_5VX1 vdd5! gnd! S CI B A CO
** N=19 EP=7 FDC=28
M0 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=5.874e-13 AS=4.272e-13 PD=3.49657e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 9 CI 8 gnd! ne5 L=5e-07 W=5.9e-07 AD=7.375e-14 AS=2.764e-13 PD=8.4e-07 PS=2.14e-06 $X=2360 $Y=960 $dt=2
M2 10 B 9 gnd! ne5 L=5e-07 W=5.9e-07 AD=7.375e-14 AS=7.375e-14 PD=8.4e-07 PS=8.4e-07 $X=3110 $Y=960 $dt=2
M3 gnd! A 10 gnd! ne5 L=5e-07 W=5.9e-07 AD=2.34033e-13 AS=7.375e-14 PD=1.52158e-06 PS=8.4e-07 $X=3860 $Y=960 $dt=2
M4 12 CI gnd! gnd! ne5 L=5e-07 W=5.5e-07 AD=1.485e-13 AS=2.18167e-13 PD=1.09e-06 PS=1.41842e-06 $X=4940 $Y=660 $dt=2
M5 gnd! A 12 gnd! ne5 L=5e-07 W=5.5e-07 AD=2.5017e-13 AS=1.485e-13 PD=1.58058e-06 PS=1.09e-06 $X=5980 $Y=660 $dt=2
M6 12 B gnd! gnd! ne5 L=5e-07 W=4.8e-07 AD=1.296e-13 AS=2.1833e-13 PD=1.02e-06 PS=1.37942e-06 $X=7110 $Y=960 $dt=2
M7 8 13 12 gnd! ne5 L=5e-07 W=4.8e-07 AD=2.304e-13 AS=1.296e-13 PD=1.92e-06 PS=1.02e-06 $X=8150 $Y=960 $dt=2
M8 gnd! 13 CO gnd! ne5 L=5e-07 W=5.9e-07 AD=2.7435e-13 AS=2.832e-13 PD=1.52e-06 PS=2.14e-06 $X=9890 $Y=960 $dt=2
M9 11 A gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=7.375e-14 AS=2.7435e-13 PD=8.4e-07 PS=1.52e-06 $X=11320 $Y=960 $dt=2
M10 13 B 11 gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=7.375e-14 PD=1.13e-06 PS=8.4e-07 $X=12070 $Y=960 $dt=2
M11 14 CI 13 gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=13110 $Y=960 $dt=2
M12 gnd! B 14 gnd! ne5 L=5e-07 W=5.9e-07 AD=4.382e-13 AS=1.593e-13 PD=1.95e-06 PS=1.13e-06 $X=14150 $Y=960 $dt=2
M13 14 A gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=3.068e-13 AS=4.382e-13 PD=2.22e-06 PS=1.95e-06 $X=15640 $Y=960 $dt=2
M14 vdd5! 8 S vdd5! pe5 L=5e-07 W=1.41e-06 AD=7.178e-13 AS=6.768e-13 PD=4.46627e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M15 vdd5! CI 15 vdd5! pe5 L=5e-07 W=1.035e-06 AD=4.57154e-13 AS=4.55288e-13 PD=2.30557e-06 PS=2.99778e-06 $X=2240 $Y=2490 $dt=5
M16 15 B vdd5! vdd5! pe5 L=5e-07 W=1.03e-06 AD=2.781e-13 AS=4.54946e-13 PD=1.57e-06 PS=2.29443e-06 $X=3360 $Y=2490 $dt=5
M17 vdd5! A 15 vdd5! pe5 L=5e-07 W=1.03e-06 AD=3.844e-13 AS=2.781e-13 PD=1.96e-06 PS=1.57e-06 $X=4400 $Y=2490 $dt=5
M18 17 A vdd5! vdd5! pe5 L=5e-07 W=1.03e-06 AD=1.2875e-13 AS=3.844e-13 PD=1.28e-06 PS=1.96e-06 $X=5520 $Y=2490 $dt=5
M19 16 B 17 vdd5! pe5 L=5e-07 W=1.03e-06 AD=1.2875e-13 AS=1.2875e-13 PD=1.28e-06 PS=1.28e-06 $X=6270 $Y=2490 $dt=5
M20 8 CI 16 vdd5! pe5 L=5e-07 W=1.03e-06 AD=2.781e-13 AS=1.2875e-13 PD=1.57e-06 PS=1.28e-06 $X=7020 $Y=2490 $dt=5
M21 15 13 8 vdd5! pe5 L=5e-07 W=1.03e-06 AD=5.646e-13 AS=2.781e-13 PD=3.72e-06 PS=1.57e-06 $X=8060 $Y=2490 $dt=5
M22 vdd5! 13 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=5.6536e-13 AS=4.245e-13 PD=2.405e-06 PS=3.19e-06 $X=9735 $Y=2410 $dt=5
M23 18 A vdd5! vdd5! pe5 L=5e-07 W=9.9e-07 AD=2.673e-13 AS=5.0424e-13 PD=1.53e-06 PS=2.145e-06 $X=11030 $Y=2530 $dt=5
M24 vdd5! B 18 vdd5! pe5 L=5e-07 W=9.9e-07 AD=6.282e-13 AS=2.673e-13 PD=3.56e-06 PS=1.53e-06 $X=12070 $Y=2530 $dt=5
M25 13 CI 18 vdd5! pe5 L=5e-07 W=1e-06 AD=2.7e-13 AS=4.8e-13 PD=1.54e-06 PS=2.96e-06 $X=13850 $Y=2520 $dt=5
M26 19 B 13 vdd5! pe5 L=5e-07 W=1e-06 AD=1.25e-13 AS=2.7e-13 PD=1.25e-06 PS=1.54e-06 $X=14890 $Y=2520 $dt=5
M27 vdd5! A 19 vdd5! pe5 L=5e-07 W=1e-06 AD=7.93e-13 AS=1.25e-13 PD=4.34e-06 PS=1.25e-06 $X=15640 $Y=2520 $dt=5
.ends FA_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: CAG_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt CAG_5VX1 vdd5! gnd! CO A B CI
** N=11 EP=6 FDC=12
M0 gnd! 8 CO gnd! ne5 L=5e-07 W=8.9e-07 AD=3.18769e-13 AS=4.272e-13 PD=1.9974e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 7 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.50431e-13 PD=6.7e-07 PS=9.42595e-07 $X=1700 $Y=1130 $dt=2
M2 8 B 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=2450 $Y=1130 $dt=2
M3 9 CI 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=3490 $Y=1130 $dt=2
M4 gnd! B 9 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=4530 $Y=1130 $dt=2
M5 9 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=1.134e-13 PD=1.8e-06 PS=9.6e-07 $X=5570 $Y=1130 $dt=2
M6 vdd5! 8 CO vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.08946e-13 AS=6.768e-13 PD=3.18841e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M7 10 A vdd5! vdd5! pe5 L=5e-07 W=6.95e-07 AD=8.6875e-14 AS=3.00154e-13 PD=9.45e-07 PS=1.57159e-06 $X=1700 $Y=2410 $dt=5
M8 8 B 10 vdd5! pe5 L=5e-07 W=6.95e-07 AD=1.8765e-13 AS=8.6875e-14 PD=1.235e-06 PS=9.45e-07 $X=2450 $Y=2410 $dt=5
M9 11 CI 8 vdd5! pe5 L=5e-07 W=6.95e-07 AD=1.8765e-13 AS=1.8765e-13 PD=1.235e-06 PS=1.235e-06 $X=3490 $Y=2410 $dt=5
M10 vdd5! B 11 vdd5! pe5 L=5e-07 W=6.95e-07 AD=3.9473e-13 AS=1.8765e-13 PD=2.37147e-06 PS=1.235e-06 $X=4530 $Y=2410 $dt=5
M11 11 A vdd5! vdd5! pe5 L=5e-07 W=7e-07 AD=3.36e-13 AS=3.9757e-13 PD=2.36e-06 PS=2.38853e-06 $X=5570 $Y=2410 $dt=5
.ends CAG_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN22_5VX1 vdd5! gnd! B A Q C D
** N=10 EP=7 FDC=8
M0 8 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.16e-13 PD=1.14e-06 PS=3.53e-06 $X=665 $Y=660 $dt=2
M1 Q A 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=1.1125e-13 PD=1.43e-06 PS=1.14e-06 $X=1415 $Y=660 $dt=2
M2 9 C Q gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.403e-13 PD=1.14e-06 PS=1.43e-06 $X=2455 $Y=660 $dt=2
M3 gnd! D 9 gnd! ne5 L=5e-07 W=8.9e-07 AD=7.524e-13 AS=1.1125e-13 PD=3.75e-06 PS=1.14e-06 $X=3205 $Y=660 $dt=2
M4 vdd5! B 10 vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=3.121e-13 AS=5.48887e-13 PD=1.92092e-06 PS=3.70092e-06 $X=620 $Y=2410 $dt=5
M5 10 A vdd5! vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=3.49987e-13 AS=3.121e-13 PD=2.00592e-06 PS=1.92092e-06 $X=1415 $Y=2410 $dt=5
M6 Q C 10 vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=2.85863e-13 AS=3.49987e-13 PD=1.87092e-06 PS=2.00592e-06 $X=2455 $Y=2410 $dt=5
M7 10 D Q vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=5.58638e-13 AS=2.85863e-13 PD=3.73092e-06 PS=1.87092e-06 $X=3495 $Y=2410 $dt=5
.ends AN22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OA21_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OA21_5VX1 vdd5! gnd! C A B Q
** N=9 EP=6 FDC=8
M0 7 C 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.922e-13 AS=2.016e-13 PD=1.89333e-06 PS=1.8e-06 $X=620 $Y=660 $dt=2
M1 gnd! A 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=2.922e-13 PD=1.8e-06 PS=1.89333e-06 $X=1700 $Y=1360 $dt=2
M2 gnd! B 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.4873e-13 AS=2.922e-13 PD=1.25679e-06 PS=1.89333e-06 $X=2700 $Y=1130 $dt=2
M3 Q 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=5.2707e-13 PD=2.74e-06 PS=2.66321e-06 $X=3920 $Y=660 $dt=2
M4 8 C vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=1.944e-13 AS=8.982e-13 PD=1.26e-06 PS=4.34e-06 $X=780 $Y=2640 $dt=5
M5 9 A 8 vdd5! pe5 L=5e-07 W=7.2e-07 AD=9e-14 AS=1.944e-13 PD=9.7e-07 PS=1.26e-06 $X=1820 $Y=2640 $dt=5
M6 vdd5! B 9 vdd5! pe5 L=5e-07 W=7.2e-07 AD=4.43932e-13 AS=9e-14 PD=1.76451e-06 PS=9.7e-07 $X=2570 $Y=2640 $dt=5
M7 Q 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=8.69368e-13 PD=3.78e-06 PS=3.45549e-06 $X=3920 $Y=2410 $dt=5
.ends OA21_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EN3_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EN3_5VX1 vdd5! gnd! C B A Q
** N=15 EP=6 FDC=20
M0 10 C gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=2.016e-13 PD=9.6e-07 PS=1.8e-06 $X=620 $Y=1030 $dt=2
M1 gnd! B 10 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.39489e-13 AS=1.134e-13 PD=1.40298e-06 PS=9.6e-07 $X=1660 $Y=1030 $dt=2
M2 11 C gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=6.5e-14 AS=2.96511e-13 PD=7.7e-07 PS=1.73702e-06 $X=3210 $Y=930 $dt=2
M3 7 B 11 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.45812e-13 AS=6.5e-14 PD=1.1249e-06 PS=7.7e-07 $X=3960 $Y=930 $dt=2
M4 gnd! 10 7 gnd! ne5 L=5e-07 W=4.6e-07 AD=5.248e-13 AS=1.28988e-13 PD=3.32e-06 PS=9.95102e-07 $X=5000 $Y=990 $dt=2
M5 12 7 9 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=6780 $Y=970 $dt=2
M6 gnd! A 12 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=7530 $Y=970 $dt=2
M7 8 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=8570 $Y=970 $dt=2
M8 gnd! 7 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.965e-13 AS=1.134e-13 PD=3.17071e-06 PS=9.6e-07 $X=9610 $Y=970 $dt=2
M9 Q 9 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=2.0035e-13 PD=1.8e-06 PS=1.77071e-06 $X=11200 $Y=1130 $dt=2
M10 14 C vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=6.806e-13 PD=1.66e-06 PS=3.8e-06 $X=620 $Y=2410 $dt=5
M11 10 B 14 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.184e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=1370 $Y=2410 $dt=5
M12 vdd5! C 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.8775e-13 AS=5.512e-13 PD=1.96e-06 PS=3.78e-06 $X=2950 $Y=2410 $dt=5
M13 13 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=3.8775e-13 PD=1.95e-06 PS=1.96e-06 $X=4000 $Y=2410 $dt=5
M14 7 10 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=5040 $Y=2410 $dt=5
M15 9 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=8.802e-13 PD=1.95e-06 PS=4.56e-06 $X=6820 $Y=2410 $dt=5
M16 vdd5! A 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=8.45e-13 AS=3.807e-13 PD=2.76e-06 PS=1.95e-06 $X=7860 $Y=2410 $dt=5
M17 15 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=8.45e-13 PD=1.66e-06 PS=2.76e-06 $X=9360 $Y=2410 $dt=5
M18 Q 7 15 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.36471e-13 AS=1.7625e-13 PD=2.34701e-06 PS=1.66e-06 $X=10110 $Y=2410 $dt=5
M19 vdd5! 9 Q vdd5! pe5 L=5e-07 W=9.45e-07 AD=8.337e-13 AS=2.92529e-13 PD=4.56e-06 PS=1.57299e-06 $X=11160 $Y=2410 $dt=5
.ends EN3_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND2_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND2_5VX1 vdd5! gnd! A B Q
** N=7 EP=5 FDC=6
M0 7 A 6 gnd! ne5 L=5e-07 W=5.8e-07 AD=7.25e-14 AS=2.784e-13 PD=8.3e-07 PS=2.12e-06 $X=930 $Y=970 $dt=2
M1 gnd! B 7 gnd! ne5 L=5e-07 W=5.8e-07 AD=2.63486e-13 AS=7.25e-14 PD=1.46776e-06 PS=8.3e-07 $X=1680 $Y=970 $dt=2
M2 Q 6 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.04314e-13 PD=2.74e-06 PS=2.25224e-06 $X=2800 $Y=660 $dt=2
M3 6 A vdd5! vdd5! pe5 L=5e-07 W=7e-07 AD=1.89e-13 AS=7.888e-13 PD=1.24e-06 PS=4.56e-06 $X=640 $Y=2410 $dt=5
M4 vdd5! B 6 vdd5! pe5 L=5e-07 W=7e-07 AD=3.15232e-13 AS=1.89e-13 PD=1.57915e-06 PS=1.24e-06 $X=1680 $Y=2410 $dt=5
M5 Q 6 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=6.34968e-13 PD=3.78e-06 PS=3.18085e-06 $X=2800 $Y=2410 $dt=5
.ends AND2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2I1_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2I1_5VX1 vdd5! gnd! AN B Q
** N=7 EP=5 FDC=6
M0 gnd! AN 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.06701e-13 AS=2.016e-13 PD=1.18704e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 Q B gnd! gnd! ne5 L=4.99026e-07 W=8.94142e-07 AD=2.3525e-13 AS=4.40049e-13 PD=1.42414e-06 PS=2.5271e-06 $X=1740 $Y=660 $dt=2
M2 gnd! 6 Q gnd! ne5 L=4.99026e-07 W=8.94142e-07 AD=6.0475e-13 AS=2.3525e-13 PD=3.51414e-06 PS=1.42414e-06 $X=2760 $Y=660 $dt=2
M3 vdd5! AN 6 vdd5! pe5 L=5e-07 W=7.2e-07 AD=4.88451e-13 AS=3.456e-13 PD=1.79831e-06 PS=2.4e-06 $X=620 $Y=2570 $dt=5
M4 7 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=9.56549e-13 PD=1.66e-06 PS=3.52169e-06 $X=2020 $Y=2410 $dt=5
M5 Q 6 7 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=2770 $Y=2410 $dt=5
.ends NO2I1_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EN2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EN2_5VX1 vdd5! gnd! A B Q
** N=9 EP=5 FDC=10
M0 8 A 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=620 $Y=970 $dt=2
M1 gnd! B 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=1370 $Y=970 $dt=2
M2 6 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=2410 $Y=970 $dt=2
M3 gnd! B 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.7275e-13 AS=1.134e-13 PD=3.17071e-06 PS=9.6e-07 $X=3450 $Y=970 $dt=2
M4 Q 7 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=2.0035e-13 PD=1.8e-06 PS=1.77071e-06 $X=5040 $Y=970 $dt=2
M5 7 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=8.802e-13 PD=1.95e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M6 vdd5! B 7 vdd5! pe5 L=5e-07 W=1.41e-06 AD=8.45e-13 AS=3.807e-13 PD=2.76e-06 PS=1.95e-06 $X=1700 $Y=2410 $dt=5
M7 9 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=8.45e-13 PD=1.66e-06 PS=2.76e-06 $X=3200 $Y=2410 $dt=5
M8 Q B 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.36471e-13 AS=1.7625e-13 PD=2.34701e-06 PS=1.66e-06 $X=3950 $Y=2410 $dt=5
M9 vdd5! 7 Q vdd5! pe5 L=5e-07 W=9.45e-07 AD=8.337e-13 AS=2.92529e-13 PD=4.56e-06 PS=1.57299e-06 $X=5000 $Y=2410 $dt=5
.ends EN2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2_5VX1 vdd5! gnd! B Q A
** N=6 EP=5 FDC=4
M0 6 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=9.322e-13 PD=1.14e-06 PS=4.04e-06 $X=920 $Y=660 $dt=2
M1 Q A 6 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=1670 $Y=660 $dt=2
M2 Q B vdd5! vdd5! pe5 L=5.00105e-07 W=1.10157e-06 AD=2.6775e-13 AS=8.387e-13 PD=1.60157e-06 PS=4.55657e-06 $X=630 $Y=2410 $dt=5
M3 vdd5! A Q vdd5! pe5 L=5.00105e-07 W=1.10157e-06 AD=8.387e-13 AS=2.6775e-13 PD=4.55657e-06 PS=1.60157e-06 $X=1670 $Y=2410 $dt=5
.ends NA2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AO21_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AO21_5VX1 vdd5! gnd! C A B Q
** N=9 EP=6 FDC=8
M0 7 C gnd! gnd! ne5 L=5e-07 W=4.6e-07 AD=1.242e-13 AS=3.862e-13 PD=1e-06 PS=2.66e-06 $X=660 $Y=660 $dt=2
M1 8 A 7 gnd! ne5 L=5e-07 W=4.6e-07 AD=1.38e-13 AS=1.242e-13 PD=1.06e-06 PS=1e-06 $X=1700 $Y=660 $dt=2
M2 gnd! B 8 gnd! ne5 L=5e-07 W=4.6e-07 AD=2.06557e-13 AS=1.38e-13 PD=1.26756e-06 PS=1.06e-06 $X=2800 $Y=660 $dt=2
M3 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=3.99643e-13 PD=2.74e-06 PS=2.45244e-06 $X=3920 $Y=660 $dt=2
M4 9 C 7 vdd5! pe5 L=5e-07 W=7.8e-07 AD=4.715e-13 AS=3.744e-13 PD=2.43219e-06 PS=2.52e-06 $X=620 $Y=2410 $dt=5
M5 9 A vdd5! vdd5! pe5 L=5e-07 W=7.8e-07 AD=4.715e-13 AS=3.744e-13 PD=2.43219e-06 PS=2.52e-06 $X=1700 $Y=1980 $dt=5
M6 vdd5! B 9 vdd5! pe5 L=5e-07 W=7.8e-07 AD=3.41277e-13 AS=4.715e-13 PD=1.69534e-06 PS=2.43219e-06 $X=2800 $Y=3040 $dt=5
M7 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=6.16923e-13 PD=3.78e-06 PS=3.06466e-06 $X=3920 $Y=2410 $dt=5
.ends AO21_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR2_5VX1 vdd5! gnd! A B Q
** N=7 EP=5 FDC=6
M0 6 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.486e-13 PD=9.6e-07 PS=3.50828e-06 $X=640 $Y=1130 $dt=2
M1 gnd! B 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.08974e-13 AS=1.134e-13 PD=1.19267e-06 PS=9.6e-07 $X=1680 $Y=1130 $dt=2
M2 Q 6 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.42826e-13 PD=2.74e-06 PS=2.52733e-06 $X=2800 $Y=660 $dt=2
M3 7 A 6 vdd5! pe5 L=5e-07 W=7.2e-07 AD=9e-14 AS=3.456e-13 PD=9.7e-07 PS=2.4e-06 $X=930 $Y=2410 $dt=5
M4 vdd5! B 7 vdd5! pe5 L=5e-07 W=7.2e-07 AD=3.2187e-13 AS=9e-14 PD=1.60901e-06 PS=9.7e-07 $X=1680 $Y=2410 $dt=5
M5 Q 6 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=6.3033e-13 PD=3.78e-06 PS=3.15099e-06 $X=2800 $Y=2410 $dt=5
.ends OR2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2_5VX1 vdd5! gnd! B Q A
** N=6 EP=5 FDC=4
M0 Q B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=4.4e-13 PD=1.43e-06 PS=2.78e-06 $X=630 $Y=660 $dt=2
M1 gnd! A Q gnd! ne5 L=5e-07 W=8.9e-07 AD=4.4e-13 AS=2.403e-13 PD=2.78e-06 PS=1.43e-06 $X=1670 $Y=660 $dt=2
M2 6 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.833e-13 AS=1.3202e-12 PD=1.67e-06 PS=5.06e-06 $X=910 $Y=2410 $dt=5
M3 Q A 6 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.833e-13 PD=3.78e-06 PS=1.67e-06 $X=1670 $Y=2410 $dt=5
.ends NO2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2I1_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2I1_5VX1 vdd5! gnd! AN B Q
** N=7 EP=5 FDC=6
M0 gnd! AN 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.2029e-13 AS=2.016e-13 PD=1.37221e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.7871e-13 PD=1.14e-06 PS=2.90779e-06 $X=2020 $Y=660 $dt=2
M2 Q 6 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=2770 $Y=660 $dt=2
M3 vdd5! AN 6 vdd5! pe5 L=5e-07 W=7.2e-07 AD=3.63434e-13 AS=3.456e-13 PD=1.89205e-06 PS=2.4e-06 $X=620 $Y=2550 $dt=5
M4 Q B vdd5! vdd5! pe5 L=5.00027e-07 W=1.08914e-06 AD=2.866e-13 AS=5.49766e-13 PD=1.61914e-06 PS=2.86209e-06 $X=1730 $Y=2410 $dt=5
M5 vdd5! 6 Q vdd5! pe5 L=5.00027e-07 W=1.08914e-06 AD=8.41e-13 AS=2.866e-13 PD=4.55414e-06 PS=1.61914e-06 $X=2770 $Y=2410 $dt=5
.ends NA2I1_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND4_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND4_5VX1 vdd5! gnd! A B C D Q
** N=11 EP=7 FDC=10
M0 9 A 8 gnd! ne5 L=5e-07 W=7e-07 AD=1.05e-13 AS=3.36e-13 PD=1e-06 PS=2.36e-06 $X=860 $Y=850 $dt=2
M1 10 B 9 gnd! ne5 L=5e-07 W=7e-07 AD=1.05e-13 AS=1.05e-13 PD=1e-06 PS=1e-06 $X=1660 $Y=850 $dt=2
M2 11 C 10 gnd! ne5 L=5e-07 W=7e-07 AD=1.05e-13 AS=1.05e-13 PD=1e-06 PS=1e-06 $X=2460 $Y=850 $dt=2
M3 gnd! D 11 gnd! ne5 L=5e-07 W=7e-07 AD=3.53874e-13 AS=1.05e-13 PD=1.72579e-06 PS=1e-06 $X=3260 $Y=850 $dt=2
M4 Q 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.49926e-13 PD=2.74e-06 PS=2.19421e-06 $X=4480 $Y=660 $dt=2
M5 8 A vdd5! vdd5! pe5 L=5e-07 W=7e-07 AD=1.89e-13 AS=5.584e-13 PD=1.24e-06 PS=4.24e-06 $X=480 $Y=2570 $dt=5
M6 vdd5! B 8 vdd5! pe5 L=5e-07 W=7e-07 AD=3.142e-13 AS=1.89e-13 PD=2.22e-06 PS=1.24e-06 $X=1520 $Y=2570 $dt=5
M7 8 C vdd5! vdd5! pe5 L=5e-07 W=7e-07 AD=1.89e-13 AS=3.142e-13 PD=1.24e-06 PS=2.22e-06 $X=2460 $Y=2570 $dt=5
M8 vdd5! D 8 vdd5! pe5 L=5e-07 W=7e-07 AD=2.60427e-13 AS=1.89e-13 PD=1.57915e-06 PS=1.24e-06 $X=3500 $Y=2570 $dt=5
M9 Q 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=5.24573e-13 PD=3.78e-06 PS=3.18085e-06 $X=4480 $Y=2410 $dt=5
.ends AND4_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON21_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON21_5VX1 vdd5! gnd! B A Q C
** N=8 EP=6 FDC=6
M0 gnd! B 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=3.494e-13 AS=4.272e-13 PD=1.86e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 7 A gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.42e-13 AS=3.494e-13 PD=1.44e-06 PS=1.86e-06 $X=1740 $Y=660 $dt=2
M2 Q C 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=2.42e-13 PD=2.74e-06 PS=1.44e-06 $X=2780 $Y=660 $dt=2
M3 8 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.1618e-12 PD=1.66e-06 PS=4.88e-06 $X=820 $Y=2410 $dt=5
M4 Q A 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.05757e-13 AS=1.7625e-13 PD=2.33503e-06 PS=1.66e-06 $X=1570 $Y=2410 $dt=5
M5 vdd5! C Q vdd5! pe5 L=5e-07 W=9.45e-07 AD=1.0977e-12 AS=2.71943e-13 PD=4.86e-06 PS=1.56497e-06 $X=2610 $Y=2410 $dt=5
.ends ON21_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO22_5VX1 vdd5! gnd! B A Q C
** N=9 EP=6 FDC=8
M0 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=2
M1 gnd! A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=3.62581e-13 AS=2.403e-13 PD=1.88269e-06 PS=1.43e-06 $X=1700 $Y=660 $dt=2
M2 Q 7 gnd! gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=2.396e-13 AS=3.64269e-13 PD=1.43414e-06 PS=1.89145e-06 $X=2850 $Y=660 $dt=2
M3 gnd! C Q gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=6.0415e-13 AS=2.396e-13 PD=3.51414e-06 PS=1.43414e-06 $X=3880 $Y=660 $dt=2
M4 8 B vdd5! vdd5! pe5 L=5.00111e-07 W=1.41828e-06 AD=1.773e-13 AS=8.785e-13 PD=1.66828e-06 PS=4.56828e-06 $X=650 $Y=2410 $dt=5
M5 7 A 8 vdd5! pe5 L=5.00111e-07 W=1.41828e-06 AD=6.572e-13 AS=1.773e-13 PD=3.76828e-06 PS=1.66828e-06 $X=1400 $Y=2410 $dt=5
M6 9 7 Q vdd5! pe5 L=5.00111e-07 W=1.41828e-06 AD=1.773e-13 AS=6.572e-13 PD=1.66828e-06 PS=3.76828e-06 $X=3140 $Y=2410 $dt=5
M7 vdd5! C 9 vdd5! pe5 L=5.00111e-07 W=1.41828e-06 AD=8.785e-13 AS=1.773e-13 PD=4.56828e-06 PS=1.66828e-06 $X=3890 $Y=2410 $dt=5
.ends NO22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN21_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN21_5VX1 vdd5! gnd! B A Q C
** N=8 EP=6 FDC=6
M0 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=7.896e-13 PD=1.14e-06 PS=3.81e-06 $X=805 $Y=660 $dt=2
M1 Q A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.69238e-13 AS=1.1125e-13 PD=1.56683e-06 PS=1.14e-06 $X=1555 $Y=660 $dt=2
M2 gnd! C Q gnd! ne5 L=5e-07 W=7.8e-07 AD=7.538e-13 AS=2.35962e-13 PD=3.77e-06 PS=1.37317e-06 $X=2635 $Y=770 $dt=2
M3 vdd5! B 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.282e-13 AS=6.768e-13 PD=2.4e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M4 8 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.282e-13 PD=1.95e-06 PS=2.4e-06 $X=1760 $Y=2410 $dt=5
M5 Q C 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=2800 $Y=2410 $dt=5
.ends AN21_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON211_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON211_5VX1 vdd5! gnd! B Q A C D
** N=10 EP=7 FDC=8
M0 Q B 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=4.272e-13 PD=1.43e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 8 A Q gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=1660 $Y=660 $dt=2
M2 9 C 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.403e-13 PD=1.14e-06 PS=1.43e-06 $X=2700 $Y=660 $dt=2
M3 gnd! D 9 gnd! ne5 L=5e-07 W=8.9e-07 AD=6.098e-13 AS=1.1125e-13 PD=3.52e-06 PS=1.14e-06 $X=3450 $Y=660 $dt=2
M4 10 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=6.825e-13 PD=1.66e-06 PS=3.81e-06 $X=620 $Y=2410 $dt=5
M5 Q A 10 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.01334e-13 AS=1.7625e-13 PD=2.23537e-06 PS=1.66e-06 $X=1370 $Y=2410 $dt=5
M6 vdd5! C Q vdd5! pe5 L=5e-07 W=1.05e-06 AD=2.852e-13 AS=2.98866e-13 PD=1.6e-06 PS=1.66463e-06 $X=2410 $Y=2770 $dt=5
M7 Q D vdd5! vdd5! pe5 L=5e-07 W=1.05e-06 AD=5.04e-13 AS=2.852e-13 PD=3.06e-06 PS=1.6e-06 $X=3450 $Y=2770 $dt=5
.ends ON211_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3I2_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3I2_5VX1 vdd5! gnd! AN BN C Q
** N=9 EP=6 FDC=8
M0 8 AN 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 gnd! BN 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.73707e-13 AS=5.25e-14 PD=1.2044e-06 PS=6.7e-07 $X=1370 $Y=1130 $dt=2
M2 Q C gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.68093e-13 PD=1.43e-06 PS=2.55217e-06 $X=2320 $Y=660 $dt=2
M3 gnd! 7 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=4.31e-13 AS=2.403e-13 PD=2.76e-06 PS=1.43e-06 $X=3360 $Y=660 $dt=2
M4 7 AN vdd5! vdd5! pe5 L=5e-07 W=6.7e-07 AD=1.809e-13 AS=4.9714e-13 PD=1.21e-06 PS=2.64102e-06 $X=490 $Y=2740 $dt=5
M5 7 BN vdd5! vdd5! pe5 L=5e-07 W=6.7e-07 AD=1.809e-13 AS=4.9714e-13 PD=1.21e-06 PS=2.64102e-06 $X=1530 $Y=2740 $dt=5
M6 9 C vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.04622e-12 PD=1.66e-06 PS=5.55796e-06 $X=2610 $Y=2410 $dt=5
M7 Q 7 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=3360 $Y=2410 $dt=5
.ends NO3I2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EN2_5VX0                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EN2_5VX0 vdd5! gnd! A B Q
** N=9 EP=5 FDC=10
M0 7 A 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=620 $Y=980 $dt=2
M1 gnd! B 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=1370 $Y=980 $dt=2
M2 8 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=2410 $Y=980 $dt=2
M3 gnd! B 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.698e-13 AS=1.134e-13 PD=3.22e-06 PS=9.6e-07 $X=3450 $Y=980 $dt=2
M4 Q 6 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=2.058e-13 PD=1.8e-06 PS=1.82e-06 $X=5040 $Y=1020 $dt=2
M5 6 A vdd5! vdd5! pe5 L=5e-07 W=9e-07 AD=2.43e-13 AS=8.292e-13 PD=1.44e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M6 vdd5! B 6 vdd5! pe5 L=5e-07 W=9e-07 AD=5.57223e-13 AS=2.43e-13 PD=1.98e-06 PS=1.44e-06 $X=1700 $Y=2410 $dt=5
M7 9 A vdd5! vdd5! pe5 L=5e-07 W=1.3e-06 AD=1.625e-13 AS=8.04877e-13 PD=1.55e-06 PS=2.86e-06 $X=3210 $Y=2520 $dt=5
M8 Q B 9 vdd5! pe5 L=5e-07 W=1.3e-06 AD=3.94793e-13 AS=1.625e-13 PD=2.20461e-06 PS=1.55e-06 $X=3960 $Y=2520 $dt=5
M9 vdd5! 6 Q vdd5! pe5 L=5e-07 W=8.7e-07 AD=7.8e-13 AS=2.64207e-13 PD=4.34e-06 PS=1.47539e-06 $X=5000 $Y=2520 $dt=5
.ends EN2_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3I1_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3I1_5VX1 vdd5! gnd! AN C Q B
** N=9 EP=6 FDC=8
M0 gnd! AN 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.26325e-13 AS=2.016e-13 PD=1.219e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 Q C gnd! gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=2.3515e-13 AS=4.81825e-13 PD=1.42414e-06 PS=2.59514e-06 $X=1790 $Y=660 $dt=2
M2 gnd! B Q gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=3.4375e-13 AS=2.3515e-13 PD=1.85414e-06 PS=1.42414e-06 $X=2810 $Y=660 $dt=2
M3 Q 7 gnd! gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=4.2205e-13 AS=3.4375e-13 PD=2.73414e-06 PS=1.85414e-06 $X=3930 $Y=660 $dt=2
M4 vdd5! AN 7 vdd5! pe5 L=5e-07 W=7.2e-07 AD=4.44642e-13 AS=3.456e-13 PD=1.75099e-06 PS=2.4e-06 $X=620 $Y=2570 $dt=5
M5 8 C vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=8.70758e-13 PD=1.66e-06 PS=3.42901e-06 $X=1950 $Y=2410 $dt=5
M6 9 B 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.7625e-13 PD=1.66e-06 PS=1.66e-06 $X=2700 $Y=2410 $dt=5
M7 Q 7 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=3450 $Y=2410 $dt=5
.ends NO3I1_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO2_5VX0                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO2_5VX0 vdd5! gnd! B A Q
** N=9 EP=5 FDC=10
M0 6 B gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.628e-13 PD=9.6e-07 PS=3.52e-06 $X=660 $Y=1130 $dt=2
M1 gnd! A 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.503e-13 AS=1.134e-13 PD=1.15e-06 PS=9.6e-07 $X=1700 $Y=1130 $dt=2
M2 7 B gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.503e-13 PD=6.7e-07 PS=1.15e-06 $X=2780 $Y=980 $dt=2
M3 Q A 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.503e-13 AS=5.25e-14 PD=1.15e-06 PS=6.7e-07 $X=3530 $Y=980 $dt=2
M4 gnd! 6 Q gnd! ne5 L=5e-07 W=4.2e-07 AD=1.0464e-12 AS=1.503e-13 PD=4.3e-06 PS=1.15e-06 $X=4610 $Y=1130 $dt=2
M5 9 B vdd5! vdd5! pe5 L=5e-07 W=9e-07 AD=1.125e-13 AS=6.95e-13 PD=1.15e-06 PS=4.56e-06 $X=550 $Y=2410 $dt=5
M6 6 A 9 vdd5! pe5 L=5e-07 W=9e-07 AD=3.53688e-13 AS=1.125e-13 PD=2.72778e-06 PS=1.15e-06 $X=1300 $Y=2410 $dt=5
M7 vdd5! B 8 vdd5! pe5 L=5e-07 W=1.3e-06 AD=4.996e-13 AS=5.44087e-13 PD=2.38e-06 PS=3.52778e-06 $X=2880 $Y=2520 $dt=5
M8 8 A vdd5! vdd5! pe5 L=5e-07 W=1.3e-06 AD=3.51e-13 AS=4.996e-13 PD=1.84e-06 PS=2.38e-06 $X=4000 $Y=2410 $dt=5
M9 Q 6 8 vdd5! pe5 L=5e-07 W=1.3e-06 AD=6.24e-13 AS=3.51e-13 PD=3.56e-06 PS=1.84e-06 $X=5040 $Y=2410 $dt=5
.ends EO2_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA22_5VX1 vdd5! gnd! A B C Q
** N=9 EP=6 FDC=8
M0 8 A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=4.272e-13 PD=1.14e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 gnd! B 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.238e-13 AS=1.1125e-13 PD=1.98e-06 PS=1.14e-06 $X=1370 $Y=660 $dt=2
M2 9 C gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=4.238e-13 PD=1.14e-06 PS=1.98e-06 $X=2610 $Y=660 $dt=2
M3 Q 7 9 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=3360 $Y=660 $dt=2
M4 7 A vdd5! vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=2.82488e-13 AS=7.59713e-13 PD=1.87092e-06 PS=4.48092e-06 $X=525 $Y=2410 $dt=5
M5 vdd5! B 7 vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=3.90112e-13 AS=2.82488e-13 PD=2.30092e-06 PS=1.87092e-06 $X=1565 $Y=2410 $dt=5
M6 Q C vdd5! vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=2.82488e-13 AS=3.90112e-13 PD=1.87092e-06 PS=2.30092e-06 $X=2415 $Y=2410 $dt=5
M7 vdd5! 7 Q vdd5! pe5 L=5.00266e-07 W=1.46592e-06 AD=7.59713e-13 AS=2.82488e-13 PD=4.48092e-06 PS=1.87092e-06 $X=3455 $Y=2410 $dt=5
.ends NA22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3_5VX1 vdd5! gnd! C Q B A
** N=8 EP=6 FDC=6
M0 Q C gnd! gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=2.3515e-13 AS=6.1655e-13 PD=1.42414e-06 PS=3.53414e-06 $X=670 $Y=660 $dt=2
M1 gnd! B Q gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=3.4375e-13 AS=2.3515e-13 PD=1.85414e-06 PS=1.42414e-06 $X=1690 $Y=660 $dt=2
M2 Q A gnd! gnd! ne5 L=4.99809e-07 W=8.94142e-07 AD=4.2205e-13 AS=3.4375e-13 PD=2.73414e-06 PS=1.85414e-06 $X=2810 $Y=660 $dt=2
M3 8 C vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.1794e-12 PD=1.66e-06 PS=4.9e-06 $X=830 $Y=2410 $dt=5
M4 7 B 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.7625e-13 PD=1.66e-06 PS=1.66e-06 $X=1580 $Y=2410 $dt=5
M5 Q A 7 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=2330 $Y=2410 $dt=5
.ends NO3_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OA211_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OA211_5VX1 vdd5! gnd! B A C D Q
** N=11 EP=7 FDC=10
M0 9 B 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=3.24933e-13 PD=9.6e-07 PS=2.8e-06 $X=460 $Y=1130 $dt=2
M1 9 A 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=3.24933e-13 PD=9.6e-07 PS=2.8e-06 $X=1500 $Y=1130 $dt=2
M2 10 C 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=3.24933e-13 PD=6.7e-07 PS=2.8e-06 $X=2420 $Y=1130 $dt=2
M3 gnd! D 10 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.8451e-13 AS=5.25e-14 PD=1.3145e-06 PS=6.7e-07 $X=3170 $Y=1130 $dt=2
M4 Q 9 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=6.0289e-13 PD=2.74e-06 PS=2.7855e-06 $X=4480 $Y=660 $dt=2
M5 11 B vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=9e-14 AS=6.032e-13 PD=9.7e-07 PS=4.56e-06 $X=460 $Y=2410 $dt=5
M6 9 A 11 vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.746e-13 AS=9e-14 PD=2.08e-06 PS=9.7e-07 $X=1210 $Y=2410 $dt=5
M7 vdd5! C 9 vdd5! pe5 L=5e-07 W=7.2e-07 AD=3.376e-13 AS=2.746e-13 PD=2.38e-06 PS=2.08e-06 $X=2130 $Y=2410 $dt=5
M8 9 D vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=4.801e-13 AS=3.376e-13 PD=3.97899e-06 PS=2.38e-06 $X=3050 $Y=2410 $dt=5
M9 Q 9 vdd5! vdd5! pe5 L=5.00314e-07 W=1.47627e-06 AD=5.32e-13 AS=7.283e-13 PD=3.68627e-06 PS=4.46627e-06 $X=4480 $Y=2410 $dt=5
.ends OA211_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND3_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND3_5VX1 vdd5! gnd! A B C Q
** N=9 EP=6 FDC=8
M0 8 A 7 gnd! ne5 L=5e-07 W=7e-07 AD=9.1e-14 AS=3.36e-13 PD=9.6e-07 PS=2.36e-06 $X=620 $Y=850 $dt=2
M1 9 B 8 gnd! ne5 L=5e-07 W=7e-07 AD=9.1e-14 AS=9.1e-14 PD=9.6e-07 PS=9.6e-07 $X=1380 $Y=850 $dt=2
M2 gnd! C 9 gnd! ne5 L=5e-07 W=7e-07 AD=3.53874e-13 AS=9.1e-14 PD=1.72579e-06 PS=9.6e-07 $X=2140 $Y=850 $dt=2
M3 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.49926e-13 PD=2.74e-06 PS=2.19421e-06 $X=3360 $Y=660 $dt=2
M4 vdd5! A 7 vdd5! pe5 L=5e-07 W=7e-07 AD=3.45e-13 AS=4.73e-13 PD=2.4e-06 PS=3.94e-06 $X=460 $Y=2410 $dt=5
M5 7 B vdd5! vdd5! pe5 L=5e-07 W=7e-07 AD=2.704e-13 AS=3.45e-13 PD=2.06e-06 PS=2.4e-06 $X=1380 $Y=2410 $dt=5
M6 vdd5! C 7 vdd5! pe5 L=5e-07 W=7e-07 AD=2.94929e-13 AS=2.704e-13 PD=1.57915e-06 PS=2.06e-06 $X=2300 $Y=2410 $dt=5
M7 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=5.94071e-13 PD=3.78e-06 PS=3.18085e-06 $X=3360 $Y=2410 $dt=5
.ends AND3_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MU2_5VX4                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MU2_5VX4 vdd5! gnd! S IN0 IN1 Q
** N=12 EP=6 FDC=18
M0 gnd! S 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.95693e-13 AS=2.016e-13 PD=1.34791e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 8 IN0 gnd! gnd! ne5 L=5e-07 W=8.7e-07 AD=1.0875e-13 AS=6.12507e-13 PD=1.12e-06 PS=2.79209e-06 $X=1950 $Y=660 $dt=2
M2 9 7 8 gnd! ne5 L=5e-07 W=8.7e-07 AD=2.349e-13 AS=1.0875e-13 PD=1.41e-06 PS=1.12e-06 $X=2700 $Y=660 $dt=2
M3 10 S 9 gnd! ne5 L=5e-07 W=8.7e-07 AD=3.63225e-13 AS=2.349e-13 PD=1.705e-06 PS=1.41e-06 $X=3740 $Y=660 $dt=2
M4 gnd! IN1 10 gnd! ne5 L=5e-07 W=8.7e-07 AD=3.46641e-13 AS=3.63225e-13 PD=1.84381e-06 PS=1.705e-06 $X=5075 $Y=660 $dt=2
M5 Q 9 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.54609e-13 PD=1.43e-06 PS=1.88619e-06 $X=6200 $Y=660 $dt=2
M6 gnd! 9 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=7240 $Y=660 $dt=2
M7 Q 9 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=8360 $Y=660 $dt=2
M8 gnd! 9 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=7.09e-13 AS=2.403e-13 PD=3.68e-06 PS=1.43e-06 $X=9400 $Y=660 $dt=2
M9 vdd5! S 7 vdd5! pe5 L=5e-07 W=7e-07 AD=4.37268e-13 AS=3.36e-13 PD=1.71848e-06 PS=2.36e-06 $X=620 $Y=2410 $dt=5
M10 11 IN0 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.88675e-13 AS=8.80782e-13 PD=2.245e-06 PS=3.46152e-06 $X=1950 $Y=2410 $dt=5
M11 9 S 11 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.88675e-13 PD=1.95e-06 PS=2.245e-06 $X=3285 $Y=2410 $dt=5
M12 12 7 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=3.807e-13 PD=1.66e-06 PS=1.95e-06 $X=4325 $Y=2410 $dt=5
M13 vdd5! IN1 12 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.14125e-13 AS=1.7625e-13 PD=2.385e-06 PS=1.66e-06 $X=5075 $Y=2410 $dt=5
M14 Q 9 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.14125e-13 PD=1.95e-06 PS=2.385e-06 $X=6200 $Y=2410 $dt=5
M15 vdd5! 9 Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.106e-13 AS=3.807e-13 PD=2.38e-06 PS=1.95e-06 $X=7240 $Y=2410 $dt=5
M16 Q 9 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.106e-13 PD=1.95e-06 PS=2.38e-06 $X=8360 $Y=2410 $dt=5
M17 vdd5! 9 Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.021e-12 AS=3.807e-13 PD=4.72e-06 PS=1.95e-06 $X=9400 $Y=2410 $dt=5
.ends MU2_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HA_5VX4                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HA_5VX4 vdd5! gnd! S B A CO
** N=11 EP=6 FDC=26
M0 S 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=2
M1 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=1700 $Y=660 $dt=2
M2 S 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=2740 $Y=660 $dt=2
M3 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=5.106e-13 AS=2.403e-13 PD=3.42627e-06 PS=1.43e-06 $X=3780 $Y=660 $dt=2
M4 gnd! A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.52e-13 PD=1.43e-06 PS=2.74e-06 $X=5400 $Y=660 $dt=2
M5 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.63753e-13 AS=2.403e-13 PD=1.71986e-06 PS=1.43e-06 $X=6440 $Y=660 $dt=2
M6 8 10 7 gnd! ne5 L=5e-07 W=5.9e-07 AD=3.068e-13 AS=1.74847e-13 PD=2.22e-06 PS=1.14014e-06 $X=7480 $Y=960 $dt=2
M7 CO 10 gnd! gnd! ne5 L=5e-07 W=5.5e-07 AD=1.485e-13 AS=3.0525e-13 PD=1.09e-06 PS=2.21e-06 $X=9335 $Y=1000 $dt=2
M8 gnd! 10 CO gnd! ne5 L=5e-07 W=5.5e-07 AD=1.71875e-13 AS=1.485e-13 PD=1.175e-06 PS=1.09e-06 $X=10375 $Y=1000 $dt=2
M9 CO 10 gnd! gnd! ne5 L=5e-07 W=5.5e-07 AD=1.485e-13 AS=1.71875e-13 PD=1.09e-06 PS=1.175e-06 $X=11500 $Y=1000 $dt=2
M10 gnd! 10 CO gnd! ne5 L=5e-07 W=5.5e-07 AD=2.4876e-13 AS=1.485e-13 PD=1.26806e-06 PS=1.09e-06 $X=12540 $Y=1000 $dt=2
M11 9 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=4.0254e-13 PD=1.14e-06 PS=2.05194e-06 $X=13810 $Y=660 $dt=2
M12 10 A 9 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=14560 $Y=660 $dt=2
M13 S 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=8.802e-13 PD=1.95e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M14 vdd5! 8 S vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.282e-13 AS=3.807e-13 PD=2.4e-06 PS=1.95e-06 $X=1700 $Y=2410 $dt=5
M15 S 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.282e-13 PD=1.95e-06 PS=2.4e-06 $X=2840 $Y=2410 $dt=5
M16 vdd5! 8 S vdd5! pe5 L=5e-07 W=1.41e-06 AD=8.63901e-13 AS=3.807e-13 PD=3.22461e-06 PS=1.95e-06 $X=3880 $Y=2410 $dt=5
M17 11 A vdd5! vdd5! pe5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=5.45299e-13 PD=1.14e-06 PS=2.03539e-06 $X=5250 $Y=2630 $dt=5
M18 8 B 11 vdd5! pe5 L=5e-07 W=8.9e-07 AD=3.221e-13 AS=1.1125e-13 PD=1.73e-06 PS=1.14e-06 $X=6000 $Y=2630 $dt=5
M19 vdd5! 10 8 vdd5! pe5 L=5e-07 W=8.9e-07 AD=5.76809e-13 AS=3.221e-13 PD=2.1716e-06 PS=1.73e-06 $X=7120 $Y=2630 $dt=5
M20 CO 10 vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=7.19391e-13 PD=1.65e-06 PS=2.7084e-06 $X=8640 $Y=2410 $dt=5
M21 vdd5! 10 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=5.11125e-13 AS=2.997e-13 PD=2.205e-06 PS=1.65e-06 $X=9680 $Y=2410 $dt=5
M22 CO 10 vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=3.13575e-13 AS=5.11125e-13 PD=1.675e-06 PS=2.205e-06 $X=10930 $Y=2410 $dt=5
M23 vdd5! 10 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=6.67575e-13 AS=3.13575e-13 PD=2.405e-06 PS=1.675e-06 $X=11995 $Y=2410 $dt=5
M24 10 B vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=6.67575e-13 PD=1.65e-06 PS=2.405e-06 $X=13480 $Y=2410 $dt=5
M25 vdd5! A 10 vdd5! pe5 L=5e-07 W=1.11e-06 AD=8.502e-13 AS=2.997e-13 PD=4.56e-06 PS=1.65e-06 $X=14520 $Y=2410 $dt=5
.ends HA_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HA_5VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HA_5VX2 vdd5! gnd! S B A CO
** N=11 EP=6 FDC=18
M0 S 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=2
M1 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=5.106e-13 AS=2.403e-13 PD=3.42627e-06 PS=1.43e-06 $X=1700 $Y=660 $dt=2
M2 gnd! A 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.52e-13 PD=1.43e-06 PS=2.74e-06 $X=3320 $Y=660 $dt=2
M3 7 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.63753e-13 AS=2.403e-13 PD=1.71986e-06 PS=1.43e-06 $X=4360 $Y=660 $dt=2
M4 8 10 7 gnd! ne5 L=5e-07 W=5.9e-07 AD=3.068e-13 AS=1.74847e-13 PD=2.22e-06 PS=1.14014e-06 $X=5400 $Y=960 $dt=2
M5 CO 10 gnd! gnd! ne5 L=5e-07 W=5.5e-07 AD=1.485e-13 AS=2.64e-13 PD=1.09e-06 PS=2.06e-06 $X=7200 $Y=1000 $dt=2
M6 gnd! 10 CO gnd! ne5 L=5e-07 W=5.5e-07 AD=1.73288e-13 AS=1.485e-13 PD=1.13056e-06 PS=1.09e-06 $X=8240 $Y=1000 $dt=2
M7 9 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.80412e-13 PD=1.14e-06 PS=1.82944e-06 $X=9330 $Y=660 $dt=2
M8 10 A 9 gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=10080 $Y=660 $dt=2
M9 S 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=8.802e-13 PD=1.95e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M10 vdd5! 8 S vdd5! pe5 L=5e-07 W=1.41e-06 AD=9.71797e-13 AS=3.807e-13 PD=3.34722e-06 PS=1.95e-06 $X=1700 $Y=2410 $dt=5
M11 11 A vdd5! vdd5! pe5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.13403e-13 PD=1.14e-06 PS=2.11278e-06 $X=3170 $Y=2630 $dt=5
M12 8 B 11 vdd5! pe5 L=5e-07 W=8.9e-07 AD=3.399e-13 AS=1.1125e-13 PD=1.77e-06 PS=1.14e-06 $X=3920 $Y=2630 $dt=5
M13 vdd5! 10 8 vdd5! pe5 L=5e-07 W=8.9e-07 AD=4.42864e-13 AS=3.399e-13 PD=1.9402e-06 PS=1.77e-06 $X=5080 $Y=2630 $dt=5
M14 CO 10 vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=3.02475e-13 AS=5.52336e-13 PD=1.655e-06 PS=2.4198e-06 $X=6340 $Y=2410 $dt=5
M15 vdd5! 10 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=7.14175e-13 AS=3.02475e-13 PD=2.475e-06 PS=1.655e-06 $X=7385 $Y=2410 $dt=5
M16 10 B vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=7.14175e-13 PD=1.65e-06 PS=2.475e-06 $X=8940 $Y=2410 $dt=5
M17 vdd5! A 10 vdd5! pe5 L=5e-07 W=1.11e-06 AD=9.558e-13 AS=2.997e-13 PD=4.68e-06 PS=1.65e-06 $X=9980 $Y=2410 $dt=5
.ends HA_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRQ_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRQ_5VX1 vdd5! gnd! D C Q
** N=19 EP=5 FDC=26
M0 gnd! 6 9 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=2.016e-13 PD=9.6e-07 PS=1.8e-06 $X=620 $Y=960 $dt=2
M1 12 9 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=1660 $Y=960 $dt=2
M2 6 11 12 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.3125e-13 AS=5.25e-14 PD=9.3e-07 PS=6.7e-07 $X=2410 $Y=960 $dt=2
M3 14 10 6 gnd! ne5 L=5e-07 W=7e-07 AD=8.75e-14 AS=2.1875e-13 PD=9.5e-07 PS=1.55e-06 $X=3450 $Y=960 $dt=2
M4 gnd! D 14 gnd! ne5 L=5e-07 W=7e-07 AD=2.1875e-13 AS=8.75e-14 PD=1.55e-06 PS=9.5e-07 $X=4200 $Y=960 $dt=2
M5 11 10 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=1.3125e-13 PD=1.8e-06 PS=9.3e-07 $X=5240 $Y=960 $dt=2
M6 gnd! C 10 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.63782e-13 AS=2.016e-13 PD=1.08316e-06 PS=1.8e-06 $X=6980 $Y=1130 $dt=2
M7 15 9 gnd! gnd! ne5 L=5e-07 W=7.2e-07 AD=9e-14 AS=2.80768e-13 PD=9.7e-07 PS=1.85684e-06 $X=8060 $Y=660 $dt=2
M8 7 11 15 gnd! ne5 L=5e-07 W=7.2e-07 AD=2.26611e-13 AS=9e-14 PD=1.59158e-06 PS=9.7e-07 $X=8810 $Y=660 $dt=2
M9 13 10 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.32189e-13 PD=6.7e-07 PS=9.28421e-07 $X=9850 $Y=960 $dt=2
M10 gnd! 8 13 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.512e-13 AS=5.25e-14 PD=1.14e-06 PS=6.7e-07 $X=10600 $Y=960 $dt=2
M11 8 7 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.00088e-13 AS=1.512e-13 PD=1.76778e-06 PS=1.14e-06 $X=11720 $Y=960 $dt=2
M12 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=5.687e-13 PD=2.74e-06 PS=3.48485e-06 $X=13440 $Y=660 $dt=2
M13 vdd5! 6 9 vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.352e-13 AS=3.456e-13 PD=1.64211e-06 PS=2.4e-06 $X=620 $Y=2890 $dt=5
M14 16 9 vdd5! vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.372e-13 PD=6.7e-07 PS=9.57895e-07 $X=1660 $Y=3230 $dt=5
M15 6 10 16 vdd5! pe5 L=5e-07 W=4.2e-07 AD=1.45342e-13 AS=5.25e-14 PD=9.06316e-07 PS=6.7e-07 $X=2410 $Y=3230 $dt=5
M16 18 11 6 vdd5! pe5 L=5e-07 W=1.1e-06 AD=1.375e-13 AS=3.80658e-13 PD=1.35e-06 PS=2.37368e-06 $X=3450 $Y=2720 $dt=5
M17 vdd5! D 18 vdd5! pe5 L=5e-07 W=1.1e-06 AD=4.78077e-13 AS=1.375e-13 PD=2.5022e-06 PS=1.35e-06 $X=4200 $Y=2720 $dt=5
M18 11 10 vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.9635e-13 AS=3.12923e-13 PD=2.37071e-06 PS=1.6378e-06 $X=5320 $Y=2720 $dt=5
M19 vdd5! C 10 vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.88539e-13 AS=3.92688e-13 PD=1.63251e-06 PS=2.78435e-06 $X=6980 $Y=2800 $dt=5
M20 19 9 vdd5! vdd5! pe5 L=5e-07 W=1.15e-06 AD=1.4375e-13 AS=4.60861e-13 PD=1.4e-06 PS=2.60749e-06 $X=8060 $Y=2670 $dt=5
M21 7 10 19 vdd5! pe5 L=5e-07 W=1.15e-06 AD=3.37236e-13 AS=1.4375e-13 PD=2.4758e-06 PS=1.4e-06 $X=8810 $Y=2670 $dt=5
M22 17 11 7 vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.23164e-13 PD=6.7e-07 PS=9.04204e-07 $X=9850 $Y=3150 $dt=5
M23 vdd5! 8 17 vdd5! pe5 L=5e-07 W=4.2e-07 AD=3.14337e-13 AS=5.25e-14 PD=1.75368e-06 PS=6.7e-07 $X=10600 $Y=3150 $dt=5
M24 8 7 vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=3.456e-13 AS=5.38863e-13 PD=2.4e-06 PS=3.00632e-06 $X=11720 $Y=2410 $dt=5
M25 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=8.172e-13 PD=3.78e-06 PS=4.56e-06 $X=13440 $Y=2410 $dt=5
.ends DFRQ_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX0                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX0 vdd5! gnd! A Q
** N=4 EP=4 FDC=2
M0 Q A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=4.888e-13 PD=1.8e-06 PS=3.52e-06 $X=560 $Y=1130 $dt=2
M1 Q A vdd5! vdd5! pe5 L=5e-07 W=9.4e-07 AD=4.512e-13 AS=7.062e-13 PD=2.84e-06 PS=4.50142e-06 $X=560 $Y=2410 $dt=5
.ends IN_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON22_5VX1 vdd5! gnd! D C Q A B
** N=10 EP=7 FDC=8
M0 gnd! D 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=3.556e-13 AS=4.272e-13 PD=1.87e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 8 C gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.556e-13 PD=1.43e-06 PS=1.87e-06 $X=1750 $Y=660 $dt=2
M2 Q A 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=2790 $Y=660 $dt=2
M3 8 B Q gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=2.403e-13 PD=2.74e-06 PS=1.43e-06 $X=3830 $Y=660 $dt=2
M4 9 D vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.4786e-12 PD=1.66e-06 PS=5.24e-06 $X=1000 $Y=2410 $dt=5
M5 Q C 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=1.7625e-13 PD=1.95e-06 PS=1.66e-06 $X=1750 $Y=2410 $dt=5
M6 10 A Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=3.807e-13 PD=1.66e-06 PS=1.95e-06 $X=2790 $Y=2410 $dt=5
M7 vdd5! B 10 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.4786e-12 AS=1.7625e-13 PD=5.24e-06 PS=1.66e-06 $X=3540 $Y=2410 $dt=5
.ends ON22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MU2_5VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MU2_5VX1 vdd5! gnd! S IN0 IN1 Q
** N=12 EP=6 FDC=12
M0 gnd! S 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.373e-13 AS=2.016e-13 PD=1.395e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=2
M1 8 IN0 gnd! gnd! ne5 L=5e-07 W=7e-07 AD=8.75e-14 AS=3.955e-13 PD=9.5e-07 PS=2.325e-06 $X=1740 $Y=660 $dt=2
M2 10 7 8 gnd! ne5 L=5e-07 W=7e-07 AD=1.89e-13 AS=8.75e-14 PD=1.24e-06 PS=9.5e-07 $X=2490 $Y=660 $dt=2
M3 9 S 10 gnd! ne5 L=5e-07 W=7e-07 AD=8.75e-14 AS=1.89e-13 PD=9.5e-07 PS=1.24e-06 $X=3530 $Y=660 $dt=2
M4 gnd! IN1 9 gnd! ne5 L=5e-07 W=7e-07 AD=3.85044e-13 AS=8.75e-14 PD=1.81384e-06 PS=9.5e-07 $X=4280 $Y=660 $dt=2
M5 Q 10 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=4.89556e-13 PD=2.74e-06 PS=2.30616e-06 $X=5600 $Y=660 $dt=2
M6 vdd5! S 7 vdd5! pe5 L=5e-07 W=5e-07 AD=3.33681e-13 AS=2.4e-13 PD=1.37222e-06 PS=1.96e-06 $X=620 $Y=2520 $dt=5
M7 11 IN0 vdd5! vdd5! pe5 L=5e-07 W=1.3e-06 AD=1.625e-13 AS=8.67569e-13 PD=1.55e-06 PS=3.56778e-06 $X=1940 $Y=2520 $dt=5
M8 10 S 11 vdd5! pe5 L=5e-07 W=1.3e-06 AD=3.51e-13 AS=1.625e-13 PD=1.84e-06 PS=1.55e-06 $X=2690 $Y=2520 $dt=5
M9 12 7 10 vdd5! pe5 L=5e-07 W=1.3e-06 AD=1.625e-13 AS=3.51e-13 PD=1.55e-06 PS=1.84e-06 $X=3730 $Y=2520 $dt=5
M10 vdd5! IN1 12 vdd5! pe5 L=5e-07 W=1.3e-06 AD=4.80376e-13 AS=1.625e-13 PD=2.28339e-06 PS=1.55e-06 $X=4480 $Y=2520 $dt=5
M11 Q 10 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=5.21024e-13 PD=3.78e-06 PS=2.47661e-06 $X=5600 $Y=2410 $dt=5
.ends MU2_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OA22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OA22_5VX1 vdd5! gnd! D C A B Q
** N=11 EP=7 FDC=10
M0 gnd! D 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=4.10587e-13 PD=9.6e-07 PS=3.4751e-06 $X=460 $Y=1130 $dt=2
M1 gnd! C 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=4.10587e-13 PD=9.6e-07 PS=3.4751e-06 $X=1500 $Y=1130 $dt=2
M2 9 A 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=4.10587e-13 PD=9.6e-07 PS=3.4751e-06 $X=2420 $Y=1130 $dt=2
M3 9 B 8 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=4.10587e-13 PD=9.6e-07 PS=3.4751e-06 $X=3460 $Y=1130 $dt=2
M4 Q 9 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=5.702e-13 PD=2.74e-06 PS=3.49657e-06 $X=5040 $Y=660 $dt=2
M5 vdd5! D 10 vdd5! pe5 L=5e-07 W=7.2e-07 AD=1.35496e-12 AS=9e-14 PD=3.99158e-06 PS=9.7e-07 $X=720 $Y=2410 $dt=5
M6 9 C 10 vdd5! pe5 L=5e-07 W=7.2e-07 AD=1.944e-13 AS=9e-14 PD=1.26e-06 PS=9.7e-07 $X=1470 $Y=2410 $dt=5
M7 11 A 9 vdd5! pe5 L=5e-07 W=7.2e-07 AD=9e-14 AS=1.944e-13 PD=9.7e-07 PS=1.26e-06 $X=2510 $Y=2410 $dt=5
M8 vdd5! B 11 vdd5! pe5 L=5e-07 W=7.2e-07 AD=1.35496e-12 AS=9e-14 PD=3.99158e-06 PS=9.7e-07 $X=3260 $Y=2410 $dt=5
M9 Q 9 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=2.65347e-12 PD=3.78e-06 PS=7.81684e-06 $X=5040 $Y=2410 $dt=5
.ends OA22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR2_5VX0                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR2_5VX0 vdd5! gnd! A B Q
** N=7 EP=5 FDC=6
M0 6 A gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=1.134e-13 AS=5.486e-13 PD=9.6e-07 PS=3.50828e-06 $X=640 $Y=1130 $dt=2
M1 gnd! B 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=3.024e-13 AS=1.134e-13 PD=1.86e-06 PS=9.6e-07 $X=1680 $Y=1130 $dt=2
M2 Q 6 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=3.024e-13 PD=1.8e-06 PS=1.86e-06 $X=2800 $Y=1130 $dt=2
M3 7 A 6 vdd5! pe5 L=5e-07 W=7.2e-07 AD=9e-14 AS=3.456e-13 PD=9.7e-07 PS=2.4e-06 $X=930 $Y=2410 $dt=5
M4 vdd5! B 7 vdd5! pe5 L=5e-07 W=7.2e-07 AD=4.416e-13 AS=9e-14 PD=2.38e-06 PS=9.7e-07 $X=1680 $Y=2410 $dt=5
M5 Q 6 vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=3.456e-13 AS=4.416e-13 PD=2.4e-06 PS=2.38e-06 $X=2800 $Y=2410 $dt=5
.ends OR2_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__P1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__P1 1 2 3 4 5 6 7 8 9 10
+ 11 12 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30
+ 31 32 33 34 35 36 37 38 39 40
+ 41 42 43 44 45 46 47 48 49 50
+ 51 52 53 54 55 56 57 58 59 60
+ 61 62 63 64 65 66 67 68 69 70
+ 71 72 73 74 75 76 77 78 79 80
+ 81 82 83 84 85 86 87 88 89 90
+ 91 92 93 94 95 96 97 98 99 100
+ 101 102 103 104 105 106 107 108 109 110
+ 111 112 113 114 115 116 117 118 119 120
+ 121 122 123 124 125 126 127 128 129 130
+ 131 132 133 134 135 136 137 138 139 140
+ 141 142 143 144 145 146 147 148 149 150
+ 151 152 153 154 155 156 157 158 159 160
+ 161 162 163 164 165 166 167 168 169 170
+ 171 172 173 174 175 176 177 178 179 180
+ 181 182 183 184 185 186 187 188 189 190
+ 191 192 193 194 195 196 197 198 199 200
+ 201 202 203 204 205 206 207 208 209 210
+ 211 212 213 214 215 216 217 218 219 220
+ 221 222 223 224 225 226 227 228 229 230
+ 231 232 233 234 235 236 237 238 239 240
+ 241 242 243 244 245 246 247 248 249 250
+ 251 252 253 254 255 256 257 258 259 260
+ 261 262 263 264 265 266 267 268 269 270
+ 271 272 273 274 275 276 277 278 279 280
+ 281 282 283 284 285 286 287 288 289 290
+ 291 292 293 294 295 296 297 298 299 300
+ 301 302 303 304 305 306 307 308 309 310
+ 311 312 313 314 315 316 317 318 319 320
+ 321 322 323 324 325 326 327 328 329 330
+ 331 332 333 334 335 336 337 338 339 340
+ 341 342 343 344 345 346 347 348 349 350
+ 351 352 353 354 355 356 357 358 359 360
+ 361 362 363 364 365 366 367 368 369 370
+ 371 372 373 374 375 376 377 378 379 380
+ 381 382 383 384 385 386 387 388 389 390
+ 391 392 393 394 395 396 397 398 399 400
+ 401 402 403 404 405 406 407 408 409 410
+ 411 412 413 414 415 416 417 418 419 420
+ 421 422 423 424 425 426 427 428 429 430
+ 431 432 433 434 435 436 437 438 439 440
+ 441 442 443 444 445 446 447 448 449 450
+ 451 452 453 454 455 456 457 458 459 460
+ 461 462 463 464 465 466 467 468 469 470
+ 471 472 473 474 475 476 477 478 479 480
+ 481 482 483 484 485 486 487 488 489 490
+ 491 492 493 494 495 496 497 498 499 500
+ 501 502 503 504 505 506 507 508 509 510
+ 511 512 513 514 515 516 517 518 519 520
+ 521 522 523 524 525 526 527 528 529 530
+ 531 532 533 534 535 536 537 538 539 540
+ 541 542 543 544 545 546 547 548 549 550
+ 551 552 553 554 555 556 557 558 559 560
+ 561 562 563 564 565 566 567 568 569 570
+ 571 572 573 574 575 576 577 578 579 580
+ 581 582 583 584 585 586 587 588 589 590
+ 591 592 593 594 595 596 597 598 599 600
+ 601 602 603 604 605 606 607 608 609 610
+ 611 612 613 614 615 616 617 618 619 620
+ 621 622 623 624 625 626 627 628 629 630
+ 631 632 633 634 635 636 637 638 639 640
+ 641 642 643 644 645 646 647 648 649 650
+ 651 652 653 654 655 656 657 658 659 660
+ 661 662 663 664 665 666 667 668 669 670
+ 671 672 673 674 675 676 677 678 679 680
+ 681 682 683 684 685 686 687 688 689 690
+ 691 692 693 694 695 696 697 698 699 700
+ 701 702 703 704 705 706 707 708 709 710
+ 711 712 713 714 715 716 717 718 719 720
+ 721 722 723 724 725 726 727 728 729 730
+ 731 732 733 734 735 736 737 738 739 740
+ 741 742 743 744 745 746 747
** N=3307 EP=747 FDC=33402
X16254 2 1 60 2527 BU_5VX1 $T=-366120 -277760 0 0 $X=-366550 $Y=-278400
X16255 2 1 956 910 BU_5VX1 $T=-316280 -394240 1 180 $X=-319510 $Y=-394880
X16256 2 1 922 764 BU_5VX1 $T=-315720 -367360 0 0 $X=-316150 $Y=-368000
X16257 2 1 1033 1038 BU_5VX1 $T=-290520 -421120 0 0 $X=-290950 $Y=-421760
X16258 2 1 1038 1041 BU_5VX1 $T=-286040 -412160 1 0 $X=-286470 $Y=-417280
X16259 2 1 1465 1061 BU_5VX1 $T=-282680 -421120 1 0 $X=-283110 $Y=-426240
X16260 2 1 1062 1044 BU_5VX1 $T=-281000 -403200 1 0 $X=-281430 $Y=-408320
X16261 2 1 126 1050 BU_5VX1 $T=-278200 -403200 1 0 $X=-278630 $Y=-408320
X16262 2 1 1073 1086 BU_5VX1 $T=-275400 -403200 1 0 $X=-275830 $Y=-408320
X16263 2 1 1086 1080 BU_5VX1 $T=-269800 -394240 0 0 $X=-270230 $Y=-394880
X16264 2 1 1100 1104 BU_5VX1 $T=-266440 -403200 1 0 $X=-266870 $Y=-408320
X16265 2 1 1061 1103 BU_5VX1 $T=-263640 -403200 1 0 $X=-264070 $Y=-408320
X16266 2 1 2638 1116 BU_5VX1 $T=-251880 -412160 0 0 $X=-252310 $Y=-412800
X16267 2 1 1207 1203 BU_5VX1 $T=-226680 -412160 0 0 $X=-227110 $Y=-412800
X16268 2 1 1216 2662 BU_5VX1 $T=-222760 -412160 0 0 $X=-223190 $Y=-412800
X16269 2 1 1217 1222 BU_5VX1 $T=-222760 -394240 1 0 $X=-223190 $Y=-399360
X16270 2 1 1223 1217 BU_5VX1 $T=-221640 -421120 0 0 $X=-222070 $Y=-421760
X16271 2 1 1224 1230 BU_5VX1 $T=-221640 -403200 1 0 $X=-222070 $Y=-408320
X16272 2 1 1239 1216 BU_5VX1 $T=-217720 -412160 1 0 $X=-218150 $Y=-417280
X16273 2 1 1230 1227 BU_5VX1 $T=-217160 -394240 1 0 $X=-217590 $Y=-399360
X16274 2 1 1249 1245 BU_5VX1 $T=-213240 -412160 0 0 $X=-213670 $Y=-412800
X16275 2 1 1256 1255 BU_5VX1 $T=-209320 -412160 0 0 $X=-209750 $Y=-412800
X16276 2 1 1255 1261 BU_5VX1 $T=-209320 -403200 1 0 $X=-209750 $Y=-408320
X16277 2 1 3227 1273 BU_5VX1 $T=-204280 -403200 1 0 $X=-204710 $Y=-408320
X16278 2 1 186 3227 BU_5VX1 $T=-203720 -412160 0 0 $X=-204150 $Y=-412800
X16279 2 1 198 3251 BU_5VX1 $T=-188040 -412160 0 0 $X=-188470 $Y=-412800
X16280 2 1 3251 1320 BU_5VX1 $T=-185240 -412160 0 0 $X=-185670 $Y=-412800
X16281 2 1 778 1207 BU_5VX1 $T=-175160 -412160 1 0 $X=-175590 $Y=-417280
X16282 2 1 218 1376 BU_5VX1 $T=-159480 -412160 0 0 $X=-159910 $Y=-412800
X16283 2 1 1382 1387 BU_5VX1 $T=-159480 -385280 0 0 $X=-159910 $Y=-385920
X16284 2 1 1490 3252 BU_5VX1 $T=-106280 -286720 1 0 $X=-106710 $Y=-291840
X16285 2 1 1625 1631 BU_5VX1 $T=-51400 -394240 0 0 $X=-51830 $Y=-394880
X16286 2 1 1502 805 BU_5VX1 $T=-11080 -421120 1 0 $X=-11510 $Y=-426240
X16287 2 1 2137 2876 BU_5VX1 $T=13000 -313600 1 0 $X=12570 $Y=-318720
X16288 2 1 1781 2878 BU_5VX1 $T=13560 -295680 0 0 $X=13130 $Y=-296320
X16289 2 1 1743 1760 BU_5VX1 $T=21960 -286720 1 0 $X=21530 $Y=-291840
X16290 2 1 2891 1822 BU_5VX1 $T=27560 -403200 1 0 $X=27130 $Y=-408320
X16291 2 1 349 1843 BU_5VX1 $T=34840 -412160 1 0 $X=34410 $Y=-417280
X16292 2 1 1843 1828 BU_5VX1 $T=43800 -421120 0 0 $X=43370 $Y=-421760
X16293 2 1 1691 804 BU_5VX1 $T=56680 -403200 0 0 $X=56250 $Y=-403840
X16294 2 1 3239 2931 BU_5VX1 $T=57800 -412160 1 0 $X=57370 $Y=-417280
X16295 2 1 2931 1904 BU_5VX1 $T=58360 -403200 1 0 $X=57930 $Y=-408320
X16296 2 1 373 1930 BU_5VX1 $T=62280 -367360 1 0 $X=61850 $Y=-372480
X16297 2 1 1904 1669 BU_5VX1 $T=63400 -421120 0 0 $X=62970 $Y=-421760
X16298 2 1 381 1936 BU_5VX1 $T=71800 -421120 1 0 $X=71370 $Y=-426240
X16299 2 1 1930 1914 BU_5VX1 $T=71800 -367360 1 0 $X=71370 $Y=-372480
X16300 2 1 1945 1942 BU_5VX1 $T=75160 -412160 1 0 $X=74730 $Y=-417280
X16301 2 1 1892 1946 BU_5VX1 $T=80760 -394240 1 0 $X=80330 $Y=-399360
X16302 2 1 1936 1927 BU_5VX1 $T=85800 -421120 0 0 $X=85370 $Y=-421760
X16303 2 1 2993 3241 BU_5VX1 $T=111560 -358400 0 0 $X=111130 $Y=-359040
X16304 2 1 416 2025 BU_5VX1 $T=114920 -403200 1 0 $X=114490 $Y=-408320
X16305 2 1 3029 2111 BU_5VX1 $T=167000 -385280 1 0 $X=166570 $Y=-390400
X16306 2 1 2163 2160 BU_5VX1 $T=186600 -331520 1 0 $X=186170 $Y=-336640
X16307 2 1 3041 2172 BU_5VX1 $T=191080 -385280 1 0 $X=190650 $Y=-390400
X16308 2 1 492 3041 BU_5VX1 $T=193880 -385280 1 0 $X=193450 $Y=-390400
X16309 2 1 2188 2196 BU_5VX1 $T=198360 -394240 0 0 $X=197930 $Y=-394880
X16310 2 1 2221 526 BU_5VX1 $T=210120 -385280 0 0 $X=209690 $Y=-385920
X16311 2 1 527 2229 BU_5VX1 $T=212920 -385280 0 0 $X=212490 $Y=-385920
X16312 2 1 530 2188 BU_5VX1 $T=215720 -385280 0 0 $X=215290 $Y=-385920
X16313 2 1 548 2230 BU_5VX1 $T=225800 -349440 1 0 $X=225370 $Y=-354560
X16314 2 1 2247 2237 BU_5VX1 $T=231960 -394240 1 0 $X=231530 $Y=-399360
X16315 2 1 3068 3245 BU_5VX1 $T=239800 -349440 1 0 $X=239370 $Y=-354560
X16316 2 1 580 3068 BU_5VX1 $T=242600 -349440 1 0 $X=242170 $Y=-354560
X16317 2 1 589 2284 BU_5VX1 $T=251560 -376320 1 0 $X=251130 $Y=-381440
X16318 2 1 3079 2288 BU_5VX1 $T=266680 -367360 0 0 $X=266250 $Y=-368000
X16319 2 1 2318 3091 BU_5VX1 $T=279560 -358400 1 0 $X=279130 $Y=-363520
X16320 2 1 3095 635 BU_5VX1 $T=287400 -349440 0 0 $X=286970 $Y=-350080
X16321 2 1 2210 2400 BU_5VX1 $T=346760 -340480 1 0 $X=346330 $Y=-345600
X16322 2 1 516 692 BU_5VX1 $T=378120 -322560 0 0 $X=377690 $Y=-323200
X16323 2 1 525 693 BU_5VX1 $T=383720 -331520 0 0 $X=383290 $Y=-332160
X16324 2 1 827 2492 BU_5VX2 $T=-440040 -304640 1 0 $X=-440470 $Y=-309760
X16325 2 1 1104 1152 BU_5VX2 $T=-249080 -394240 1 0 $X=-249510 $Y=-399360
X16326 2 1 1443 1490 BU_5VX2 $T=-97320 -313600 0 0 $X=-97750 $Y=-314240
X16327 2 1 1732 1745 BU_5VX2 $T=-7720 -277760 0 0 $X=-8150 $Y=-278400
X16328 2 1 1754 1812 BU_5VX2 $T=23640 -295680 1 0 $X=23210 $Y=-300800
X16329 2 1 1580 1810 BU_5VX2 $T=59480 -421120 0 0 $X=59050 $Y=-421760
X16330 2 1 2208 2221 BU_5VX2 $T=216840 -412160 1 0 $X=216410 $Y=-417280
X16331 2 1 2229 2205 BU_5VX2 $T=234760 -394240 1 0 $X=234330 $Y=-399360
X16332 2 1 2408 2410 BU_5VX2 $T=379800 -331520 1 0 $X=379370 $Y=-336640
X16333 2 1 2527 61 BU_5VX0 $T=-368920 -277760 0 0 $X=-369350 $Y=-278400
X16334 2 1 1131 2638 BU_5VX0 $T=-254680 -412160 0 0 $X=-255110 $Y=-412800
X16335 2 1 1423 3232 BU_5VX0 $T=-143800 -412160 1 0 $X=-144230 $Y=-417280
X16336 2 1 1471 2757 BU_5VX0 $T=-122520 -412160 0 0 $X=-122950 $Y=-412800
X16337 2 1 1476 2758 BU_5VX0 $T=-122520 -403200 0 0 $X=-122950 $Y=-403840
X16338 2 1 1483 1481 BU_5VX0 $T=-118600 -412160 1 0 $X=-119030 $Y=-417280
X16339 2 1 781 1493 BU_5VX0 $T=-106280 -367360 0 0 $X=-106710 $Y=-368000
X16340 2 1 1489 1150 BU_5VX0 $T=-106280 -358400 0 0 $X=-106710 $Y=-359040
X16341 2 1 240 2704 BU_5VX0 $T=-106280 -304640 1 0 $X=-106710 $Y=-309760
X16342 2 1 1678 1625 BU_5VX0 $T=-48040 -385280 1 0 $X=-48470 $Y=-390400
X16343 2 1 1735 1743 BU_5VX0 $T=-6600 -295680 0 0 $X=-7030 $Y=-296320
X16344 2 1 2868 1768 BU_5VX0 $T=6280 -313600 1 0 $X=5850 $Y=-318720
X16345 2 1 1838 1721 BU_5VX0 $T=35400 -394240 1 0 $X=34970 $Y=-399360
X16346 2 1 1851 1838 BU_5VX0 $T=38760 -403200 1 0 $X=38330 $Y=-408320
X16347 2 1 1854 1851 BU_5VX0 $T=51080 -394240 1 0 $X=50650 $Y=-399360
X16348 2 1 413 2993 BU_5VX0 $T=111000 -349440 1 0 $X=110570 $Y=-354560
X16349 2 1 456 3029 BU_5VX0 $T=163640 -385280 0 0 $X=163210 $Y=-385920
X16350 2 1 2148 2163 BU_5VX0 $T=177640 -331520 0 0 $X=177210 $Y=-332160
X16351 2 1 2153 477 BU_5VX0 $T=180440 -394240 0 0 $X=180010 $Y=-394880
X16352 2 1 2156 3045 BU_5VX0 $T=196120 -295680 1 0 $X=195690 $Y=-300800
X16353 2 1 2300 3079 BU_5VX0 $T=263880 -367360 0 0 $X=263450 $Y=-368000
X16354 2 1 3091 2319 BU_5VX0 $T=282360 -358400 1 0 $X=281930 $Y=-363520
X16355 2 1 3098 647 BU_5VX0 $T=301400 -322560 1 0 $X=300970 $Y=-327680
X16356 2 1 2343 2339 BU_5VX0 $T=310920 -331520 1 0 $X=310490 $Y=-336640
X16357 2 1 2410 691 BU_5VX0 $T=377000 -331520 1 0 $X=376570 $Y=-336640
X16358 2 1 829 67 DLY2_5VX1 $T=-348200 -295680 0 0 $X=-348630 $Y=-296320
X16359 2 1 946 83 DLY2_5VX1 $T=-329160 -322560 1 0 $X=-329590 $Y=-327680
X16360 2 1 95 1005 DLY2_5VX1 $T=-311240 -385280 1 0 $X=-311670 $Y=-390400
X16361 2 1 93 1004 DLY2_5VX1 $T=-310120 -376320 0 0 $X=-310550 $Y=-376960
X16362 2 1 109 1017 DLY2_5VX1 $T=-304520 -385280 0 0 $X=-304950 $Y=-385920
X16363 2 1 119 123 DLY2_5VX1 $T=-289400 -331520 1 0 $X=-289830 $Y=-336640
X16364 2 1 966 1091 DLY2_5VX1 $T=-277080 -385280 1 0 $X=-277510 $Y=-390400
X16365 2 1 1078 134 DLY2_5VX1 $T=-274280 -277760 1 0 $X=-274710 $Y=-282880
X16366 2 1 953 131 DLY2_5VX1 $T=-273720 -367360 0 0 $X=-274150 $Y=-368000
X16367 2 1 839 141 DLY2_5VX1 $T=-267560 -286720 0 0 $X=-267990 $Y=-287360
X16368 2 1 845 156 DLY2_5VX1 $T=-253000 -277760 1 0 $X=-253430 $Y=-282880
X16369 2 1 1150 783 DLY2_5VX1 $T=-247960 -358400 1 0 $X=-248390 $Y=-363520
X16370 2 1 766 163 DLY2_5VX1 $T=-241800 -295680 1 0 $X=-242230 $Y=-300800
X16371 2 1 1005 172 DLY2_5VX1 $T=-231720 -340480 1 0 $X=-232150 $Y=-345600
X16372 2 1 1017 175 DLY2_5VX1 $T=-230040 -367360 0 0 $X=-230470 $Y=-368000
X16373 2 1 1203 1505 DLY2_5VX1 $T=-229480 -421120 0 0 $X=-229910 $Y=-421760
X16374 2 1 950 1292 DLY2_5VX1 $T=-204280 -376320 1 0 $X=-204710 $Y=-381440
X16375 2 1 1032 199 DLY2_5VX1 $T=-193640 -286720 0 0 $X=-194070 $Y=-287360
X16376 2 1 1004 202 DLY2_5VX1 $T=-187480 -376320 0 0 $X=-187910 $Y=-376960
X16377 2 1 3215 203 DLY2_5VX1 $T=-186360 -340480 0 0 $X=-186790 $Y=-341120
X16378 2 1 207 778 DLY2_5VX1 $T=-174600 -421120 1 0 $X=-175030 $Y=-426240
X16379 2 1 1359 1369 DLY2_5VX1 $T=-169000 -412160 0 0 $X=-169430 $Y=-412800
X16380 2 1 2704 217 DLY2_5VX1 $T=-169000 -385280 1 0 $X=-169430 $Y=-390400
X16381 2 1 1014 216 DLY2_5VX1 $T=-167880 -349440 0 0 $X=-168310 $Y=-350080
X16382 2 1 1384 1403 DLY2_5VX1 $T=-158360 -403200 0 0 $X=-158790 $Y=-403840
X16383 2 1 1387 1434 DLY2_5VX1 $T=-148280 -385280 0 0 $X=-148710 $Y=-385920
X16384 2 1 3232 1448 DLY2_5VX1 $T=-141000 -412160 1 0 $X=-141430 $Y=-417280
X16385 2 1 232 238 DLY2_5VX1 $T=-134840 -277760 1 0 $X=-135270 $Y=-282880
X16386 2 1 1091 239 DLY2_5VX1 $T=-121960 -304640 1 0 $X=-122390 $Y=-309760
X16387 2 1 1481 2764 DLY2_5VX1 $T=-119720 -421120 1 0 $X=-120150 $Y=-426240
X16388 2 1 2757 1488 DLY2_5VX1 $T=-119720 -412160 0 0 $X=-120150 $Y=-412800
X16389 2 1 2758 1492 DLY2_5VX1 $T=-119720 -403200 0 0 $X=-120150 $Y=-403840
X16390 2 1 1581 1529 DLY2_5VX1 $T=-65400 -412160 0 0 $X=-65830 $Y=-412800
X16391 2 1 1572 1552 DLY2_5VX1 $T=-63160 -394240 1 0 $X=-63590 $Y=-399360
X16392 2 1 1822 322 DLY2_5VX1 $T=-10520 -403200 1 0 $X=-10950 $Y=-408320
X16393 2 1 1734 323 DLY2_5VX1 $T=-7720 -349440 1 0 $X=-8150 $Y=-354560
X16394 2 1 1740 1756 DLY2_5VX1 $T=-3800 -322560 0 0 $X=-4230 $Y=-323200
X16395 2 1 329 1734 DLY2_5VX1 $T=7960 -412160 1 0 $X=7530 $Y=-417280
X16396 2 1 333 1791 DLY2_5VX1 $T=11320 -394240 1 0 $X=10890 $Y=-399360
X16397 2 1 2795 2891 DLY2_5VX1 $T=19160 -412160 0 0 $X=18730 $Y=-412800
X16398 2 1 1841 358 DLY2_5VX1 $T=36520 -340480 0 0 $X=36090 $Y=-341120
X16399 2 1 1842 359 DLY2_5VX1 $T=36520 -304640 1 0 $X=36090 $Y=-309760
X16400 2 1 2918 367 DLY2_5VX1 $T=47160 -421120 1 0 $X=46730 $Y=-426240
X16401 2 1 361 1892 DLY2_5VX1 $T=47720 -358400 0 0 $X=47290 $Y=-359040
X16402 2 1 2949 1753 DLY2_5VX1 $T=74600 -313600 0 0 $X=74170 $Y=-314240
X16403 2 1 1946 1575 DLY2_5VX1 $T=75720 -385280 1 0 $X=75290 $Y=-390400
X16404 2 1 391 1841 DLY2_5VX1 $T=78520 -367360 1 0 $X=78090 $Y=-372480
X16405 2 1 805 1519 DLY2_5VX1 $T=85240 -421120 1 0 $X=84810 $Y=-426240
X16406 2 1 431 435 DLY2_5VX1 $T=128920 -421120 1 0 $X=128490 $Y=-426240
X16407 2 1 2065 436 DLY2_5VX1 $T=128920 -394240 1 0 $X=128490 $Y=-399360
X16408 2 1 433 437 DLY2_5VX1 $T=128920 -322560 0 0 $X=128490 $Y=-323200
X16409 2 1 445 2084 DLY2_5VX1 $T=151880 -412160 1 0 $X=151450 $Y=-417280
X16410 2 1 444 2081 DLY2_5VX1 $T=151880 -403200 0 0 $X=151450 $Y=-403840
X16411 2 1 2081 452 DLY2_5VX1 $T=151880 -340480 0 0 $X=151450 $Y=-341120
X16412 2 1 2084 451 DLY2_5VX1 $T=151880 -295680 1 0 $X=151450 $Y=-300800
X16413 2 1 1791 2918 DLY2_5VX1 $T=162520 -421120 0 0 $X=162090 $Y=-421760
X16414 2 1 2204 461 DLY2_5VX1 $T=164760 -277760 1 0 $X=164330 $Y=-282880
X16415 2 1 464 2153 DLY2_5VX1 $T=171480 -394240 1 0 $X=171050 $Y=-399360
X16416 2 1 504 512 DLY2_5VX1 $T=200040 -349440 0 0 $X=199610 $Y=-350080
X16417 2 1 508 2065 DLY2_5VX1 $T=206200 -421120 0 0 $X=205770 $Y=-421760
X16418 2 1 2256 1900 DLY2_5VX1 $T=233080 -394240 0 0 $X=232650 $Y=-394880
X16419 2 1 569 579 DLY2_5VX1 $T=236440 -385280 1 0 $X=236010 $Y=-390400
X16420 2 1 582 2267 DLY2_5VX1 $T=243720 -385280 0 0 $X=243290 $Y=-385920
X16421 2 1 2284 2281 DLY2_5VX1 $T=243720 -376320 1 0 $X=243290 $Y=-381440
X16422 2 1 597 602 DLY2_5VX1 $T=256600 -349440 0 0 $X=256170 $Y=-350080
X16423 2 1 599 609 DLY2_5VX1 $T=262760 -277760 0 0 $X=262330 $Y=-278400
X16424 2 1 606 610 DLY2_5VX1 $T=267240 -331520 1 0 $X=266810 $Y=-336640
X16425 2 1 611 2318 DLY2_5VX1 $T=276200 -358400 0 0 $X=275770 $Y=-359040
X16426 2 1 2319 630 DLY2_5VX1 $T=280120 -313600 0 0 $X=279690 $Y=-314240
X16427 2 1 629 636 DLY2_5VX1 $T=285160 -358400 1 0 $X=284730 $Y=-363520
X16428 2 1 2327 640 DLY2_5VX1 $T=288520 -277760 1 0 $X=288090 $Y=-282880
X16429 2 1 645 2343 DLY2_5VX1 $T=302520 -340480 0 0 $X=302090 $Y=-341120
X16430 2 1 2339 655 DLY2_5VX1 $T=304200 -286720 1 0 $X=303770 $Y=-291840
X16431 2 1 662 665 DLY2_5VX1 $T=322120 -322560 0 0 $X=321690 $Y=-323200
X16432 2 1 668 673 DLY2_5VX1 $T=335000 -331520 0 0 $X=334570 $Y=-332160
X16433 2 1 2492 829 DLY4_5VX1 $T=-436680 -304640 0 0 $X=-437110 $Y=-305280
X16434 2 1 2493 1137 DLY4_5VX1 $T=-430520 -313600 1 0 $X=-430950 $Y=-318720
X16435 2 1 42 46 DLY4_5VX1 $T=-397480 -304640 1 0 $X=-397910 $Y=-309760
X16436 2 1 45 54 DLY4_5VX1 $T=-388520 -304640 0 0 $X=-388950 $Y=-305280
X16437 2 1 57 903 DLY4_5VX1 $T=-372280 -304640 0 0 $X=-372710 $Y=-305280
X16438 2 1 65 70 DLY4_5VX1 $T=-348200 -358400 0 0 $X=-348630 $Y=-359040
X16439 2 1 68 944 DLY4_5VX1 $T=-338120 -322560 0 0 $X=-338550 $Y=-323200
X16440 2 1 930 950 DLY4_5VX1 $T=-337000 -412160 0 0 $X=-337430 $Y=-412800
X16441 2 1 71 953 DLY4_5VX1 $T=-336440 -412160 1 0 $X=-336870 $Y=-417280
X16442 2 1 74 966 DLY4_5VX1 $T=-330280 -421120 0 0 $X=-330710 $Y=-421760
X16443 2 1 81 969 DLY4_5VX1 $T=-328600 -421120 1 0 $X=-329030 $Y=-426240
X16444 2 1 78 3215 DLY4_5VX1 $T=-326360 -403200 1 0 $X=-326790 $Y=-408320
X16445 2 1 84 1078 DLY4_5VX1 $T=-320760 -412160 0 0 $X=-321190 $Y=-412800
X16446 2 1 102 1144 DLY4_5VX1 $T=-304520 -412160 0 0 $X=-304950 $Y=-412800
X16447 2 1 112 120 DLY4_5VX1 $T=-296680 -412160 1 0 $X=-297110 $Y=-417280
X16448 2 1 117 1056 DLY4_5VX1 $T=-294440 -394240 1 0 $X=-294870 $Y=-399360
X16449 2 1 114 1052 DLY4_5VX1 $T=-293880 -412160 0 0 $X=-294310 $Y=-412800
X16450 2 1 118 127 DLY4_5VX1 $T=-287160 -394240 0 0 $X=-287590 $Y=-394880
X16451 2 1 1044 1070 DLY4_5VX1 $T=-286600 -403200 0 0 $X=-287030 $Y=-403840
X16452 2 1 903 130 DLY4_5VX1 $T=-284920 -304640 0 0 $X=-285350 $Y=-305280
X16453 2 1 1144 159 DLY4_5VX1 $T=-250760 -313600 1 0 $X=-251190 $Y=-318720
X16454 2 1 1052 180 DLY4_5VX1 $T=-222760 -322560 1 0 $X=-223190 $Y=-327680
X16455 2 1 944 211 DLY4_5VX1 $T=-182440 -304640 0 0 $X=-182870 $Y=-305280
X16456 2 1 1056 213 DLY4_5VX1 $T=-173480 -358400 1 0 $X=-173910 $Y=-363520
X16457 2 1 1376 222 DLY4_5VX1 $T=-161160 -421120 1 0 $X=-161590 $Y=-426240
X16458 2 1 1505 247 DLY4_5VX1 $T=-93400 -385280 1 0 $X=-93830 $Y=-390400
X16459 2 1 250 2795 DLY4_5VX1 $T=-81080 -367360 0 0 $X=-81510 $Y=-368000
X16460 2 1 1548 1732 DLY4_5VX1 $T=-79960 -286720 1 0 $X=-80390 $Y=-291840
X16461 2 1 254 263 DLY4_5VX1 $T=-76600 -403200 1 0 $X=-77030 $Y=-408320
X16462 2 1 1575 271 DLY4_5VX1 $T=-69320 -331520 1 0 $X=-69750 $Y=-336640
X16463 2 1 266 276 DLY4_5VX1 $T=-65400 -385280 1 0 $X=-65830 $Y=-390400
X16464 2 1 1705 317 DLY4_5VX1 $T=-20040 -313600 1 0 $X=-20470 $Y=-318720
X16465 2 1 1755 330 DLY4_5VX1 $T=-1560 -349440 0 0 $X=-1990 $Y=-350080
X16466 2 1 1760 1771 DLY4_5VX1 $T=2920 -295680 0 0 $X=2490 $Y=-296320
X16467 2 1 2104 352 DLY4_5VX1 $T=31480 -367360 1 0 $X=31050 $Y=-372480
X16468 2 1 2192 365 DLY4_5VX1 $T=38200 -286720 1 0 $X=37770 $Y=-291840
X16469 2 1 2101 362 DLY4_5VX1 $T=39880 -367360 0 0 $X=39450 $Y=-368000
X16470 2 1 1881 370 DLY4_5VX1 $T=50520 -277760 0 0 $X=50090 $Y=-278400
X16471 2 1 377 382 DLY4_5VX1 $T=65080 -403200 1 0 $X=64650 $Y=-408320
X16472 2 1 1942 1504 DLY4_5VX1 $T=74600 -421120 1 0 $X=74170 $Y=-426240
X16473 2 1 389 399 DLY4_5VX1 $T=78520 -412160 0 0 $X=78090 $Y=-412800
X16474 2 1 393 402 DLY4_5VX1 $T=85240 -367360 0 0 $X=84810 $Y=-368000
X16475 2 1 2005 412 DLY4_5VX1 $T=100920 -304640 0 0 $X=100490 $Y=-305280
X16476 2 1 409 420 DLY4_5VX1 $T=106520 -403200 0 0 $X=106090 $Y=-403840
X16477 2 1 427 1705 DLY4_5VX1 $T=125560 -421120 0 0 $X=125130 $Y=-421760
X16478 2 1 430 439 DLY4_5VX1 $T=127800 -277760 0 0 $X=127370 $Y=-278400
X16479 2 1 441 453 DLY4_5VX1 $T=151880 -421120 1 0 $X=151450 $Y=-426240
X16480 2 1 442 2101 DLY4_5VX1 $T=151880 -421120 0 0 $X=151450 $Y=-421760
X16481 2 1 440 2104 DLY4_5VX1 $T=151880 -412160 0 0 $X=151450 $Y=-412800
X16482 2 1 443 1755 DLY4_5VX1 $T=151880 -403200 1 0 $X=151450 $Y=-408320
X16483 2 1 2086 1754 DLY4_5VX1 $T=154680 -322560 0 0 $X=154250 $Y=-323200
X16484 2 1 454 1881 DLY4_5VX1 $T=162520 -421120 1 0 $X=162090 $Y=-426240
X16485 2 1 2122 2130 DLY4_5VX1 $T=170360 -421120 0 0 $X=169930 $Y=-421760
X16486 2 1 465 473 DLY4_5VX1 $T=173160 -421120 1 0 $X=172730 $Y=-426240
X16487 2 1 466 478 DLY4_5VX1 $T=173720 -358400 0 0 $X=173290 $Y=-359040
X16488 2 1 814 2132 DLY4_5VX1 $T=174280 -412160 1 0 $X=173850 $Y=-417280
X16489 2 1 467 483 DLY4_5VX1 $T=178200 -412160 0 0 $X=177770 $Y=-412800
X16490 2 1 471 488 DLY4_5VX1 $T=180440 -403200 1 0 $X=180010 $Y=-408320
X16491 2 1 2113 2116 DLY4_5VX1 $T=181000 -421120 0 0 $X=180570 $Y=-421760
X16492 2 1 480 497 DLY4_5VX1 $T=184920 -412160 1 0 $X=184490 $Y=-417280
X16493 2 1 484 500 DLY4_5VX1 $T=188840 -412160 0 0 $X=188410 $Y=-412800
X16494 2 1 2126 2129 DLY4_5VX1 $T=188840 -403200 0 0 $X=188410 $Y=-403840
X16495 2 1 487 2192 DLY4_5VX1 $T=191080 -403200 1 0 $X=190650 $Y=-408320
X16496 2 1 2125 2121 DLY4_5VX1 $T=193880 -394240 1 0 $X=193450 $Y=-399360
X16497 2 1 2120 2123 DLY4_5VX1 $T=195560 -412160 1 0 $X=195130 $Y=-417280
X16498 2 1 502 521 DLY4_5VX1 $T=199480 -403200 0 0 $X=199050 $Y=-403840
X16499 2 1 3045 1767 DLY4_5VX1 $T=201160 -304640 0 0 $X=200730 $Y=-305280
X16500 2 1 2114 2118 DLY4_5VX1 $T=204520 -394240 1 0 $X=204090 $Y=-399360
X16501 2 1 507 1842 DLY4_5VX1 $T=206200 -412160 1 0 $X=205770 $Y=-417280
X16502 2 1 515 541 DLY4_5VX1 $T=210120 -403200 0 0 $X=209690 $Y=-403840
X16503 2 1 519 539 DLY4_5VX1 $T=211240 -385280 1 0 $X=210810 $Y=-390400
X16504 2 1 533 2005 DLY4_5VX1 $T=215160 -394240 1 0 $X=214730 $Y=-399360
X16505 2 1 2244 551 DLY4_5VX1 $T=216280 -403200 1 0 $X=215850 $Y=-408320
X16506 2 1 536 553 DLY4_5VX1 $T=218520 -385280 0 0 $X=218090 $Y=-385920
X16507 2 1 2237 559 DLY4_5VX1 $T=220760 -403200 0 0 $X=220330 $Y=-403840
X16508 2 1 542 562 DLY4_5VX1 $T=222440 -376320 1 0 $X=222010 $Y=-381440
X16509 2 1 561 576 DLY4_5VX1 $T=231400 -367360 1 0 $X=230970 $Y=-372480
X16510 2 1 2124 2127 DLY4_5VX1 $T=233080 -376320 1 0 $X=232650 $Y=-381440
X16511 2 1 2112 2117 DLY4_5VX1 $T=233640 -376320 0 0 $X=233210 $Y=-376960
X16512 2 1 2267 588 DLY4_5VX1 $T=242040 -367360 1 0 $X=241610 $Y=-372480
X16513 2 1 2293 594 DLY4_5VX1 $T=246520 -304640 1 0 $X=246090 $Y=-309760
X16514 2 1 587 2293 DLY4_5VX1 $T=247080 -367360 0 0 $X=246650 $Y=-368000
X16515 2 1 2288 600 DLY4_5VX1 $T=252680 -367360 1 0 $X=252250 $Y=-372480
X16516 2 1 591 601 DLY4_5VX1 $T=253800 -358400 1 0 $X=253370 $Y=-363520
X16517 2 1 604 615 DLY4_5VX1 $T=268360 -358400 1 0 $X=267930 $Y=-363520
X16518 2 1 621 631 DLY4_5VX1 $T=279560 -349440 1 0 $X=279130 $Y=-354560
X16519 2 1 2323 637 DLY4_5VX1 $T=283480 -331520 0 0 $X=283050 $Y=-332160
X16520 2 1 626 2323 DLY4_5VX1 $T=284040 -358400 0 0 $X=283610 $Y=-359040
X16521 2 1 633 641 DLY4_5VX1 $T=290200 -349440 0 0 $X=289770 $Y=-350080
X16522 2 1 2329 649 DLY4_5VX1 $T=294120 -313600 0 0 $X=293690 $Y=-314240
X16523 2 1 639 2329 DLY4_5VX1 $T=294680 -340480 1 0 $X=294250 $Y=-345600
X16524 2 1 644 2327 DLY4_5VX1 $T=300840 -349440 0 0 $X=300410 $Y=-350080
X16525 2 1 678 684 DLY4_5VX1 $T=354600 -358400 0 0 $X=354170 $Y=-359040
X16526 2 1 713 722 DLY4_5VX1 $T=436920 -277760 0 0 $X=436490 $Y=-278400
X16527 2 1 3 6 DLY8_5VX1 $T=-452920 -286720 1 0 $X=-453350 $Y=-291840
X16528 2 1 822 3216 DLY8_5VX1 $T=-452920 -277760 0 0 $X=-453350 $Y=-278400
X16529 2 1 4 10 DLY8_5VX1 $T=-449000 -295680 0 0 $X=-449430 $Y=-296320
X16530 2 1 5 11 DLY8_5VX1 $T=-446760 -286720 0 0 $X=-447190 $Y=-287360
X16531 2 1 7 16 DLY8_5VX1 $T=-438360 -277760 1 0 $X=-438790 $Y=-282880
X16532 2 1 824 826 DLY8_5VX1 $T=-437240 -295680 1 0 $X=-437670 $Y=-300800
X16533 2 1 13 22 DLY8_5VX1 $T=-432760 -313600 0 0 $X=-433190 $Y=-314240
X16534 2 1 18 839 DLY8_5VX1 $T=-428840 -304640 1 0 $X=-429270 $Y=-309760
X16535 2 1 15 840 DLY8_5VX1 $T=-428280 -322560 0 0 $X=-428710 $Y=-323200
X16536 2 1 30 845 DLY8_5VX1 $T=-415400 -331520 0 0 $X=-415830 $Y=-332160
X16537 2 1 27 39 DLY8_5VX1 $T=-412600 -340480 0 0 $X=-413030 $Y=-341120
X16538 2 1 28 40 DLY8_5VX1 $T=-412040 -322560 1 0 $X=-412470 $Y=-327680
X16539 2 1 29 41 DLY8_5VX1 $T=-410920 -331520 1 0 $X=-411350 $Y=-336640
X16540 2 1 56 62 DLY8_5VX1 $T=-376200 -349440 1 0 $X=-376630 $Y=-354560
X16541 2 1 63 73 DLY8_5VX1 $T=-345960 -304640 0 0 $X=-346390 $Y=-305280
X16542 2 1 79 766 DLY8_5VX1 $T=-325800 -412160 1 0 $X=-326230 $Y=-417280
X16543 2 1 86 100 DLY8_5VX1 $T=-319640 -421120 0 0 $X=-320070 $Y=-421760
X16544 2 1 88 108 DLY8_5VX1 $T=-317960 -421120 1 0 $X=-318390 $Y=-426240
X16545 2 1 96 1014 DLY8_5VX1 $T=-311240 -412160 1 0 $X=-311670 $Y=-417280
X16546 2 1 101 116 DLY8_5VX1 $T=-305080 -421120 0 0 $X=-305510 $Y=-421760
X16547 2 1 103 1032 DLY8_5VX1 $T=-303400 -421120 1 0 $X=-303830 $Y=-426240
X16548 2 1 2597 129 DLY8_5VX1 $T=-289400 -277760 1 0 $X=-289830 $Y=-282880
X16549 2 1 1041 1076 DLY8_5VX1 $T=-287720 -421120 0 0 $X=-288150 $Y=-421760
X16550 2 1 2606 1089 DLY8_5VX1 $T=-283240 -412160 1 0 $X=-283670 $Y=-417280
X16551 2 1 1050 132 DLY8_5VX1 $T=-283240 -412160 0 0 $X=-283670 $Y=-412800
X16552 2 1 124 136 DLY8_5VX1 $T=-281560 -331520 1 0 $X=-281990 $Y=-336640
X16553 2 1 1065 138 DLY8_5VX1 $T=-279880 -421120 1 0 $X=-280310 $Y=-426240
X16554 2 1 1080 1113 DLY8_5VX1 $T=-273160 -421120 0 0 $X=-273590 $Y=-421760
X16555 2 1 1152 1129 DLY8_5VX1 $T=-268680 -412160 1 0 $X=-269110 $Y=-417280
X16556 2 1 137 144 DLY8_5VX1 $T=-267000 -331520 1 0 $X=-267430 $Y=-336640
X16557 2 1 1103 1138 DLY8_5VX1 $T=-265320 -421120 1 0 $X=-265750 $Y=-426240
X16558 2 1 139 145 DLY8_5VX1 $T=-264760 -394240 0 0 $X=-265190 $Y=-394880
X16559 2 1 142 148 DLY8_5VX1 $T=-260280 -358400 0 0 $X=-260710 $Y=-359040
X16560 2 1 1116 1157 DLY8_5VX1 $T=-258600 -421120 0 0 $X=-259030 $Y=-421760
X16561 2 1 1122 1159 DLY8_5VX1 $T=-257480 -376320 1 0 $X=-257910 $Y=-381440
X16562 2 1 1145 161 DLY8_5VX1 $T=-250760 -421120 1 0 $X=-251190 $Y=-426240
X16563 2 1 160 169 DLY8_5VX1 $T=-239560 -403200 1 0 $X=-239990 $Y=-408320
X16564 2 1 1176 1215 DLY8_5VX1 $T=-236200 -421120 1 0 $X=-236630 $Y=-426240
X16565 2 1 1222 1254 DLY8_5VX1 $T=-221640 -421120 1 0 $X=-222070 $Y=-426240
X16566 2 1 1227 1257 DLY8_5VX1 $T=-221080 -403200 0 0 $X=-221510 $Y=-403840
X16567 2 1 177 183 DLY8_5VX1 $T=-221080 -367360 1 0 $X=-221510 $Y=-372480
X16568 2 1 2662 1266 DLY8_5VX1 $T=-218840 -421120 0 0 $X=-219270 $Y=-421760
X16569 2 1 1245 1287 DLY8_5VX1 $T=-213800 -412160 1 0 $X=-214230 $Y=-417280
X16570 2 1 1261 1433 DLY8_5VX1 $T=-207080 -421120 1 0 $X=-207510 $Y=-426240
X16571 2 1 1273 194 DLY8_5VX1 $T=-204280 -421120 0 0 $X=-204710 $Y=-421760
X16572 2 1 1149 1166 DLY8_5VX1 $T=-202040 -331520 1 0 $X=-202470 $Y=-336640
X16573 2 1 1320 206 DLY8_5VX1 $T=-189720 -421120 0 0 $X=-190150 $Y=-421760
X16574 2 1 1335 1418 DLY8_5VX1 $T=-178520 -340480 0 0 $X=-178950 $Y=-341120
X16575 2 1 208 220 DLY8_5VX1 $T=-171800 -304640 0 0 $X=-172230 $Y=-305280
X16576 2 1 1383 1420 DLY8_5VX1 $T=-156680 -421120 0 0 $X=-157110 $Y=-421760
X16577 2 1 219 230 DLY8_5VX1 $T=-155560 -295680 1 0 $X=-155990 $Y=-300800
X16578 2 1 224 231 DLY8_5VX1 $T=-150520 -421120 1 0 $X=-150950 $Y=-426240
X16579 2 1 1408 2741 DLY8_5VX1 $T=-150520 -403200 0 0 $X=-150950 $Y=-403840
X16580 2 1 1419 1432 DLY8_5VX1 $T=-142680 -313600 1 0 $X=-143110 $Y=-318720
X16581 2 1 1430 1429 DLY8_5VX1 $T=-142120 -421120 0 0 $X=-142550 $Y=-421760
X16582 2 1 2740 2752 DLY8_5VX1 $T=-140440 -385280 0 0 $X=-140870 $Y=-385920
X16583 2 1 1441 1442 DLY8_5VX1 $T=-135960 -421120 1 0 $X=-136390 $Y=-426240
X16584 2 1 1444 1462 DLY8_5VX1 $T=-133160 -412160 1 0 $X=-133590 $Y=-417280
X16585 2 1 1437 1446 DLY8_5VX1 $T=-131480 -349440 1 0 $X=-131910 $Y=-354560
X16586 2 1 1450 1454 DLY8_5VX1 $T=-127560 -421120 0 0 $X=-127990 $Y=-421760
X16587 2 1 1474 1473 DLY8_5VX1 $T=-97880 -421120 1 0 $X=-98310 $Y=-426240
X16588 2 1 1508 248 DLY8_5VX1 $T=-97880 -412160 0 0 $X=-98310 $Y=-412800
X16589 2 1 3252 1472 DLY8_5VX1 $T=-97880 -286720 1 0 $X=-98310 $Y=-291840
X16590 2 1 1499 1506 DLY8_5VX1 $T=-95640 -421120 0 0 $X=-96070 $Y=-421760
X16591 2 1 1440 1452 DLY8_5VX1 $T=-93960 -403200 0 0 $X=-94390 $Y=-403840
X16592 2 1 2772 1509 DLY8_5VX1 $T=-91720 -412160 1 0 $X=-92150 $Y=-417280
X16593 2 1 260 275 DLY8_5VX1 $T=-70440 -295680 0 0 $X=-70870 $Y=-296320
X16594 2 1 279 298 DLY8_5VX1 $T=-51960 -295680 0 0 $X=-52390 $Y=-296320
X16595 2 1 319 328 DLY8_5VX1 $T=-7720 -385280 1 0 $X=-8150 $Y=-390400
X16596 2 1 336 341 DLY8_5VX1 $T=9640 -349440 0 0 $X=9210 $Y=-350080
X16597 2 1 1828 357 DLY8_5VX1 $T=32600 -421120 1 0 $X=32170 $Y=-426240
X16598 2 1 369 379 DLY8_5VX1 $T=53320 -304640 1 0 $X=52890 $Y=-309760
X16599 2 1 376 390 DLY8_5VX1 $T=65080 -295680 0 0 $X=64650 $Y=-296320
X16600 2 1 1914 386 DLY8_5VX1 $T=65640 -376320 0 0 $X=65210 $Y=-376960
X16601 2 1 1927 392 DLY8_5VX1 $T=71240 -421120 0 0 $X=70810 $Y=-421760
X16602 2 1 387 403 DLY8_5VX1 $T=79640 -304640 1 0 $X=79210 $Y=-309760
X16603 2 1 406 419 DLY8_5VX1 $T=100920 -322560 1 0 $X=100490 $Y=-327680
X16604 2 1 2025 429 DLY8_5VX1 $T=114360 -394240 1 0 $X=113930 $Y=-399360
X16605 2 1 3241 432 DLY8_5VX1 $T=115480 -349440 1 0 $X=115050 $Y=-354560
X16606 2 1 2033 2067 DLY8_5VX1 $T=116600 -322560 1 0 $X=116170 $Y=-327680
X16607 2 1 1439 2089 DLY8_5VX1 $T=156920 -394240 1 0 $X=156490 $Y=-399360
X16608 2 1 2096 2119 DLY8_5VX1 $T=159720 -412160 1 0 $X=159290 $Y=-417280
X16609 2 1 1422 3022 DLY8_5VX1 $T=159720 -403200 0 0 $X=159290 $Y=-403840
X16610 2 1 2103 2108 DLY8_5VX1 $T=160840 -349440 1 0 $X=160410 $Y=-354560
X16611 2 1 1787 2107 DLY8_5VX1 $T=163640 -412160 0 0 $X=163210 $Y=-412800
X16612 2 1 455 469 DLY8_5VX1 $T=164200 -403200 1 0 $X=163770 $Y=-408320
X16613 2 1 1414 2106 DLY8_5VX1 $T=164200 -394240 0 0 $X=163770 $Y=-394880
X16614 2 1 2111 476 DLY8_5VX1 $T=166440 -385280 0 0 $X=166010 $Y=-385920
X16615 2 1 458 470 DLY8_5VX1 $T=167560 -313600 0 0 $X=167130 $Y=-314240
X16616 2 1 468 490 DLY8_5VX1 $T=174280 -403200 0 0 $X=173850 $Y=-403840
X16617 2 1 3253 486 DLY8_5VX1 $T=176520 -385280 1 0 $X=176090 $Y=-390400
X16618 2 1 2134 2143 DLY8_5VX1 $T=177640 -304640 1 0 $X=177210 $Y=-309760
X16619 2 1 2158 2147 DLY8_5VX1 $T=178760 -376320 1 0 $X=178330 $Y=-381440
X16620 2 1 475 489 DLY8_5VX1 $T=179320 -394240 1 0 $X=178890 $Y=-399360
X16621 2 1 2154 2152 DLY8_5VX1 $T=181000 -385280 0 0 $X=180570 $Y=-385920
X16622 2 1 474 494 DLY8_5VX1 $T=183240 -394240 0 0 $X=182810 $Y=-394880
X16623 2 1 479 495 DLY8_5VX1 $T=183800 -421120 1 0 $X=183370 $Y=-426240
X16624 2 1 2109 2155 DLY8_5VX1 $T=189960 -376320 0 0 $X=189530 $Y=-376960
X16625 2 1 485 2204 DLY8_5VX1 $T=191640 -421120 0 0 $X=191210 $Y=-421760
X16626 2 1 491 2208 DLY8_5VX1 $T=193320 -376320 1 0 $X=192890 $Y=-381440
X16627 2 1 2172 522 DLY8_5VX1 $T=195560 -385280 0 0 $X=195130 $Y=-385920
X16628 2 1 498 523 DLY8_5VX1 $T=196680 -385280 1 0 $X=196250 $Y=-390400
X16629 2 1 2182 3035 DLY8_5VX1 $T=197240 -367360 0 0 $X=196810 $Y=-368000
X16630 2 1 499 518 DLY8_5VX1 $T=198360 -421120 1 0 $X=197930 $Y=-426240
X16631 2 1 501 532 DLY8_5VX1 $T=199480 -412160 0 0 $X=199050 $Y=-412800
X16632 2 1 503 528 DLY8_5VX1 $T=201720 -403200 1 0 $X=201290 $Y=-408320
X16633 2 1 2193 2175 DLY8_5VX1 $T=202280 -367360 1 0 $X=201850 $Y=-372480
X16634 2 1 2205 534 DLY8_5VX1 $T=204520 -376320 0 0 $X=204090 $Y=-376960
X16635 2 1 513 540 DLY8_5VX1 $T=207880 -376320 1 0 $X=207450 $Y=-381440
X16636 2 1 3056 2183 DLY8_5VX1 $T=210120 -358400 1 0 $X=209690 $Y=-363520
X16637 2 1 2139 2141 DLY8_5VX1 $T=210120 -304640 1 0 $X=209690 $Y=-309760
X16638 2 1 2167 2186 DLY8_5VX1 $T=211240 -349440 1 0 $X=210810 $Y=-354560
X16639 2 1 2196 546 DLY8_5VX1 $T=211800 -367360 0 0 $X=211370 $Y=-368000
X16640 2 1 2222 2239 DLY8_5VX1 $T=213480 -358400 0 0 $X=213050 $Y=-359040
X16641 2 1 2159 2245 DLY8_5VX1 $T=215160 -340480 0 0 $X=214730 $Y=-341120
X16642 2 1 2230 556 DLY8_5VX1 $T=216840 -367360 1 0 $X=216410 $Y=-372480
X16643 2 1 535 560 DLY8_5VX1 $T=218520 -394240 0 0 $X=218090 $Y=-394880
X16644 2 1 538 563 DLY8_5VX1 $T=219080 -376320 0 0 $X=218650 $Y=-376960
X16645 2 1 545 566 DLY8_5VX1 $T=221880 -385280 1 0 $X=221450 $Y=-390400
X16646 2 1 2240 571 DLY8_5VX1 $T=224680 -358400 1 0 $X=224250 $Y=-363520
X16647 2 1 2145 2157 DLY8_5VX1 $T=224680 -304640 1 0 $X=224250 $Y=-309760
X16648 2 1 552 574 DLY8_5VX1 $T=226360 -367360 0 0 $X=225930 $Y=-368000
X16649 2 1 554 577 DLY8_5VX1 $T=229160 -385280 0 0 $X=228730 $Y=-385920
X16650 2 1 573 590 DLY8_5VX1 $T=239240 -358400 1 0 $X=238810 $Y=-363520
X16651 2 1 3245 595 DLY8_5VX1 $T=242040 -349440 0 0 $X=241610 $Y=-350080
X16652 2 1 581 596 DLY8_5VX1 $T=244280 -376320 0 0 $X=243850 $Y=-376960
X16653 2 1 2164 2314 DLY8_5VX1 $T=257160 -295680 1 0 $X=256730 $Y=-300800
X16654 2 1 2307 2174 DLY8_5VX1 $T=265000 -349440 1 0 $X=264570 $Y=-354560
X16655 2 1 2311 2170 DLY8_5VX1 $T=268360 -349440 0 0 $X=267930 $Y=-350080
X16656 2 1 607 627 DLY8_5VX1 $T=272840 -286720 1 0 $X=272410 $Y=-291840
X16657 2 1 608 3095 DLY8_5VX1 $T=273400 -340480 0 0 $X=272970 $Y=-341120
X16658 2 1 612 3040 DLY8_5VX1 $T=277880 -340480 1 0 $X=277450 $Y=-345600
X16659 2 1 620 638 DLY8_5VX1 $T=279000 -331520 1 0 $X=278570 $Y=-336640
X16660 2 1 624 3098 DLY8_5VX1 $T=280120 -322560 1 0 $X=279690 $Y=-327680
X16661 2 1 628 643 DLY8_5VX1 $T=287960 -340480 0 0 $X=287530 $Y=-341120
X16662 2 1 632 646 DLY8_5VX1 $T=290200 -349440 1 0 $X=289770 $Y=-354560
X16663 2 1 656 664 DLY8_5VX1 $T=312040 -295680 0 0 $X=311610 $Y=-296320
X16664 2 1 663 669 DLY8_5VX1 $T=323800 -277760 0 0 $X=323370 $Y=-278400
X16665 2 1 667 674 DLY8_5VX1 $T=332200 -286720 1 0 $X=331770 $Y=-291840
X16666 2 1 671 676 DLY8_5VX1 $T=338360 -277760 0 0 $X=337930 $Y=-278400
X16667 2 1 683 2408 DLY8_5VX1 $T=362440 -331520 1 0 $X=362010 $Y=-336640
X16668 2 1 682 690 DLY8_5VX1 $T=363560 -286720 1 0 $X=363130 $Y=-291840
X16669 2 1 2397 2396 DLY8_5VX1 $T=368600 -358400 1 0 $X=368170 $Y=-363520
X16670 2 1 3248 696 DLY8_5VX1 $T=373640 -358400 0 0 $X=373210 $Y=-359040
X16671 2 1 688 697 DLY8_5VX1 $T=373640 -295680 1 0 $X=373210 $Y=-300800
X16672 2 1 299 2256 BU_5VX3 $T=-37400 -277760 1 0 $X=-37830 $Y=-282880
X16673 2 1 823 822 DLY1_5VX1 $T=-452360 -277760 1 0 $X=-452790 $Y=-282880
X16674 2 1 825 2493 DLY1_5VX1 $T=-436680 -313600 1 0 $X=-437110 $Y=-318720
X16675 2 1 8 825 DLY1_5VX1 $T=-436120 -322560 0 0 $X=-436550 $Y=-323200
X16676 2 1 9 827 DLY1_5VX1 $T=-436120 -304640 1 0 $X=-436550 $Y=-309760
X16677 2 1 72 1065 DLY1_5VX1 $T=-337560 -421120 1 0 $X=-337990 $Y=-426240
X16678 2 1 85 946 DLY1_5VX1 $T=-321320 -313600 1 0 $X=-321750 $Y=-318720
X16679 2 1 115 2597 DLY1_5VX1 $T=-297800 -295680 1 0 $X=-298230 $Y=-300800
X16680 2 1 1037 2606 DLY1_5VX1 $T=-288840 -421120 1 0 $X=-289270 $Y=-426240
X16681 2 1 840 146 DLY1_5VX1 $T=-259160 -286720 1 0 $X=-259590 $Y=-291840
X16682 2 1 1137 152 DLY1_5VX1 $T=-251880 -304640 1 0 $X=-252310 $Y=-309760
X16683 2 1 150 1145 DLY1_5VX1 $T=-247960 -412160 1 0 $X=-248390 $Y=-417280
X16684 2 1 1175 166 DLY1_5VX1 $T=-238440 -286720 1 0 $X=-238870 $Y=-291840
X16685 2 1 196 200 DLY1_5VX1 $T=-193080 -304640 0 0 $X=-193510 $Y=-305280
X16686 2 1 201 1175 DLY1_5VX1 $T=-184120 -277760 1 0 $X=-184550 $Y=-282880
X16687 2 1 969 221 DLY1_5VX1 $T=-162280 -367360 0 0 $X=-162710 $Y=-368000
X16688 2 1 226 228 DLY1_5VX1 $T=-151640 -331520 1 0 $X=-152070 $Y=-336640
X16689 2 1 2754 1437 DLY1_5VX1 $T=-142680 -340480 0 0 $X=-143110 $Y=-341120
X16690 2 1 1435 1449 DLY1_5VX1 $T=-133720 -403200 1 0 $X=-134150 $Y=-408320
X16691 2 1 1463 1469 DLY1_5VX1 $T=-118040 -385280 0 0 $X=-118470 $Y=-385920
X16692 2 1 1485 1508 DLY1_5VX1 $T=-97880 -412160 1 0 $X=-98310 $Y=-417280
X16693 2 1 241 244 DLY1_5VX1 $T=-97880 -394240 1 0 $X=-98310 $Y=-399360
X16694 2 1 3233 1498 DLY1_5VX1 $T=-95640 -340480 0 0 $X=-96070 $Y=-341120
X16695 2 1 1501 1496 DLY1_5VX1 $T=-87800 -331520 0 0 $X=-88230 $Y=-332160
X16696 2 1 253 1703 DLY1_5VX1 $T=-80520 -322560 1 0 $X=-80950 $Y=-327680
X16697 2 1 256 1574 DLY1_5VX1 $T=-76600 -358400 0 0 $X=-77030 $Y=-359040
X16698 2 1 1491 1572 DLY1_5VX1 $T=-74920 -394240 0 0 $X=-75350 $Y=-394880
X16699 2 1 1495 1581 DLY1_5VX1 $T=-73240 -412160 1 0 $X=-73670 $Y=-417280
X16700 2 1 1629 286 DLY1_5VX1 $T=-50280 -367360 0 0 $X=-50710 $Y=-368000
X16701 2 1 1631 293 DLY1_5VX1 $T=-45240 -385280 0 0 $X=-45670 $Y=-385920
X16702 2 1 287 294 DLY1_5VX1 $T=-44680 -322560 0 0 $X=-45110 $Y=-323200
X16703 2 1 296 1710 DLY1_5VX1 $T=-39640 -304640 1 0 $X=-40070 $Y=-309760
X16704 2 1 302 1678 DLY1_5VX1 $T=-35160 -313600 1 0 $X=-35590 $Y=-318720
X16705 2 1 1669 1680 DLY1_5VX1 $T=-34040 -421120 1 0 $X=-34470 $Y=-426240
X16706 2 1 3218 310 DLY1_5VX1 $T=-31800 -349440 1 0 $X=-32230 $Y=-354560
X16707 2 1 309 312 DLY1_5VX1 $T=-29560 -304640 1 0 $X=-29990 $Y=-309760
X16708 2 1 1703 1713 DLY1_5VX1 $T=-20600 -385280 0 0 $X=-21030 $Y=-385920
X16709 2 1 1710 1720 DLY1_5VX1 $T=-17800 -385280 1 0 $X=-18230 $Y=-390400
X16710 2 1 1680 316 DLY1_5VX1 $T=-17240 -331520 1 0 $X=-17670 $Y=-336640
X16711 2 1 1721 1629 DLY1_5VX1 $T=-12200 -394240 0 0 $X=-12630 $Y=-394880
X16712 2 1 1494 1740 DLY1_5VX1 $T=-10520 -304640 0 0 $X=-10950 $Y=-305280
X16713 2 1 1773 340 DLY1_5VX1 $T=15800 -286720 1 0 $X=15370 $Y=-291840
X16714 2 1 345 347 DLY1_5VX1 $T=27560 -331520 0 0 $X=27130 $Y=-332160
X16715 2 1 1713 1854 DLY1_5VX1 $T=35960 -403200 0 0 $X=35530 $Y=-403840
X16716 2 1 350 353 DLY1_5VX1 $T=35960 -295680 1 0 $X=35530 $Y=-300800
X16717 2 1 1872 363 DLY1_5VX1 $T=46040 -340480 0 0 $X=45610 $Y=-341120
X16718 2 1 1720 3239 DLY1_5VX1 $T=53320 -421120 0 0 $X=52890 $Y=-421760
X16719 2 1 1574 3218 DLY1_5VX1 $T=54440 -349440 1 0 $X=54010 $Y=-354560
X16720 2 1 1900 375 DLY1_5VX1 $T=58920 -385280 0 0 $X=58490 $Y=-385920
X16721 2 1 1923 2949 DLY1_5VX1 $T=69000 -304640 1 0 $X=68570 $Y=-309760
X16722 2 1 385 1957 DLY1_5VX1 $T=75720 -340480 0 0 $X=75290 $Y=-341120
X16723 2 1 1957 1872 DLY1_5VX1 $T=99240 -358400 1 0 $X=98810 $Y=-363520
X16724 2 1 446 448 DLY1_5VX1 $T=151880 -349440 0 0 $X=151450 $Y=-350080
X16725 2 1 2281 462 DLY1_5VX1 $T=164200 -304640 0 0 $X=163770 $Y=-305280
X16726 2 1 463 3253 DLY1_5VX1 $T=170360 -385280 1 0 $X=169930 $Y=-390400
X16727 2 1 529 3254 DLY1_5VX1 $T=216840 -412160 0 0 $X=216410 $Y=-412800
X16728 2 1 3254 2244 DLY1_5VX1 $T=223000 -412160 0 0 $X=222570 $Y=-412800
X16729 2 1 547 2247 DLY1_5VX1 $T=225800 -394240 1 0 $X=225370 $Y=-399360
X16730 2 1 2243 2253 DLY1_5VX1 $T=226920 -304640 0 0 $X=226490 $Y=-305280
X16731 2 1 558 2240 DLY1_5VX1 $T=228040 -358400 0 0 $X=227610 $Y=-359040
X16732 2 1 575 583 DLY1_5VX1 $T=239800 -277760 0 0 $X=239370 $Y=-278400
X16733 2 1 598 2300 DLY1_5VX1 $T=257720 -367360 0 0 $X=257290 $Y=-368000
X16734 2 1 261 616 DLY1_5VX1 $T=272840 -277760 0 0 $X=272410 $Y=-278400
X16735 2 1 687 3248 DLY1_5VX1 $T=367480 -358400 0 0 $X=367050 $Y=-359040
X16736 2 1 2399 2397 DLY1_5VX1 $T=369160 -367360 0 0 $X=368730 $Y=-368000
X16737 2 1 694 698 DLY1_5VX1 $T=382040 -277760 0 0 $X=381610 $Y=-278400
X16738 2 1 701 2405 DLY1_5VX1 $T=401640 -277760 1 0 $X=401210 $Y=-282880
X16739 2 1 235 229 BU_5VX12 $T=-133160 -286720 0 0 $X=-133590 $Y=-287360
X16740 2 1 235 1479 BU_5VX12 $T=-129240 -385280 1 0 $X=-129670 $Y=-390400
X16741 2 1 235 1455 BU_5VX12 $T=-129240 -376320 0 0 $X=-129670 $Y=-376960
X16742 2 1 235 1447 BU_5VX12 $T=-129240 -331520 0 0 $X=-129670 $Y=-332160
X16743 2 1 235 1468 BU_5VX12 $T=-93960 -358400 0 0 $X=-94390 $Y=-359040
X16744 2 1 335 1783 BU_5VX12 $T=13000 -304640 0 0 $X=12570 $Y=-305280
X16745 2 1 335 3021 BU_5VX12 $T=169240 -322560 1 0 $X=168810 $Y=-327680
X16746 2 1 335 2165 BU_5VX12 $T=177080 -295680 1 0 $X=176650 $Y=-300800
X16747 2 1 481 2149 BU_5VX12 $T=184920 -358400 0 0 $X=184490 $Y=-359040
X16748 2 1 505 509 BU_5VX12 $T=201160 -394240 0 0 $X=200730 $Y=-394880
X16749 2 1 113 460 IN_5VX3 $T=177080 -331520 1 180 $X=172730 $Y=-332160
X16750 2 1 830 832 IN_5VX1 $T=-422680 -295680 1 0 $X=-423110 $Y=-300800
X16751 2 1 837 833 IN_5VX1 $T=-412600 -304640 0 180 $X=-414710 $Y=-309760
X16752 2 1 47 929 IN_5VX1 $T=-347080 -286720 0 0 $X=-347510 $Y=-287360
X16753 2 1 910 2535 IN_5VX1 $T=-344840 -322560 1 180 $X=-346950 $Y=-323200
X16754 2 1 942 2553 IN_5VX1 $T=-339800 -349440 0 0 $X=-340230 $Y=-350080
X16755 2 1 764 2546 IN_5VX1 $T=-339800 -322560 1 0 $X=-340230 $Y=-327680
X16756 2 1 55 2555 IN_5VX1 $T=-329720 -286720 0 180 $X=-331830 $Y=-291840
X16757 2 1 935 915 IN_5VX1 $T=-330840 -322560 1 0 $X=-331270 $Y=-327680
X16758 2 1 764 2549 IN_5VX1 $T=-326920 -331520 0 180 $X=-329030 $Y=-336640
X16759 2 1 49 2557 IN_5VX1 $T=-326920 -295680 1 180 $X=-329030 $Y=-296320
X16760 2 1 894 2563 IN_5VX1 $T=-326360 -304640 0 180 $X=-328470 $Y=-309760
X16761 2 1 55 958 IN_5VX1 $T=-326360 -286720 1 0 $X=-326790 $Y=-291840
X16762 2 1 894 2565 IN_5VX1 $T=-325800 -304640 1 0 $X=-326230 $Y=-309760
X16763 2 1 51 954 IN_5VX1 $T=-324120 -286720 1 180 $X=-326230 $Y=-287360
X16764 2 1 765 948 IN_5VX1 $T=-323000 -295680 0 180 $X=-325110 $Y=-300800
X16765 2 1 764 965 IN_5VX1 $T=-319640 -322560 0 0 $X=-320070 $Y=-323200
X16766 2 1 983 972 IN_5VX1 $T=-312360 -376320 1 180 $X=-314470 $Y=-376960
X16767 2 1 921 955 IN_5VX1 $T=-311800 -385280 1 180 $X=-313910 $Y=-385920
X16768 2 1 984 991 IN_5VX1 $T=-311240 -340480 1 0 $X=-311670 $Y=-345600
X16769 2 1 51 992 IN_5VX1 $T=-309560 -295680 1 0 $X=-309990 $Y=-300800
X16770 2 1 921 767 IN_5VX1 $T=-308440 -385280 0 0 $X=-308870 $Y=-385920
X16771 2 1 1002 2583 IN_5VX1 $T=-303960 -340480 1 0 $X=-304390 $Y=-345600
X16772 2 1 2588 2581 IN_5VX1 $T=-296680 -376320 0 180 $X=-298790 $Y=-381440
X16773 2 1 921 1022 IN_5VX1 $T=-290520 -385280 0 180 $X=-292630 $Y=-390400
X16774 2 1 1063 1074 IN_5VX1 $T=-275400 -367360 0 0 $X=-275830 $Y=-368000
X16775 2 1 2615 1088 IN_5VX1 $T=-272600 -304640 1 0 $X=-273030 $Y=-309760
X16776 2 1 3223 1098 IN_5VX1 $T=-269240 -304640 0 0 $X=-269670 $Y=-305280
X16777 2 1 2619 2621 IN_5VX1 $T=-268120 -358400 0 0 $X=-268550 $Y=-359040
X16778 2 1 1102 3224 IN_5VX1 $T=-265880 -367360 0 0 $X=-266310 $Y=-368000
X16779 2 1 1087 2625 IN_5VX1 $T=-265880 -304640 0 0 $X=-266310 $Y=-305280
X16780 2 1 1128 2630 IN_5VX1 $T=-254680 -277760 0 180 $X=-256790 $Y=-282880
X16781 2 1 2637 2629 IN_5VX1 $T=-251880 -304640 1 180 $X=-253990 $Y=-305280
X16782 2 1 771 1134 IN_5VX1 $T=-253000 -403200 0 0 $X=-253430 $Y=-403840
X16783 2 1 113 147 IN_5VX1 $T=-250760 -295680 1 0 $X=-251190 $Y=-300800
X16784 2 1 921 1167 IN_5VX1 $T=-244600 -394240 1 0 $X=-245030 $Y=-399360
X16785 2 1 1155 1177 IN_5VX1 $T=-244600 -331520 1 0 $X=-245030 $Y=-336640
X16786 2 1 51 1163 IN_5VX1 $T=-244600 -295680 1 0 $X=-245030 $Y=-300800
X16787 2 1 774 1162 IN_5VX1 $T=-239000 -394240 0 180 $X=-241110 $Y=-399360
X16788 2 1 956 1179 IN_5VX1 $T=-232280 -376320 0 180 $X=-234390 $Y=-381440
X16789 2 1 3255 1197 IN_5VX1 $T=-230040 -412160 1 0 $X=-230470 $Y=-417280
X16790 2 1 47 164 IN_5VX1 $T=-229480 -277760 0 0 $X=-229910 $Y=-278400
X16791 2 1 922 1146 IN_5VX1 $T=-227240 -376320 0 180 $X=-229350 $Y=-381440
X16792 2 1 894 2656 IN_5VX1 $T=-223880 -349440 0 180 $X=-225990 $Y=-354560
X16793 2 1 36 1204 IN_5VX1 $T=-225560 -295680 0 0 $X=-225990 $Y=-296320
X16794 2 1 1211 1233 IN_5VX1 $T=-221640 -394240 1 180 $X=-223750 $Y=-394880
X16795 2 1 55 2659 IN_5VX1 $T=-221640 -313600 0 180 $X=-223750 $Y=-318720
X16796 2 1 49 171 IN_5VX1 $T=-217720 -277760 0 180 $X=-219830 $Y=-282880
X16797 2 1 31 1182 IN_5VX1 $T=-216040 -286720 0 180 $X=-218150 $Y=-291840
X16798 2 1 913 2655 IN_5VX1 $T=-212680 -394240 0 180 $X=-214790 $Y=-399360
X16799 2 1 33 1235 IN_5VX1 $T=-212680 -286720 1 0 $X=-213110 $Y=-291840
X16800 2 1 2666 2663 IN_5VX1 $T=-209880 -385280 0 180 $X=-211990 $Y=-390400
X16801 2 1 2665 1253 IN_5VX1 $T=-211000 -403200 1 0 $X=-211430 $Y=-408320
X16802 2 1 765 1218 IN_5VX1 $T=-207080 -385280 1 180 $X=-209190 $Y=-385920
X16803 2 1 956 1283 IN_5VX1 $T=-206520 -403200 1 0 $X=-206950 $Y=-408320
X16804 2 1 1252 2668 IN_5VX1 $T=-204840 -313600 0 180 $X=-206950 $Y=-318720
X16805 2 1 47 1264 IN_5VX1 $T=-203720 -331520 1 0 $X=-204150 $Y=-336640
X16806 2 1 1297 2674 IN_5VX1 $T=-201480 -403200 1 0 $X=-201910 $Y=-408320
X16807 2 1 921 1288 IN_5VX1 $T=-197000 -394240 1 0 $X=-197430 $Y=-399360
X16808 2 1 913 2677 IN_5VX1 $T=-196440 -385280 0 0 $X=-196870 $Y=-385920
X16809 2 1 51 1298 IN_5VX1 $T=-194200 -358400 1 0 $X=-194630 $Y=-363520
X16810 2 1 1301 2682 IN_5VX1 $T=-189720 -412160 0 0 $X=-190150 $Y=-412800
X16811 2 1 55 2687 IN_5VX1 $T=-188040 -367360 0 0 $X=-188470 $Y=-368000
X16812 2 1 922 2690 IN_5VX1 $T=-184680 -394240 1 0 $X=-185110 $Y=-399360
X16813 2 1 765 2688 IN_5VX1 $T=-179080 -412160 1 180 $X=-181190 $Y=-412800
X16814 2 1 1316 1353 IN_5VX1 $T=-177400 -403200 0 0 $X=-177830 $Y=-403840
X16815 2 1 1377 2708 IN_5VX1 $T=-159480 -412160 1 180 $X=-161590 $Y=-412800
X16816 2 1 894 1324 IN_5VX1 $T=-159480 -385280 0 180 $X=-161590 $Y=-390400
X16817 2 1 3231 2719 IN_5VX1 $T=-153880 -340480 1 0 $X=-154310 $Y=-345600
X16818 2 1 1398 2714 IN_5VX1 $T=-147160 -286720 0 180 $X=-149270 $Y=-291840
X16819 2 1 3256 1537 IN_5VX1 $T=-77720 -286720 1 180 $X=-79830 $Y=-287360
X16820 2 1 2785 2787 IN_5VX1 $T=-78840 -304640 1 0 $X=-79270 $Y=-309760
X16821 2 1 1558 2783 IN_5VX1 $T=-76040 -394240 1 180 $X=-78150 $Y=-394880
X16822 2 1 1533 1542 IN_5VX1 $T=-75480 -403200 1 180 $X=-77590 $Y=-403840
X16823 2 1 2786 2788 IN_5VX1 $T=-77160 -313600 1 0 $X=-77590 $Y=-318720
X16824 2 1 1541 1557 IN_5VX1 $T=-73240 -412160 0 180 $X=-75350 $Y=-417280
X16825 2 1 3257 1530 IN_5VX1 $T=-68760 -403200 1 180 $X=-70870 $Y=-403840
X16826 2 1 1600 2798 IN_5VX1 $T=-60920 -331520 0 0 $X=-61350 $Y=-332160
X16827 2 1 2806 3258 IN_5VX1 $T=-51960 -322560 0 180 $X=-54070 $Y=-327680
X16828 2 1 1630 2811 IN_5VX1 $T=-48600 -322560 1 0 $X=-49030 $Y=-327680
X16829 2 1 1661 2815 IN_5VX1 $T=-39640 -313600 0 180 $X=-41750 $Y=-318720
X16830 2 1 265 289 IN_5VX1 $T=-39080 -277760 0 0 $X=-39510 $Y=-278400
X16831 2 1 268 2817 IN_5VX1 $T=-36280 -286720 1 180 $X=-38390 $Y=-287360
X16832 2 1 300 2816 IN_5VX1 $T=-35160 -313600 0 180 $X=-37270 $Y=-318720
X16833 2 1 274 1666 IN_5VX1 $T=-30680 -304640 0 180 $X=-32790 $Y=-309760
X16834 2 1 1683 306 IN_5VX1 $T=-27880 -286720 0 180 $X=-29990 $Y=-291840
X16835 2 1 277 1681 IN_5VX1 $T=-29560 -286720 0 0 $X=-29990 $Y=-287360
X16836 2 1 304 1685 IN_5VX1 $T=-23400 -358400 1 180 $X=-25510 $Y=-359040
X16837 2 1 1731 2831 IN_5VX1 $T=-20600 -313600 0 180 $X=-22710 $Y=-318720
X16838 2 1 1711 1689 IN_5VX1 $T=-19480 -376320 1 180 $X=-21590 $Y=-376960
X16839 2 1 801 1707 IN_5VX1 $T=-20040 -385280 1 0 $X=-20470 $Y=-390400
X16840 2 1 285 1716 IN_5VX1 $T=-15000 -295680 0 0 $X=-15430 $Y=-296320
X16841 2 1 1534 1697 IN_5VX1 $T=-12760 -385280 1 180 $X=-14870 $Y=-385920
X16842 2 1 795 1712 IN_5VX1 $T=-11080 -304640 1 180 $X=-13190 $Y=-305280
X16843 2 1 1699 2848 IN_5VX1 $T=-10520 -331520 1 0 $X=-10950 $Y=-336640
X16844 2 1 1534 1730 IN_5VX1 $T=-8840 -403200 0 0 $X=-9270 $Y=-403840
X16845 2 1 1550 1717 IN_5VX1 $T=-4360 -394240 1 180 $X=-6470 $Y=-394880
X16846 2 1 315 1714 IN_5VX1 $T=-3800 -322560 1 180 $X=-5910 $Y=-323200
X16847 2 1 1749 2854 IN_5VX1 $T=-1560 -349440 1 180 $X=-3670 $Y=-350080
X16848 2 1 1766 2858 IN_5VX1 $T=5160 -340480 1 180 $X=3050 $Y=-341120
X16849 2 1 3259 2867 IN_5VX1 $T=6280 -412160 1 0 $X=5850 $Y=-417280
X16850 2 1 1691 1718 IN_5VX1 $T=11320 -358400 0 180 $X=9210 $Y=-363520
X16851 2 1 3260 2874 IN_5VX1 $T=10760 -421120 1 0 $X=10330 $Y=-426240
X16852 2 1 304 1708 IN_5VX1 $T=10760 -313600 1 0 $X=10330 $Y=-318720
X16853 2 1 1775 2875 IN_5VX1 $T=15240 -385280 0 180 $X=13130 $Y=-390400
X16854 2 1 1724 1795 IN_5VX1 $T=16360 -376320 0 0 $X=15930 $Y=-376960
X16855 2 1 1786 1777 IN_5VX1 $T=19720 -421120 1 180 $X=17610 $Y=-421760
X16856 2 1 1744 1794 IN_5VX1 $T=20280 -385280 0 0 $X=19850 $Y=-385920
X16857 2 1 1550 2884 IN_5VX1 $T=23640 -376320 1 180 $X=21530 $Y=-376960
X16858 2 1 3261 1780 IN_5VX1 $T=24760 -421120 1 180 $X=22650 $Y=-421760
X16859 2 1 1805 1792 IN_5VX1 $T=23080 -385280 0 0 $X=22650 $Y=-385920
X16860 2 1 290 2886 IN_5VX1 $T=25320 -331520 1 0 $X=24890 $Y=-336640
X16861 2 1 2883 1820 IN_5VX1 $T=27560 -403200 0 0 $X=27130 $Y=-403840
X16862 2 1 1691 794 IN_5VX1 $T=30920 -358400 1 0 $X=30490 $Y=-363520
X16863 2 1 793 797 IN_5VX1 $T=34840 -385280 0 0 $X=34410 $Y=-385920
X16864 2 1 1550 2911 IN_5VX1 $T=39320 -385280 0 0 $X=38890 $Y=-385920
X16865 2 1 801 1868 IN_5VX1 $T=44360 -385280 0 0 $X=43930 $Y=-385920
X16866 2 1 1855 2916 IN_5VX1 $T=44360 -340480 0 0 $X=43930 $Y=-341120
X16867 2 1 1866 2913 IN_5VX1 $T=48280 -304640 1 180 $X=46170 $Y=-305280
X16868 2 1 1871 1879 IN_5VX1 $T=47160 -385280 0 0 $X=46730 $Y=-385920
X16869 2 1 1534 1860 IN_5VX1 $T=52200 -367360 1 180 $X=50090 $Y=-368000
X16870 2 1 2928 1893 IN_5VX1 $T=56680 -295680 1 0 $X=56250 $Y=-300800
X16871 2 1 2930 2933 IN_5VX1 $T=58920 -286720 1 0 $X=58490 $Y=-291840
X16872 2 1 274 368 IN_5VX1 $T=63960 -277760 0 180 $X=61850 $Y=-282880
X16873 2 1 258 374 IN_5VX1 $T=63400 -295680 0 0 $X=62970 $Y=-296320
X16874 2 1 290 2946 IN_5VX1 $T=74600 -322560 0 180 $X=72490 $Y=-327680
X16875 2 1 804 1943 IN_5VX1 $T=74040 -340480 0 0 $X=73610 $Y=-341120
X16876 2 1 277 1934 IN_5VX1 $T=75160 -304640 1 0 $X=74730 $Y=-309760
X16877 2 1 274 1949 IN_5VX1 $T=77400 -286720 1 0 $X=76970 $Y=-291840
X16878 2 1 803 1937 IN_5VX1 $T=79640 -349440 0 180 $X=77530 $Y=-354560
X16879 2 1 285 2955 IN_5VX1 $T=79640 -304640 0 180 $X=77530 $Y=-309760
X16880 2 1 268 1955 IN_5VX1 $T=79080 -286720 1 0 $X=78650 $Y=-291840
X16881 2 1 795 1959 IN_5VX1 $T=82440 -331520 0 0 $X=82010 $Y=-332160
X16882 2 1 1810 2961 IN_5VX1 $T=83000 -349440 1 0 $X=82570 $Y=-354560
X16883 2 1 1810 1968 IN_5VX1 $T=89720 -403200 0 0 $X=89290 $Y=-403840
X16884 2 1 1534 1981 IN_5VX1 $T=89720 -394240 0 0 $X=89290 $Y=-394880
X16885 2 1 1550 1969 IN_5VX1 $T=91960 -376320 1 0 $X=91530 $Y=-381440
X16886 2 1 304 1973 IN_5VX1 $T=91960 -358400 0 0 $X=91530 $Y=-359040
X16887 2 1 801 1994 IN_5VX1 $T=93080 -403200 0 0 $X=92650 $Y=-403840
X16888 2 1 258 400 IN_5VX1 $T=96440 -304640 0 180 $X=94330 $Y=-309760
X16889 2 1 265 394 IN_5VX1 $T=98680 -304640 1 180 $X=96570 $Y=-305280
X16890 2 1 795 1995 IN_5VX1 $T=99240 -367360 1 0 $X=98810 $Y=-372480
X16891 2 1 304 2977 IN_5VX1 $T=99240 -322560 1 0 $X=98810 $Y=-327680
X16892 2 1 264 401 IN_5VX1 $T=103160 -304640 0 180 $X=101050 $Y=-309760
X16893 2 1 264 405 IN_5VX1 $T=103160 -277760 0 180 $X=101050 $Y=-282880
X16894 2 1 290 2984 IN_5VX1 $T=102600 -349440 1 0 $X=102170 $Y=-354560
X16895 2 1 277 2985 IN_5VX1 $T=109320 -331520 0 180 $X=107210 $Y=-336640
X16896 2 1 274 2013 IN_5VX1 $T=111000 -304640 0 180 $X=108890 $Y=-309760
X16897 2 1 268 2002 IN_5VX1 $T=111560 -304640 0 0 $X=111130 $Y=-305280
X16898 2 1 285 2027 IN_5VX1 $T=113800 -349440 1 0 $X=113370 $Y=-354560
X16899 2 1 1972 2024 IN_5VX1 $T=119400 -403200 1 180 $X=117290 $Y=-403840
X16900 2 1 524 2242 IN_5VX1 $T=225240 -304640 0 0 $X=224810 $Y=-305280
X16901 2 1 2262 2248 IN_5VX1 $T=242040 -349440 1 180 $X=239930 $Y=-350080
X16902 2 1 516 3069 IN_5VX1 $T=246520 -304640 0 180 $X=244410 $Y=-309760
X16903 2 1 525 2286 IN_5VX1 $T=247640 -331520 0 0 $X=247210 $Y=-332160
X16904 2 1 511 3075 IN_5VX1 $T=254360 -295680 0 0 $X=253930 $Y=-296320
X16905 2 1 517 2290 IN_5VX1 $T=258280 -304640 0 0 $X=257850 $Y=-305280
X16906 2 1 2278 3078 IN_5VX1 $T=261080 -322560 1 180 $X=258970 $Y=-323200
X16907 2 1 2219 3081 IN_5VX1 $T=263880 -322560 0 0 $X=263450 $Y=-323200
X16908 2 1 514 2297 IN_5VX1 $T=266120 -331520 1 180 $X=264010 $Y=-332160
X16909 2 1 2294 3080 IN_5VX1 $T=266680 -349440 0 0 $X=266250 $Y=-350080
X16910 2 1 549 2308 IN_5VX1 $T=272840 -277760 1 180 $X=270730 $Y=-278400
X16911 2 1 510 2310 IN_5VX1 $T=275640 -295680 0 180 $X=273530 $Y=-300800
X16912 2 1 2210 2312 IN_5VX1 $T=274520 -322560 1 0 $X=274090 $Y=-327680
X16913 2 1 2306 3090 IN_5VX1 $T=280120 -322560 0 180 $X=278010 $Y=-327680
X16914 2 1 2322 3089 IN_5VX1 $T=280120 -295680 0 180 $X=278010 $Y=-300800
X16915 2 1 524 625 IN_5VX1 $T=279560 -277760 0 0 $X=279130 $Y=-278400
X16916 2 1 2325 2326 IN_5VX1 $T=289080 -322560 0 0 $X=288650 $Y=-323200
X16917 2 1 516 3262 IN_5VX1 $T=293000 -286720 1 180 $X=290890 $Y=-287360
X16918 2 1 525 3097 IN_5VX1 $T=295240 -286720 0 180 $X=293130 $Y=-291840
X16919 2 1 514 3101 IN_5VX1 $T=301400 -313600 1 0 $X=300970 $Y=-318720
X16920 2 1 525 2337 IN_5VX1 $T=303640 -304640 1 0 $X=303210 $Y=-309760
X16921 2 1 2219 3105 IN_5VX1 $T=309240 -331520 1 0 $X=308810 $Y=-336640
X16922 2 1 516 652 IN_5VX1 $T=311480 -304640 1 0 $X=311050 $Y=-309760
X16923 2 1 2210 3109 IN_5VX1 $T=323240 -331520 1 180 $X=321130 $Y=-332160
X16924 2 1 2358 2359 IN_5VX1 $T=328280 -313600 1 0 $X=327850 $Y=-318720
X16925 2 1 2369 3246 IN_5VX1 $T=342280 -295680 0 180 $X=340170 $Y=-300800
X16926 2 1 2377 3247 IN_5VX1 $T=350120 -313600 1 0 $X=349690 $Y=-318720
X16927 2 1 2400 2385 IN_5VX1 $T=351800 -349440 0 0 $X=351370 $Y=-350080
X16928 2 1 677 3138 IN_5VX1 $T=352360 -277760 1 0 $X=351930 $Y=-282880
X16929 2 1 2389 2388 IN_5VX1 $T=354600 -295680 0 0 $X=354170 $Y=-296320
X16930 2 1 3143 3136 IN_5VX1 $T=359080 -286720 1 180 $X=356970 $Y=-287360
X16931 2 1 2390 3140 IN_5VX1 $T=359640 -304640 1 0 $X=359210 $Y=-309760
X16932 2 1 2393 3142 IN_5VX1 $T=365800 -295680 0 180 $X=363690 $Y=-300800
X16933 2 1 3150 3146 IN_5VX1 $T=368600 -295680 1 180 $X=366490 $Y=-296320
X16934 2 1 3165 2419 IN_5VX1 $T=402760 -295680 1 0 $X=402330 $Y=-300800
X16935 2 1 3167 3169 IN_5VX1 $T=405000 -304640 1 0 $X=404570 $Y=-309760
X16936 2 1 3166 3171 IN_5VX1 $T=407240 -286720 1 0 $X=406810 $Y=-291840
X16937 2 1 3175 2420 IN_5VX1 $T=416200 -295680 0 180 $X=414090 $Y=-300800
X16938 2 1 2449 2442 IN_5VX1 $T=440280 -331520 1 180 $X=438170 $Y=-332160
X16939 2 1 721 720 IN_5VX1 $T=449240 -277760 1 180 $X=447130 $Y=-278400
X16940 2 1 2400 2453 IN_5VX1 $T=459880 -331520 0 0 $X=459450 $Y=-332160
X16941 2 1 2434 2463 IN_5VX1 $T=464360 -331520 1 0 $X=463930 $Y=-336640
X16942 2 1 2400 820 IN_5VX1 $T=478360 -322560 1 0 $X=477930 $Y=-327680
X16943 2 1 2481 3210 IN_5VX1 $T=497400 -286720 1 180 $X=495290 $Y=-287360
X16944 2 1 12 113 IN_5VX2 $T=-297240 -286720 1 0 $X=-297670 $Y=-291840
X16945 2 1 113 227 IN_5VX2 $T=-131480 -340480 0 0 $X=-131910 $Y=-341120
X16946 2 1 846 33 2501 EO2_5VX1 $T=-410360 -295680 1 0 $X=-410790 $Y=-300800
X16947 2 1 31 34 2497 EO2_5VX1 $T=-402520 -277760 1 180 $X=-409110 $Y=-278400
X16948 2 1 848 36 2498 EO2_5VX1 $T=-399160 -304640 0 180 $X=-405750 $Y=-309760
X16949 2 1 51 2520 2516 EO2_5VX1 $T=-377880 -367360 0 180 $X=-384470 $Y=-372480
X16950 2 1 47 882 851 EO2_5VX1 $T=-376200 -313600 0 180 $X=-382790 $Y=-318720
X16951 2 1 890 55 886 EO2_5VX1 $T=-367240 -376320 1 180 $X=-373830 $Y=-376960
X16952 2 1 888 894 2528 EO2_5VX1 $T=-372280 -394240 0 0 $X=-372710 $Y=-394880
X16953 2 1 58 55 893 EO2_5VX1 $T=-365000 -286720 1 180 $X=-371590 $Y=-287360
X16954 2 1 764 901 895 EO2_5VX1 $T=-362760 -313600 0 180 $X=-369350 $Y=-318720
X16955 2 1 887 894 2531 EO2_5VX1 $T=-368360 -295680 1 0 $X=-368790 $Y=-300800
X16956 2 1 910 935 2534 EO2_5VX1 $T=-342040 -322560 0 180 $X=-348630 $Y=-327680
X16957 2 1 913 765 2536 EO2_5VX1 $T=-341480 -349440 1 180 $X=-348070 $Y=-350080
X16958 2 1 2536 920 924 EO2_5VX1 $T=-344840 -367360 1 0 $X=-345270 $Y=-372480
X16959 2 1 922 934 2551 EO2_5VX1 $T=-340360 -403200 0 0 $X=-340790 $Y=-403840
X16960 2 1 765 2549 2554 EO2_5VX1 $T=-337000 -331520 1 0 $X=-337430 $Y=-336640
X16961 2 1 942 920 2556 EO2_5VX1 $T=-326920 -358400 1 180 $X=-333510 $Y=-359040
X16962 2 1 951 764 2552 EO2_5VX1 $T=-325240 -367360 1 180 $X=-331830 $Y=-368000
X16963 2 1 910 951 2550 EO2_5VX1 $T=-324120 -367360 0 180 $X=-330710 $Y=-372480
X16964 2 1 913 910 942 EO2_5VX1 $T=-321320 -349440 0 180 $X=-327910 $Y=-354560
X16965 2 1 921 960 957 EO2_5VX1 $T=-319640 -385280 0 180 $X=-326230 $Y=-390400
X16966 2 1 921 765 2571 EO2_5VX1 $T=-324120 -367360 0 0 $X=-324550 $Y=-368000
X16967 2 1 972 975 985 EO2_5VX1 $T=-317400 -349440 0 0 $X=-317830 $Y=-350080
X16968 2 1 984 1002 997 EO2_5VX1 $T=-310680 -331520 1 0 $X=-311110 $Y=-336640
X16969 2 1 767 974 1006 EO2_5VX1 $T=-306200 -340480 0 0 $X=-306630 $Y=-341120
X16970 2 1 1013 105 2579 EO2_5VX1 $T=-299480 -286720 0 180 $X=-306070 $Y=-291840
X16971 2 1 1006 997 1015 EO2_5VX1 $T=-303400 -331520 1 0 $X=-303830 $Y=-336640
X16972 2 1 956 983 1020 EO2_5VX1 $T=-302280 -376320 0 0 $X=-302710 $Y=-376960
X16973 2 1 2581 1026 2587 EO2_5VX1 $T=-302280 -367360 0 0 $X=-302710 $Y=-368000
X16974 2 1 767 2588 1039 EO2_5VX1 $T=-296680 -385280 0 0 $X=-297110 $Y=-385920
X16975 2 1 111 999 1031 EO2_5VX1 $T=-295560 -277760 1 0 $X=-295990 $Y=-282880
X16976 2 1 767 1029 1034 EO2_5VX1 $T=-293880 -376320 1 0 $X=-294310 $Y=-381440
X16977 2 1 995 1026 2603 EO2_5VX1 $T=-293880 -367360 0 0 $X=-294310 $Y=-368000
X16978 2 1 1018 105 1046 EO2_5VX1 $T=-292760 -304640 0 0 $X=-293190 $Y=-305280
X16979 2 1 1020 1034 1059 EO2_5VX1 $T=-286600 -376320 0 0 $X=-287030 $Y=-376960
X16980 2 1 1019 2608 1030 EO2_5VX1 $T=-280440 -295680 1 180 $X=-287030 $Y=-296320
X16981 2 1 770 1090 2612 EO2_5VX1 $T=-266440 -403200 0 180 $X=-273030 $Y=-408320
X16982 2 1 1146 2640 1118 EO2_5VX1 $T=-247960 -412160 0 180 $X=-254550 $Y=-417280
X16983 2 1 1134 2640 1153 EO2_5VX1 $T=-253000 -403200 1 0 $X=-253430 $Y=-408320
X16984 2 1 765 1146 1139 EO2_5VX1 $T=-246280 -385280 0 180 $X=-252870 $Y=-390400
X16985 2 1 1168 1135 1123 EO2_5VX1 $T=-239560 -403200 0 180 $X=-246150 $Y=-408320
X16986 2 1 913 1179 1142 EO2_5VX1 $T=-236760 -376320 0 180 $X=-243350 $Y=-381440
X16987 2 1 2665 3226 1186 EO2_5VX1 $T=-213800 -412160 1 180 $X=-220390 $Y=-412800
X16988 2 1 2655 1218 2665 EO2_5VX1 $T=-218840 -403200 1 0 $X=-219270 $Y=-408320
X16989 2 1 922 1267 2672 EO2_5VX1 $T=-208760 -385280 1 0 $X=-209190 $Y=-390400
X16990 2 1 1304 2676 1275 EO2_5VX1 $T=-190280 -376320 0 180 $X=-196870 $Y=-381440
X16991 2 1 1297 1268 2683 EO2_5VX1 $T=-194200 -394240 1 0 $X=-194630 $Y=-399360
X16992 2 1 1301 2680 1312 EO2_5VX1 $T=-191960 -403200 1 0 $X=-192390 $Y=-408320
X16993 2 1 1338 1328 2693 EO2_5VX1 $T=-171240 -385280 0 180 $X=-177830 $Y=-390400
X16994 2 1 1434 1448 2779 EO2_5VX1 $T=-95640 -403200 1 0 $X=-96070 $Y=-408320
X16995 2 1 277 1632 2805 EO2_5VX1 $T=-45240 -385280 1 180 $X=-51830 $Y=-385920
X16996 2 1 1637 284 1628 EO2_5VX1 $T=-43560 -367360 0 180 $X=-50150 $Y=-372480
X16997 2 1 1615 1632 2814 EO2_5VX1 $T=-48600 -394240 0 0 $X=-49030 $Y=-394880
X16998 2 1 1638 284 1627 EO2_5VX1 $T=-37960 -367360 1 180 $X=-44550 $Y=-368000
X16999 2 1 1671 1642 1621 EO2_5VX1 $T=-37400 -358400 1 180 $X=-43990 $Y=-359040
X17000 2 1 2827 1664 1632 EO2_5VX1 $T=-32920 -385280 1 180 $X=-39510 $Y=-385920
X17001 2 1 1534 1665 1654 EO2_5VX1 $T=-31240 -403200 1 180 $X=-37830 $Y=-403840
X17002 2 1 1665 1668 2826 EO2_5VX1 $T=-37400 -394240 1 0 $X=-37830 $Y=-399360
X17003 2 1 1676 1670 2819 EO2_5VX1 $T=-30680 -376320 1 180 $X=-37270 $Y=-376960
X17004 2 1 1690 1691 2840 EO2_5VX1 $T=-24520 -412160 1 0 $X=-24950 $Y=-417280
X17005 2 1 1580 1690 1670 EO2_5VX1 $T=-23400 -403200 1 0 $X=-23830 $Y=-408320
X17006 2 1 1724 2847 1736 EO2_5VX1 $T=-10520 -376320 0 0 $X=-10950 $Y=-376960
X17007 2 1 1534 1746 1799 EO2_5VX1 $T=12440 -358400 1 0 $X=12010 $Y=-363520
X17008 2 1 1746 1775 2888 EO2_5VX1 $T=17480 -367360 0 0 $X=17050 $Y=-368000
X17009 2 1 1534 1808 2893 EO2_5VX1 $T=22520 -358400 1 0 $X=22090 $Y=-363520
X17010 2 1 1804 1823 1821 EO2_5VX1 $T=27000 -340480 1 0 $X=26570 $Y=-345600
X17011 2 1 801 794 2899 EO2_5VX1 $T=28680 -322560 1 0 $X=28250 $Y=-327680
X17012 2 1 1808 1804 1831 EO2_5VX1 $T=40440 -331520 1 180 $X=33850 $Y=-332160
X17013 2 1 1871 2908 2909 EO2_5VX1 $T=35400 -376320 1 0 $X=34970 $Y=-381440
X17014 2 1 1534 1890 2917 EO2_5VX1 $T=41560 -394240 0 0 $X=41130 $Y=-394880
X17015 2 1 1691 2920 1857 EO2_5VX1 $T=54440 -358400 0 180 $X=47850 $Y=-363520
X17016 2 1 1810 2920 1891 EO2_5VX1 $T=50520 -367360 1 0 $X=50090 $Y=-372480
X17017 2 1 268 384 2956 EO2_5VX1 $T=73480 -277760 1 0 $X=73050 $Y=-282880
X17018 2 1 801 1968 1971 EO2_5VX1 $T=81320 -403200 0 0 $X=80890 $Y=-403840
X17019 2 1 1976 1993 2970 EO2_5VX1 $T=100920 -349440 0 180 $X=94330 $Y=-354560
X17020 2 1 804 1985 2976 EO2_5VX1 $T=95880 -403200 1 0 $X=95450 $Y=-408320
X17021 2 1 2968 304 2988 EO2_5VX1 $T=102600 -385280 0 0 $X=102170 $Y=-385920
X17022 2 1 2007 290 2986 EO2_5VX1 $T=103720 -376320 0 0 $X=103290 $Y=-376960
X17023 2 1 795 808 2989 EO2_5VX1 $T=105400 -412160 1 0 $X=104970 $Y=-417280
X17024 2 1 2007 1995 2018 EO2_5VX1 $T=105400 -358400 1 0 $X=104970 $Y=-363520
X17025 2 1 808 304 2014 EO2_5VX1 $T=117160 -394240 1 180 $X=110570 $Y=-394880
X17026 2 1 2269 510 2257 EO2_5VX1 $T=243160 -322560 0 180 $X=236570 $Y=-327680
X17027 2 1 2269 3069 2268 EO2_5VX1 $T=237000 -313600 0 0 $X=236570 $Y=-314240
X17028 2 1 2271 524 2246 EO2_5VX1 $T=245960 -313600 0 180 $X=239370 $Y=-318720
X17029 2 1 3072 2272 3066 EO2_5VX1 $T=247640 -322560 1 180 $X=241050 $Y=-323200
X17030 2 1 2271 2290 2292 EO2_5VX1 $T=251000 -295680 1 0 $X=250570 $Y=-300800
X17031 2 1 2295 2290 3263 EO2_5VX1 $T=258280 -304640 1 180 $X=251690 $Y=-305280
X17032 2 1 2306 3082 2313 EO2_5VX1 $T=266680 -313600 1 0 $X=266250 $Y=-318720
X17033 2 1 2317 2316 2304 EO2_5VX1 $T=280680 -322560 1 180 $X=274090 $Y=-323200
X17034 2 1 2210 2219 2358 EO2_5VX1 $T=295240 -331520 0 0 $X=294810 $Y=-332160
X17035 2 1 516 3113 2342 EO2_5VX1 $T=323800 -340480 1 180 $X=317210 $Y=-341120
X17036 2 1 2338 3113 2353 EO2_5VX1 $T=319320 -313600 1 0 $X=318890 $Y=-318720
X17037 2 1 517 2349 3111 EO2_5VX1 $T=327160 -322560 0 180 $X=320570 $Y=-327680
X17038 2 1 2434 693 3181 EO2_5VX1 $T=422360 -331520 1 0 $X=421930 $Y=-336640
X17039 2 1 2442 2443 2439 EO2_5VX1 $T=436920 -331520 1 180 $X=430330 $Y=-332160
X17040 2 1 2453 2449 3188 EO2_5VX1 $T=439720 -322560 1 0 $X=439290 $Y=-327680
X17041 2 1 2447 2443 3191 EO2_5VX1 $T=443640 -331520 1 0 $X=443210 $Y=-336640
X17042 2 1 2400 723 727 EO2_5VX1 $T=451480 -277760 0 0 $X=451050 $Y=-278400
X17043 2 1 2463 728 3198 EO2_5VX1 $T=460440 -304640 1 0 $X=460010 $Y=-309760
X17044 2 1 2468 692 2440 EO2_5VX1 $T=467720 -322560 0 180 $X=461130 $Y=-327680
X17045 2 1 2453 514 2468 EO2_5VX1 $T=463800 -331520 0 0 $X=463370 $Y=-332160
X17046 2 1 693 2468 3201 EO2_5VX1 $T=476120 -331520 1 180 $X=469530 $Y=-332160
X17047 2 1 2219 514 2474 EO2_5VX1 $T=476680 -295680 0 0 $X=476250 $Y=-296320
X17048 2 1 2474 2472 3250 EO2_5VX1 $T=483960 -286720 0 180 $X=477370 $Y=-291840
X17049 2 1 2400 3208 3209 EO2_5VX1 $T=493480 -322560 1 180 $X=486890 $Y=-323200
X17050 2 1 692 2480 2482 EO2_5VX1 $T=491240 -313600 0 0 $X=490810 $Y=-314240
X17051 2 1 693 2480 2488 EO2_5VX1 $T=497960 -313600 0 0 $X=497530 $Y=-314240
X17052 2 1 2494 828 3220 19 HA_5VX1 $T=-428840 -295680 0 0 $X=-429270 $Y=-296320
X17053 2 1 2543 921 2535 2537 HA_5VX1 $T=-338120 -313600 0 180 $X=-347510 $Y=-318720
X17054 2 1 920 921 2549 2561 HA_5VX1 $T=-322440 -340480 0 180 $X=-331830 $Y=-345600
X17055 2 1 763 921 765 931 HA_5VX1 $T=-331400 -313600 0 0 $X=-331830 $Y=-314240
X17056 2 1 975 910 764 2566 HA_5VX1 $T=-317400 -349440 1 180 $X=-326790 $Y=-350080
X17057 2 1 951 955 765 2569 HA_5VX1 $T=-324120 -367360 1 0 $X=-324550 $Y=-372480
X17058 2 1 974 765 910 2568 HA_5VX1 $T=-315160 -340480 1 180 $X=-324550 $Y=-341120
X17059 2 1 963 965 968 2572 HA_5VX1 $T=-322440 -313600 0 0 $X=-322870 $Y=-314240
X17060 2 1 976 2572 2565 970 HA_5VX1 $T=-312360 -295680 0 180 $X=-321750 $Y=-300800
X17061 2 1 982 970 958 87 HA_5VX1 $T=-312360 -286720 1 180 $X=-321750 $Y=-287360
X17062 2 1 1026 921 764 768 HA_5VX1 $T=-302840 -367360 1 180 $X=-312230 $Y=-368000
X17063 2 1 983 921 913 2577 HA_5VX1 $T=-311240 -376320 1 0 $X=-311670 $Y=-381440
X17064 2 1 92 51 49 1008 HA_5VX1 $T=-310120 -295680 0 0 $X=-310550 $Y=-296320
X17065 2 1 999 36 31 106 HA_5VX1 $T=-306760 -277760 1 0 $X=-307190 $Y=-282880
X17066 2 1 2588 913 956 2586 HA_5VX1 $T=-294440 -385280 0 180 $X=-303830 $Y=-390400
X17067 2 1 105 49 47 1027 HA_5VX1 $T=-301160 -295680 0 0 $X=-301590 $Y=-296320
X17068 2 1 2608 47 36 1066 HA_5VX1 $T=-281560 -295680 1 0 $X=-281990 $Y=-300800
X17069 2 1 770 771 1118 1096 HA_5VX1 $T=-268680 -412160 0 0 $X=-269110 $Y=-412800
X17070 2 1 1149 2633 2628 1121 HA_5VX1 $T=-252440 -295680 1 180 $X=-261830 $Y=-296320
X17071 2 1 1122 1121 2630 143 HA_5VX1 $T=-250760 -286720 1 180 $X=-260150 $Y=-287360
X17072 2 1 2640 1167 765 1164 HA_5VX1 $T=-247400 -412160 0 0 $X=-247830 $Y=-412800
X17073 2 1 2646 1167 1179 1189 HA_5VX1 $T=-243480 -394240 0 0 $X=-243910 $Y=-394880
X17074 2 1 774 1167 2655 771 HA_5VX1 $T=-239000 -394240 1 0 $X=-239430 $Y=-399360
X17075 2 1 1187 1191 2656 1196 HA_5VX1 $T=-233400 -349440 0 0 $X=-233830 $Y=-350080
X17076 2 1 1212 1179 1146 2657 HA_5VX1 $T=-223320 -376320 1 180 $X=-232710 $Y=-376960
X17077 2 1 1188 1196 2659 165 HA_5VX1 $T=-232280 -313600 0 0 $X=-232710 $Y=-314240
X17078 2 1 1206 1146 2657 1191 HA_5VX1 $T=-221080 -367360 0 180 $X=-230470 $Y=-372480
X17079 2 1 3226 921 1146 1194 HA_5VX1 $T=-217720 -412160 0 180 $X=-227110 $Y=-417280
X17080 2 1 1231 1218 1179 1240 HA_5VX1 $T=-211560 -385280 1 180 $X=-220950 $Y=-385920
X17081 2 1 1268 921 765 1274 HA_5VX1 $T=-194760 -367360 0 180 $X=-204150 $Y=-372480
X17082 2 1 2680 913 765 1291 HA_5VX1 $T=-191960 -412160 1 180 $X=-201350 $Y=-412800
X17083 2 1 1303 2688 1283 1327 HA_5VX1 $T=-184680 -412160 1 0 $X=-185110 $Y=-417280
X17084 2 1 1344 1158 3264 1332 HA_5VX1 $T=-173480 -313600 0 180 $X=-182870 $Y=-318720
X17085 2 1 3265 2697 3266 1333 HA_5VX1 $T=-171240 -286720 0 180 $X=-180630 $Y=-291840
X17086 2 1 2699 209 1333 205 HA_5VX1 $T=-170680 -277760 1 180 $X=-180070 $Y=-278400
X17087 2 1 777 921 1283 1338 HA_5VX1 $T=-170120 -403200 0 180 $X=-179510 $Y=-408320
X17088 2 1 3267 1332 2694 2697 HA_5VX1 $T=-167880 -304640 0 180 $X=-177270 $Y=-309760
X17089 2 1 1366 212 2699 2701 HA_5VX1 $T=-163960 -277760 0 180 $X=-173350 $Y=-282880
X17090 2 1 2709 1348 3265 2702 HA_5VX1 $T=-161720 -286720 0 180 $X=-171110 $Y=-291840
X17091 2 1 2713 1375 1344 2706 HA_5VX1 $T=-157800 -295680 0 180 $X=-167190 $Y=-300800
X17092 2 1 1364 2705 1386 1378 HA_5VX1 $T=-165640 -313600 0 0 $X=-166070 $Y=-314240
X17093 2 1 2718 1378 1326 215 HA_5VX1 $T=-155000 -277760 0 180 $X=-164390 $Y=-282880
X17094 2 1 2710 3268 1397 1386 HA_5VX1 $T=-161160 -322560 0 0 $X=-161590 $Y=-323200
X17095 2 1 1419 2724 1364 1400 HA_5VX1 $T=-146600 -313600 1 180 $X=-155990 $Y=-314240
X17096 2 1 3230 1373 2715 2726 HA_5VX1 $T=-153880 -412160 1 0 $X=-154310 $Y=-417280
X17097 2 1 2729 2725 1368 1397 HA_5VX1 $T=-144920 -340480 1 180 $X=-154310 $Y=-341120
X17098 2 1 1430 1400 2718 223 HA_5VX1 $T=-144920 -277760 1 180 $X=-154310 $Y=-278400
X17099 2 1 3269 2728 2719 2725 HA_5VX1 $T=-144360 -349440 1 180 $X=-153750 $Y=-350080
X17100 2 1 3270 2732 1404 2728 HA_5VX1 $T=-142120 -349440 0 180 $X=-151510 $Y=-354560
X17101 2 1 1335 2735 2710 2724 HA_5VX1 $T=-142120 -322560 1 180 $X=-151510 $Y=-323200
X17102 2 1 1391 2726 1406 2731 HA_5VX1 $T=-150520 -412160 0 0 $X=-150950 $Y=-412800
X17103 2 1 1417 2734 1409 1410 HA_5VX1 $T=-141000 -394240 1 180 $X=-150390 $Y=-394880
X17104 2 1 779 2722 1410 2727 HA_5VX1 $T=-141000 -376320 0 180 $X=-150390 $Y=-381440
X17105 2 1 2723 2727 2736 2733 HA_5VX1 $T=-149960 -367360 1 0 $X=-150390 $Y=-372480
X17106 2 1 1413 2733 2720 2732 HA_5VX1 $T=-140440 -358400 1 180 $X=-149830 $Y=-359040
X17107 2 1 1390 2731 1411 2734 HA_5VX1 $T=-148840 -403200 1 0 $X=-149270 $Y=-408320
X17108 2 1 2740 2737 2723 1424 HA_5VX1 $T=-138200 -376320 1 180 $X=-147590 $Y=-376960
X17109 2 1 1441 2738 2729 2735 HA_5VX1 $T=-137640 -340480 0 180 $X=-147030 $Y=-345600
X17110 2 1 1408 1424 1413 1425 HA_5VX1 $T=-137080 -358400 0 180 $X=-146470 $Y=-363520
X17111 2 1 1444 1402 1417 1426 HA_5VX1 $T=-135960 -394240 0 180 $X=-145350 $Y=-399360
X17112 2 1 1440 1426 779 2737 HA_5VX1 $T=-134840 -385280 0 180 $X=-144230 $Y=-390400
X17113 2 1 1450 2744 3269 2738 HA_5VX1 $T=-134280 -349440 1 180 $X=-143670 $Y=-350080
X17114 2 1 1383 1425 3270 2744 HA_5VX1 $T=-132600 -349440 0 180 $X=-141990 $Y=-354560
X17115 2 1 1428 236 1470 237 HA_5VX1 $T=-132600 -277760 0 0 $X=-133030 $Y=-278400
X17116 2 1 2749 2755 2760 1416 HA_5VX1 $T=-130920 -295680 0 0 $X=-131350 $Y=-296320
X17117 2 1 2756 1480 3271 1451 HA_5VX1 $T=-121400 -322560 0 0 $X=-121830 $Y=-323200
X17118 2 1 2760 2771 1510 1507 HA_5VX1 $T=-97880 -295680 1 0 $X=-98310 $Y=-300800
X17119 2 1 1514 2773 2766 242 HA_5VX1 $T=-88920 -286720 1 180 $X=-98310 $Y=-287360
X17120 2 1 1470 2767 1507 243 HA_5VX1 $T=-97880 -277760 0 0 $X=-98310 $Y=-278400
X17121 2 1 3271 3272 1515 1510 HA_5VX1 $T=-97320 -322560 0 0 $X=-97750 $Y=-323200
X17122 2 1 1945 2770 2776 2773 HA_5VX1 $T=-97320 -304640 1 0 $X=-97750 $Y=-309760
X17123 2 1 1517 1513 2765 1484 HA_5VX1 $T=-87800 -331520 1 180 $X=-97190 $Y=-332160
X17124 2 1 3273 1503 2778 2776 HA_5VX1 $T=-96200 -331520 1 0 $X=-96630 $Y=-336640
X17125 2 1 3234 1488 2769 1500 HA_5VX1 $T=-86120 -385280 1 180 $X=-95510 $Y=-385920
X17126 2 1 1555 1492 1500 2774 HA_5VX1 $T=-85560 -376320 0 180 $X=-94950 $Y=-381440
X17127 2 1 1384 1512 1544 1503 HA_5VX1 $T=-93960 -349440 0 0 $X=-94390 $Y=-350080
X17128 2 1 1550 3234 2777 782 HA_5VX1 $T=-81640 -394240 1 180 $X=-91030 $Y=-394880
X17129 2 1 1359 1516 2780 1512 HA_5VX1 $T=-90600 -376320 0 0 $X=-91030 $Y=-376960
X17130 2 1 1535 1529 2774 1523 HA_5VX1 $T=-81080 -367360 1 180 $X=-90470 $Y=-368000
X17131 2 1 1381 1525 1545 1528 HA_5VX1 $T=-88360 -322560 0 0 $X=-88790 $Y=-323200
X17132 2 1 1700 1552 1523 1539 HA_5VX1 $T=-76040 -349440 1 180 $X=-85430 $Y=-350080
X17133 2 1 2782 2784 3236 1515 HA_5VX1 $T=-81080 -331520 0 0 $X=-81510 $Y=-332160
X17134 2 1 2765 1576 1597 2784 HA_5VX1 $T=-71560 -331520 0 0 $X=-71990 $Y=-332160
X17135 2 1 1642 290 285 1672 HA_5VX1 $T=-44680 -349440 0 0 $X=-45110 $Y=-350080
X17136 2 1 284 285 277 1641 HA_5VX1 $T=-43560 -358400 1 0 $X=-43990 $Y=-363520
X17137 2 1 1695 304 290 2828 HA_5VX1 $T=-24520 -340480 1 180 $X=-33910 $Y=-341120
X17138 2 1 1668 1580 1691 2830 HA_5VX1 $T=-30120 -394240 0 0 $X=-30550 $Y=-394880
X17139 2 1 1677 801 1580 2835 HA_5VX1 $T=-29560 -385280 0 0 $X=-29990 $Y=-385920
X17140 2 1 1676 1704 795 1711 HA_5VX1 $T=-22840 -376320 1 0 $X=-23270 $Y=-381440
X17141 2 1 1719 795 304 2845 HA_5VX1 $T=-9400 -304640 0 180 $X=-18790 $Y=-309760
X17142 2 1 1665 1534 1717 1706 HA_5VX1 $T=-15000 -394240 1 0 $X=-15430 $Y=-399360
X17143 2 1 2847 1730 801 1741 HA_5VX1 $T=-9400 -385280 0 0 $X=-9830 $Y=-385920
X17144 2 1 1775 801 1691 2864 HA_5VX1 $T=9640 -376320 0 180 $X=250 $Y=-381440
X17145 2 1 1761 2865 1776 1545 HA_5VX1 $T=2920 -322560 1 0 $X=2490 $Y=-327680
X17146 2 1 1746 1534 2884 2880 HA_5VX1 $T=6840 -367360 1 0 $X=6410 $Y=-372480
X17147 2 1 1427 1782 1798 1776 HA_5VX1 $T=12440 -322560 1 0 $X=12010 $Y=-327680
X17148 2 1 1804 1810 795 1816 HA_5VX1 $T=22520 -340480 0 0 $X=22090 $Y=-341120
X17149 2 1 2908 1534 794 2902 HA_5VX1 $T=41000 -358400 1 180 $X=31610 $Y=-359040
X17150 2 1 1808 1534 2911 2907 HA_5VX1 $T=34840 -358400 1 0 $X=34410 $Y=-363520
X17151 2 1 351 290 277 1866 HA_5VX1 $T=39880 -295680 0 0 $X=39450 $Y=-296320
X17152 2 1 1871 2911 1868 799 HA_5VX1 $T=41560 -376320 1 0 $X=41130 $Y=-381440
X17153 2 1 356 285 274 2910 HA_5VX1 $T=44920 -277760 1 0 $X=44490 $Y=-282880
X17154 2 1 1889 304 285 1845 HA_5VX1 $T=57800 -295680 1 180 $X=48410 $Y=-296320
X17155 2 1 2920 1860 801 1880 HA_5VX1 $T=54440 -358400 1 0 $X=54010 $Y=-363520
X17156 2 1 1461 1917 1938 1798 HA_5VX1 $T=64520 -331520 0 0 $X=64090 $Y=-332160
X17157 2 1 1933 1534 2961 1953 HA_5VX1 $T=77960 -349440 0 0 $X=77530 $Y=-350080
X17158 2 1 1976 1534 801 1965 HA_5VX1 $T=90840 -358400 1 180 $X=81450 $Y=-359040
X17159 2 1 2969 1534 801 2964 HA_5VX1 $T=93640 -340480 0 180 $X=84250 $Y=-345600
X17160 2 1 1985 1534 1968 1999 HA_5VX1 $T=94200 -394240 0 0 $X=93770 $Y=-394880
X17161 2 1 2062 2054 3274 2047 HA_5VX1 $T=128920 -421120 0 180 $X=119530 $Y=-426240
X17162 2 1 3008 2047 3003 3005 HA_5VX1 $T=135080 -412160 0 180 $X=125690 $Y=-417280
X17163 2 1 2057 3005 2068 2069 HA_5VX1 $T=127800 -403200 1 0 $X=127370 $Y=-408320
X17164 2 1 3275 3020 2080 3016 HA_5VX1 $T=160840 -358400 1 180 $X=151450 $Y=-359040
X17165 2 1 2082 3016 2102 3019 HA_5VX1 $T=151880 -349440 1 0 $X=151450 $Y=-354560
X17166 2 1 3276 3018 3013 3014 HA_5VX1 $T=160840 -313600 0 180 $X=151450 $Y=-318720
X17167 2 1 3277 2095 3014 3017 HA_5VX1 $T=160840 -304640 0 180 $X=151450 $Y=-309760
X17168 2 1 3025 2092 2085 2079 HA_5VX1 $T=161400 -385280 1 180 $X=152010 $Y=-385920
X17169 2 1 2098 2093 2079 812 HA_5VX1 $T=161400 -376320 1 180 $X=152010 $Y=-376960
X17170 2 1 2094 2074 812 2080 HA_5VX1 $T=161400 -367360 1 180 $X=152010 $Y=-368000
X17171 2 1 2077 2088 3026 1938 HA_5VX1 $T=152440 -331520 1 0 $X=152010 $Y=-336640
X17172 2 1 3278 3019 3012 3018 HA_5VX1 $T=161400 -331520 1 180 $X=152010 $Y=-332160
X17173 2 1 3015 3017 3024 449 HA_5VX1 $T=152440 -286720 0 0 $X=152010 $Y=-287360
X17174 2 1 2091 2069 3011 2085 HA_5VX1 $T=161960 -394240 1 180 $X=152570 $Y=-394880
X17175 2 1 2114 3025 2090 2097 HA_5VX1 $T=165880 -376320 0 180 $X=156490 $Y=-381440
X17176 2 1 2113 2076 2091 2090 HA_5VX1 $T=166440 -385280 0 180 $X=157050 $Y=-390400
X17177 2 1 2112 2097 2098 2099 HA_5VX1 $T=166440 -367360 0 180 $X=157050 $Y=-372480
X17178 2 1 2120 2099 2094 2100 HA_5VX1 $T=167000 -358400 0 180 $X=157610 $Y=-363520
X17179 2 1 2125 3027 2082 2105 HA_5VX1 $T=168120 -349440 1 180 $X=158730 $Y=-350080
X17180 2 1 1779 3243 2128 3026 HA_5VX1 $T=160280 -340480 0 0 $X=159850 $Y=-341120
X17181 2 1 2124 2100 3275 3027 HA_5VX1 $T=169800 -358400 1 180 $X=160410 $Y=-359040
X17182 2 1 2126 3028 3276 2115 HA_5VX1 $T=169800 -313600 0 180 $X=160410 $Y=-318720
X17183 2 1 2122 2115 3277 2110 HA_5VX1 $T=169800 -304640 0 180 $X=160410 $Y=-309760
X17184 2 1 2096 2105 3278 3028 HA_5VX1 $T=170360 -331520 1 180 $X=160970 $Y=-332160
X17185 2 1 814 2110 3015 457 HA_5VX1 $T=171480 -286720 1 180 $X=162090 $Y=-287360
X17186 2 1 2207 3035 2147 2162 HA_5VX1 $T=187160 -367360 1 180 $X=177770 $Y=-368000
X17187 2 1 2176 2245 2161 3038 HA_5VX1 $T=195560 -331520 1 180 $X=186170 $Y=-332160
X17188 2 1 2179 2175 2162 3039 HA_5VX1 $T=197240 -367360 1 180 $X=187850 $Y=-368000
X17189 2 1 2148 2169 2180 3042 HA_5VX1 $T=189400 -313600 1 0 $X=188970 $Y=-318720
X17190 2 1 1797 2171 3279 493 HA_5VX1 $T=189400 -277760 0 0 $X=188970 $Y=-278400
X17191 2 1 2211 2183 3039 2166 HA_5VX1 $T=198920 -358400 0 180 $X=189530 $Y=-363520
X17192 2 1 3054 2239 2166 2168 HA_5VX1 $T=199480 -349440 0 180 $X=190090 $Y=-354560
X17193 2 1 2209 2186 2168 2161 HA_5VX1 $T=200040 -349440 1 180 $X=190650 $Y=-350080
X17194 2 1 3280 2173 3047 2180 HA_5VX1 $T=191640 -322560 1 0 $X=191210 $Y=-327680
X17195 2 1 2144 3042 2191 3044 HA_5VX1 $T=192200 -304640 0 0 $X=191770 $Y=-305280
X17196 2 1 3281 3046 2206 2187 HA_5VX1 $T=196680 -340480 0 0 $X=196250 $Y=-341120
X17197 2 1 3043 2187 2195 2173 HA_5VX1 $T=196680 -331520 0 0 $X=196250 $Y=-332160
X17198 2 1 3053 3051 2185 3049 HA_5VX1 $T=205640 -286720 1 180 $X=196250 $Y=-287360
X17199 2 1 2243 3044 3053 2171 HA_5VX1 $T=197240 -295680 0 0 $X=196810 $Y=-296320
X17200 2 1 3047 2197 3282 2203 HA_5VX1 $T=198920 -313600 1 0 $X=198490 $Y=-318720
X17201 2 1 2191 2198 3052 3051 HA_5VX1 $T=198920 -295680 1 0 $X=198490 $Y=-300800
X17202 2 1 3279 3049 3283 506 HA_5VX1 $T=198920 -277760 0 0 $X=198490 $Y=-278400
X17203 2 1 2169 2199 2203 3052 HA_5VX1 $T=199480 -313600 0 0 $X=199050 $Y=-314240
X17204 2 1 2195 2201 2215 2197 HA_5VX1 $T=201720 -322560 1 0 $X=201290 $Y=-327680
X17205 2 1 3046 3055 2224 2215 HA_5VX1 $T=206200 -340480 0 0 $X=205770 $Y=-341120
X17206 2 1 2189 2214 3284 2206 HA_5VX1 $T=207880 -349440 0 0 $X=207450 $Y=-350080
X17207 2 1 3284 2255 3285 2224 HA_5VX1 $T=216840 -349440 0 0 $X=216410 $Y=-350080
X17208 2 1 3067 2261 2248 2255 HA_5VX1 $T=238680 -349440 0 180 $X=229290 $Y=-354560
X17209 2 1 3070 2273 2282 3073 HA_5VX1 $T=243720 -358400 0 0 $X=243290 $Y=-359040
X17210 2 1 2260 2210 2286 3072 HA_5VX1 $T=244280 -322560 1 0 $X=243850 $Y=-327680
X17211 2 1 2299 2297 2286 2285 HA_5VX1 $T=261080 -331520 1 180 $X=251690 $Y=-332160
X17212 2 1 2264 3073 3286 2261 HA_5VX1 $T=253800 -358400 0 0 $X=253370 $Y=-359040
X17213 2 1 2295 2219 514 817 HA_5VX1 $T=258280 -313600 0 0 $X=257850 $Y=-314240
X17214 2 1 3082 2210 514 2277 HA_5VX1 $T=269480 -304640 1 180 $X=260090 $Y=-305280
X17215 2 1 2317 517 510 2321 HA_5VX1 $T=276200 -313600 1 0 $X=275770 $Y=-318720
X17216 2 1 618 2210 514 3093 HA_5VX1 $T=279560 -277760 1 0 $X=279130 $Y=-282880
X17217 2 1 2320 2210 3097 2324 HA_5VX1 $T=282360 -295680 0 0 $X=281930 $Y=-296320
X17218 2 1 3103 2210 652 3106 HA_5VX1 $T=305880 -313600 0 0 $X=305450 $Y=-314240
X17219 2 1 3112 3109 2337 2346 HA_5VX1 $T=318760 -322560 0 180 $X=309370 $Y=-327680
X17220 2 1 3113 3109 514 2347 HA_5VX1 $T=322120 -322560 1 180 $X=312730 $Y=-323200
X17221 2 1 2443 2400 692 3185 HA_5VX1 $T=443640 -340480 0 180 $X=434250 $Y=-345600
X17222 2 1 2449 2219 693 3192 HA_5VX1 $T=445880 -322560 1 0 $X=445450 $Y=-327680
X17223 2 1 2434 2400 2219 3194 HA_5VX1 $T=461560 -340480 1 180 $X=452170 $Y=-341120
X17224 2 1 728 693 692 2469 HA_5VX1 $T=459880 -295680 0 0 $X=459450 $Y=-296320
X17225 2 1 726 730 517 731 HA_5VX1 $T=462120 -277760 0 0 $X=461690 $Y=-278400
X17226 2 1 723 514 693 3200 HA_5VX1 $T=464920 -277760 1 0 $X=464490 $Y=-282880
X17227 2 1 2480 820 514 3202 HA_5VX1 $T=477800 -304640 0 180 $X=468410 $Y=-309760
X17228 2 1 2472 2400 738 3207 HA_5VX1 $T=489560 -277760 0 180 $X=480170 $Y=-282880
X17229 2 1 976 981 55 80 EO3_5VX1 $T=-310120 -295680 1 180 $X=-322870 $Y=-296320
X17230 2 1 963 978 894 987 EO3_5VX1 $T=-316840 -304640 1 0 $X=-317270 $Y=-309760
X17231 2 1 47 1064 36 2611 EO3_5VX1 $T=-268680 -313600 0 180 $X=-281430 $Y=-318720
X17232 2 1 1140 51 47 1072 EO3_5VX1 $T=-263640 -367360 0 180 $X=-276390 $Y=-372480
X17233 2 1 36 1107 31 1127 EO3_5VX1 $T=-266440 -340480 0 0 $X=-266870 $Y=-341120
X17234 2 1 1124 2641 33 1117 EO3_5VX1 $T=-246280 -340480 0 180 $X=-259030 $Y=-345600
X17235 2 1 1143 1151 25 1148 EO3_5VX1 $T=-235080 -331520 1 180 $X=-247830 $Y=-332160
X17236 2 1 1174 1163 47 1155 EO3_5VX1 $T=-233400 -340480 0 180 $X=-246150 $Y=-345600
X17237 2 1 1190 1214 32 2650 EO3_5VX1 $T=-226680 -322560 1 180 $X=-239430 $Y=-323200
X17238 2 1 1187 1201 55 2660 EO3_5VX1 $T=-235080 -322560 1 0 $X=-235510 $Y=-327680
X17239 2 1 1206 1199 894 2664 EO3_5VX1 $T=-226680 -358400 1 0 $X=-227110 $Y=-363520
X17240 2 1 1184 1213 31 1214 EO3_5VX1 $T=-211560 -340480 0 180 $X=-224310 $Y=-345600
X17241 2 1 1251 33 25 1259 EO3_5VX1 $T=-218840 -286720 0 0 $X=-219270 $Y=-287360
X17242 2 1 1237 1244 25 1272 EO3_5VX1 $T=-217720 -331520 0 0 $X=-218150 $Y=-332160
X17243 2 1 1258 47 33 1244 EO3_5VX1 $T=-203720 -340480 1 180 $X=-216470 $Y=-341120
X17244 2 1 1259 1277 23 1295 EO3_5VX1 $T=-207080 -286720 1 0 $X=-207510 $Y=-291840
X17245 2 1 1282 1265 190 1302 EO3_5VX1 $T=-205960 -304640 1 0 $X=-206390 $Y=-309760
X17246 2 1 1295 1276 182 1308 EO3_5VX1 $T=-205960 -286720 0 0 $X=-206390 $Y=-287360
X17247 2 1 894 1298 171 1234 EO3_5VX1 $T=-191400 -349440 1 180 $X=-204150 $Y=-350080
X17248 2 1 1272 1262 23 1299 EO3_5VX1 $T=-202600 -322560 0 0 $X=-203030 $Y=-323200
X17249 2 1 1279 33 31 1374 EO3_5VX1 $T=-181320 -340480 1 0 $X=-181750 $Y=-345600
X17250 2 1 776 36 33 1380 EO3_5VX1 $T=-175720 -349440 1 0 $X=-176150 $Y=-354560
X17251 2 1 1321 1298 49 1370 EO3_5VX1 $T=-174600 -376320 1 0 $X=-175030 $Y=-381440
X17252 2 1 1289 49 47 1399 EO3_5VX1 $T=-162280 -367360 1 0 $X=-162710 $Y=-372480
X17253 2 1 1377 1367 55 1406 EO3_5VX1 $T=-161720 -403200 1 0 $X=-162150 $Y=-408320
X17254 2 1 1416 1428 1436 1457 EO3_5VX1 $T=-145480 -286720 0 0 $X=-145910 $Y=-287360
X17255 2 1 1451 2749 1445 1475 EO3_5VX1 $T=-134280 -304640 1 0 $X=-134710 $Y=-309760
X17256 2 1 1568 2786 1565 2797 EO3_5VX1 $T=-73800 -313600 1 0 $X=-74230 $Y=-318720
X17257 2 1 297 274 268 2807 EO3_5VX1 $T=-39080 -304640 1 180 $X=-51830 $Y=-305280
X17258 2 1 274 1648 1642 282 EO3_5VX1 $T=-38520 -313600 1 180 $X=-51270 $Y=-314240
X17259 2 1 1671 290 285 788 EO3_5VX1 $T=-31240 -367360 0 180 $X=-43990 $Y=-372480
X17260 2 1 1674 304 290 1615 EO3_5VX1 $T=-30120 -394240 1 180 $X=-42870 $Y=-394880
X17261 2 1 1580 795 304 1656 EO3_5VX1 $T=-12200 -421120 1 180 $X=-24950 $Y=-421760
X17262 2 1 2848 315 1715 1750 EO3_5VX1 $T=-9400 -322560 1 0 $X=-9830 $Y=-327680
X17263 2 1 1756 1753 1539 1739 EO3_5VX1 $T=6840 -313600 1 180 $X=-5910 $Y=-314240
X17264 2 1 2855 1745 1812 2868 EO3_5VX1 $T=-3240 -295680 1 0 $X=-3670 $Y=-300800
X17265 2 1 1764 1771 1767 2871 EO3_5VX1 $T=-3240 -286720 0 0 $X=-3670 $Y=-287360
X17266 2 1 1746 1580 795 2889 EO3_5VX1 $T=15240 -403200 1 0 $X=14810 $Y=-408320
X17267 2 1 1785 1804 290 1813 EO3_5VX1 $T=15240 -331520 0 0 $X=14810 $Y=-332160
X17268 2 1 1818 285 274 1800 EO3_5VX1 $T=46600 -304640 1 180 $X=33850 $Y=-305280
X17269 2 1 274 354 264 1839 EO3_5VX1 $T=50520 -277760 1 180 $X=37770 $Y=-278400
X17270 2 1 304 1823 285 1882 EO3_5VX1 $T=39880 -322560 1 0 $X=39450 $Y=-327680
X17271 2 1 1887 304 285 1870 EO3_5VX1 $T=58360 -340480 0 180 $X=45610 $Y=-345600
X17272 2 1 1864 290 277 1895 EO3_5VX1 $T=70680 -340480 1 180 $X=57930 $Y=-341120
X17273 2 1 2015 258 265 3004 EO3_5VX1 $T=112120 -313600 0 0 $X=111690 $Y=-314240
X17274 2 1 2020 274 2002 3242 EO3_5VX1 $T=112680 -358400 1 0 $X=112250 $Y=-363520
X17275 2 1 2031 265 267 3006 EO3_5VX1 $T=117160 -304640 0 0 $X=116730 $Y=-305280
X17276 2 1 2009 268 264 3007 EO3_5VX1 $T=119400 -340480 1 0 $X=118970 $Y=-345600
X17277 2 1 1990 264 258 3000 EO3_5VX1 $T=133400 -331520 1 180 $X=120650 $Y=-332160
X17278 2 1 424 267 434 3010 EO3_5VX1 $T=125000 -277760 1 0 $X=124570 $Y=-282880
X17279 2 1 564 555 544 3060 EO3_5VX1 $T=233640 -295680 1 180 $X=220890 $Y=-296320
X17280 2 1 568 544 543 3061 EO3_5VX1 $T=234760 -277760 0 180 $X=222010 $Y=-282880
X17281 2 1 2266 592 586 2252 EO3_5VX1 $T=257720 -277760 0 180 $X=244970 $Y=-282880
X17282 2 1 2294 2313 2304 3286 EO3_5VX1 $T=275640 -358400 1 180 $X=262890 $Y=-359040
X17283 2 1 2369 549 555 3128 EO3_5VX1 $T=352920 -304640 1 180 $X=340170 $Y=-305280
X17284 2 1 714 524 511 2444 EO3_5VX1 $T=444760 -286720 0 180 $X=432010 $Y=-291840
X17285 2 1 2400 517 510 709 EO3_5VX1 $T=433000 -304640 1 0 $X=432570 $Y=-309760
X17286 2 1 2452 510 524 3195 EO3_5VX1 $T=447560 -295680 0 0 $X=447130 $Y=-296320
X17287 2 1 732 510 511 2487 EO3_5VX1 $T=469400 -286720 0 0 $X=468970 $Y=-287360
X17288 2 1 830 838 842 835 834 FA_5VX1 $T=-426040 -304640 0 0 $X=-426470 $Y=-305280
X17289 2 1 831 23 2497 25 26 FA_5VX1 $T=-423800 -277760 1 0 $X=-424230 $Y=-282880
X17290 2 1 837 2496 3221 2499 838 FA_5VX1 $T=-419880 -313600 1 0 $X=-420310 $Y=-318720
X17291 2 1 2496 25 2498 33 842 FA_5VX1 $T=-418200 -313600 0 0 $X=-418630 $Y=-314240
X17292 2 1 835 32 31 2501 841 FA_5VX1 $T=-416520 -295680 0 0 $X=-416950 $Y=-296320
X17293 2 1 836 31 851 36 3221 FA_5VX1 $T=-413720 -322560 0 0 $X=-414150 $Y=-323200
X17294 2 1 843 33 2507 3287 2503 FA_5VX1 $T=-408120 -349440 0 0 $X=-408550 $Y=-350080
X17295 2 1 844 861 2508 23 35 FA_5VX1 $T=-406440 -286720 1 0 $X=-406870 $Y=-291840
X17296 2 1 866 25 847 2500 2505 FA_5VX1 $T=-385160 -313600 0 180 $X=-402390 $Y=-318720
X17297 2 1 850 31 871 855 2510 FA_5VX1 $T=-400840 -331520 0 0 $X=-401270 $Y=-332160
X17298 2 1 2500 33 885 2514 857 FA_5VX1 $T=-399720 -313600 0 0 $X=-400150 $Y=-314240
X17299 2 1 856 31 872 868 2508 FA_5VX1 $T=-399160 -295680 0 0 $X=-399590 $Y=-296320
X17300 2 1 867 36 49 2516 858 FA_5VX1 $T=-398600 -367360 0 0 $X=-399030 $Y=-368000
X17301 2 1 853 33 2515 873 859 FA_5VX1 $T=-398040 -340480 0 0 $X=-398470 $Y=-341120
X17302 2 1 862 32 857 856 861 FA_5VX1 $T=-381240 -295680 0 180 $X=-398470 $Y=-300800
X17303 2 1 852 870 49 2517 2512 FA_5VX1 $T=-397480 -349440 1 0 $X=-397910 $Y=-354560
X17304 2 1 855 36 874 2518 847 FA_5VX1 $T=-397480 -322560 1 0 $X=-397910 $Y=-327680
X17305 2 1 849 25 2521 881 48 FA_5VX1 $T=-395240 -277760 1 0 $X=-395670 $Y=-282880
X17306 2 1 863 47 51 886 869 FA_5VX1 $T=-393000 -376320 0 0 $X=-393430 $Y=-376960
X17307 2 1 868 36 47 883 2521 FA_5VX1 $T=-388520 -286720 1 0 $X=-388950 $Y=-291840
X17308 2 1 2513 884 893 49 52 FA_5VX1 $T=-387960 -286720 0 0 $X=-388390 $Y=-287360
X17309 2 1 881 33 2513 36 50 FA_5VX1 $T=-370600 -277760 1 180 $X=-387830 $Y=-278400
X17310 2 1 2514 47 49 880 872 FA_5VX1 $T=-386840 -304640 1 0 $X=-387270 $Y=-309760
X17311 2 1 873 47 51 2525 871 FA_5VX1 $T=-385720 -331520 1 0 $X=-386150 $Y=-336640
X17312 2 1 2518 49 878 51 885 FA_5VX1 $T=-382920 -322560 0 0 $X=-383350 $Y=-323200
X17313 2 1 875 55 2528 902 879 FA_5VX1 $T=-381240 -385280 0 0 $X=-381670 $Y=-385920
X17314 2 1 876 55 2530 923 2524 FA_5VX1 $T=-380680 -367360 0 0 $X=-381110 $Y=-368000
X17315 2 1 2517 55 877 892 2525 FA_5VX1 $T=-380680 -340480 1 0 $X=-381110 $Y=-345600
X17316 2 1 2515 55 2529 898 874 FA_5VX1 $T=-380680 -331520 0 0 $X=-381110 $Y=-332160
X17317 2 1 889 2524 2522 51 870 FA_5VX1 $T=-363320 -358400 1 180 $X=-380550 $Y=-359040
X17318 2 1 2522 894 2532 904 892 FA_5VX1 $T=-380120 -349440 0 0 $X=-380550 $Y=-350080
X17319 2 1 877 894 3288 899 898 FA_5VX1 $T=-380120 -340480 0 0 $X=-380550 $Y=-341120
X17320 2 1 878 894 2534 900 891 FA_5VX1 $T=-380120 -322560 1 0 $X=-380550 $Y=-327680
X17321 2 1 880 55 895 891 2523 FA_5VX1 $T=-379560 -313600 0 0 $X=-379990 $Y=-314240
X17322 2 1 883 2523 2531 51 884 FA_5VX1 $T=-378440 -295680 0 0 $X=-378870 $Y=-296320
X17323 2 1 53 917 894 51 59 FA_5VX1 $T=-378440 -277760 1 0 $X=-378870 $Y=-282880
X17324 2 1 2533 2539 2548 2550 2541 FA_5VX1 $T=-348200 -367360 0 0 $X=-348630 $Y=-368000
X17325 2 1 2532 2545 916 2552 899 FA_5VX1 $T=-348200 -340480 1 0 $X=-348630 $Y=-345600
X17326 2 1 905 931 913 910 2542 FA_5VX1 $T=-348200 -313600 0 0 $X=-348630 $Y=-314240
X17327 2 1 762 894 910 907 908 FA_5VX1 $T=-331400 -295680 0 180 $X=-348630 $Y=-300800
X17328 2 1 936 55 764 908 917 FA_5VX1 $T=-331400 -286720 0 180 $X=-348630 $Y=-291840
X17329 2 1 64 2544 936 929 69 FA_5VX1 $T=-348200 -277760 0 0 $X=-348630 $Y=-278400
X17330 2 1 2559 2542 765 764 907 FA_5VX1 $T=-330840 -304640 0 180 $X=-348070 $Y=-309760
X17331 2 1 66 2547 762 2557 2544 FA_5VX1 $T=-347640 -277760 1 0 $X=-348070 $Y=-282880
X17332 2 1 3288 932 921 2553 2540 FA_5VX1 $T=-347080 -340480 0 0 $X=-347510 $Y=-341120
X17333 2 1 906 932 910 957 926 FA_5VX1 $T=-346520 -394240 0 0 $X=-346950 $Y=-394880
X17334 2 1 761 926 938 924 927 FA_5VX1 $T=-346520 -385280 0 0 $X=-346950 $Y=-385920
X17335 2 1 912 894 2533 927 923 FA_5VX1 $T=-329720 -376320 1 180 $X=-346950 $Y=-376960
X17336 2 1 2530 2541 2564 2556 904 FA_5VX1 $T=-346520 -358400 1 0 $X=-346950 $Y=-363520
X17337 2 1 2529 2540 916 2554 900 FA_5VX1 $T=-346520 -331520 0 0 $X=-346950 $Y=-332160
X17338 2 1 909 894 2551 941 902 FA_5VX1 $T=-345960 -403200 1 0 $X=-346390 $Y=-408320
X17339 2 1 77 2555 905 919 933 FA_5VX1 $T=-325800 -286720 1 180 $X=-343030 $Y=-287360
X17340 2 1 949 2537 913 2546 940 FA_5VX1 $T=-321320 -313600 0 180 $X=-338550 $Y=-318720
X17341 2 1 943 961 959 2570 941 FA_5VX1 $T=-332520 -403200 0 0 $X=-332950 $Y=-403840
X17342 2 1 90 2563 763 940 919 FA_5VX1 $T=-314600 -304640 1 180 $X=-331830 $Y=-305280
X17343 2 1 89 933 2559 954 2547 FA_5VX1 $T=-314040 -277760 0 180 $X=-331270 $Y=-282880
X17344 2 1 1000 2575 979 2573 961 FA_5VX1 $T=-298920 -403200 0 180 $X=-316150 $Y=-408320
X17345 2 1 2584 2574 921 922 2575 FA_5VX1 $T=-298920 -394240 1 180 $X=-316150 $Y=-394880
X17346 2 1 1013 55 977 980 2576 FA_5VX1 $T=-298360 -313600 0 180 $X=-315590 $Y=-318720
X17347 2 1 1019 2576 987 51 99 FA_5VX1 $T=-297800 -304640 1 180 $X=-315030 $Y=-305280
X17348 2 1 2585 894 989 986 980 FA_5VX1 $T=-296680 -322560 1 180 $X=-313910 $Y=-323200
X17349 2 1 998 894 1028 1015 1058 FA_5VX1 $T=-306200 -322560 1 0 $X=-306630 $Y=-327680
X17350 2 1 2578 971 1003 994 1021 FA_5VX1 $T=-305640 -358400 0 0 $X=-306070 $Y=-359040
X17351 2 1 2602 33 2580 2579 1016 FA_5VX1 $T=-288280 -286720 1 180 $X=-305510 $Y=-287360
X17352 2 1 104 107 2595 2602 1047 FA_5VX1 $T=-301720 -277760 0 0 $X=-302150 $Y=-278400
X17353 2 1 1024 55 1009 1012 2591 FA_5VX1 $T=-283240 -340480 1 180 $X=-300470 $Y=-341120
X17354 2 1 1009 2599 2605 2603 1028 FA_5VX1 $T=-299480 -367360 1 0 $X=-299910 $Y=-372480
X17355 2 1 1011 894 1021 1057 1012 FA_5VX1 $T=-298920 -349440 1 0 $X=-299350 $Y=-354560
X17356 2 1 2607 2589 988 2587 2609 FA_5VX1 $T=-281560 -340480 0 180 $X=-298790 $Y=-345600
X17357 2 1 111 1045 1055 1042 2595 FA_5VX1 $T=-298360 -313600 1 0 $X=-298790 $Y=-318720
X17358 2 1 1025 956 1022 913 1010 FA_5VX1 $T=-281000 -403200 0 180 $X=-298230 $Y=-408320
X17359 2 1 1018 55 2607 1058 1035 FA_5VX1 $T=-297800 -331520 0 0 $X=-298230 $Y=-332160
X17360 2 1 1082 2603 2598 2596 989 FA_5VX1 $T=-272600 -358400 0 180 $X=-289830 $Y=-363520
X17361 2 1 2617 31 2601 1030 122 FA_5VX1 $T=-272040 -286720 0 180 $X=-289270 $Y=-291840
X17362 2 1 2615 2611 1040 1048 1060 FA_5VX1 $T=-271480 -313600 1 180 $X=-288710 $Y=-314240
X17363 2 1 1071 1054 769 994 2610 FA_5VX1 $T=-270920 -358400 1 180 $X=-288150 $Y=-359040
X17364 2 1 1084 33 2604 2600 1068 FA_5VX1 $T=-270920 -322560 0 180 $X=-288150 $Y=-327680
X17365 2 1 2600 47 51 2613 1045 FA_5VX1 $T=-287720 -322560 0 0 $X=-288150 $Y=-323200
X17366 2 1 1049 32 1016 2617 128 FA_5VX1 $T=-286040 -286720 0 0 $X=-286470 $Y=-287360
X17367 2 1 3289 1049 1047 23 125 FA_5VX1 $T=-268120 -277760 1 180 $X=-285350 $Y=-278400
X17368 2 1 1053 894 2620 1097 1067 FA_5VX1 $T=-283800 -394240 1 0 $X=-284230 $Y=-399360
X17369 2 1 2604 55 1082 1075 1055 FA_5VX1 $T=-283240 -349440 0 0 $X=-283670 $Y=-350080
X17370 2 1 1051 55 1093 1085 2613 FA_5VX1 $T=-283240 -340480 0 0 $X=-283670 $Y=-341120
X17371 2 1 1093 894 2610 1059 1075 FA_5VX1 $T=-265320 -349440 0 180 $X=-282550 $Y=-354560
X17372 2 1 1064 1035 1112 51 1083 FA_5VX1 $T=-281000 -331520 0 0 $X=-281430 $Y=-332160
X17373 2 1 1063 2618 49 2624 2616 FA_5VX1 $T=-279880 -376320 1 0 $X=-280310 $Y=-381440
X17374 2 1 2624 55 1069 1067 2614 FA_5VX1 $T=-261960 -385280 1 180 $X=-279190 $Y=-385920
X17375 2 1 2623 1031 1068 25 1108 FA_5VX1 $T=-261960 -295680 1 180 $X=-279190 $Y=-296320
X17376 2 1 1112 894 1071 2609 1085 FA_5VX1 $T=-260840 -340480 0 180 $X=-278070 $Y=-345600
X17377 2 1 1102 1072 2614 2616 1101 FA_5VX1 $T=-255800 -376320 1 180 $X=-273030 $Y=-376960
X17378 2 1 2619 3225 1101 36 1126 FA_5VX1 $T=-270920 -358400 1 0 $X=-271350 $Y=-363520
X17379 2 1 2634 1083 49 1051 1094 FA_5VX1 $T=-254120 -322560 0 180 $X=-271350 $Y=-327680
X17380 2 1 2636 1084 1094 31 1092 FA_5VX1 $T=-253560 -322560 1 180 $X=-270790 $Y=-323200
X17381 2 1 1087 1120 2634 1060 2627 FA_5VX1 $T=-270360 -313600 0 0 $X=-270790 $Y=-314240
X17382 2 1 2637 2623 1092 1095 1105 FA_5VX1 $T=-253000 -295680 0 180 $X=-270230 $Y=-300800
X17383 2 1 1069 2632 1132 1139 2626 FA_5VX1 $T=-269240 -385280 1 0 $X=-269670 $Y=-390400
X17384 2 1 3223 2627 1110 2636 1095 FA_5VX1 $T=-269240 -304640 1 0 $X=-269670 $Y=-309760
X17385 2 1 1120 33 36 1079 1110 FA_5VX1 $T=-251880 -313600 0 180 $X=-269110 $Y=-318720
X17386 2 1 1128 1099 135 3289 140 FA_5VX1 $T=-251320 -277760 1 180 $X=-268550 $Y=-278400
X17387 2 1 2620 1135 921 1142 2632 FA_5VX1 $T=-265880 -394240 1 0 $X=-266310 $Y=-399360
X17388 2 1 2643 55 1109 1106 1124 FA_5VX1 $T=-246840 -367360 0 180 $X=-264070 $Y=-372480
X17389 2 1 3225 2639 49 2643 2635 FA_5VX1 $T=-263640 -367360 0 0 $X=-264070 $Y=-368000
X17390 2 1 1140 894 1115 2626 1106 FA_5VX1 $T=-245160 -385280 1 180 $X=-262390 $Y=-385920
X17391 2 1 1109 1161 1162 922 2647 FA_5VX1 $T=-255800 -376320 0 0 $X=-256230 $Y=-376960
X17392 2 1 1165 894 1153 2647 1170 FA_5VX1 $T=-230040 -367360 0 180 $X=-247270 $Y=-372480
X17393 2 1 2644 55 2652 1170 1171 FA_5VX1 $T=-246840 -367360 0 0 $X=-247270 $Y=-368000
X17394 2 1 1107 2648 49 2644 1143 FA_5VX1 $T=-229480 -349440 0 180 $X=-246710 $Y=-354560
X17395 2 1 154 1182 1192 1183 162 FA_5VX1 $T=-245160 -277760 1 0 $X=-245590 $Y=-282880
X17396 2 1 155 1173 1181 1235 167 FA_5VX1 $T=-241240 -286720 0 0 $X=-241670 $Y=-287360
X17397 2 1 1174 1186 1209 1197 1195 FA_5VX1 $T=-238440 -385280 0 0 $X=-238870 $Y=-385920
X17398 2 1 1180 2653 51 1232 1205 FA_5VX1 $T=-235080 -340480 0 0 $X=-235510 $Y=-341120
X17399 2 1 1181 1205 2661 1234 170 FA_5VX1 $T=-234520 -331520 0 0 $X=-234950 $Y=-332160
X17400 2 1 2653 55 922 1247 2661 FA_5VX1 $T=-231160 -331520 1 0 $X=-231590 $Y=-336640
X17401 2 1 1200 1241 2664 51 1229 FA_5VX1 $T=-229480 -358400 0 0 $X=-229910 $Y=-359040
X17402 2 1 1251 1229 2660 49 1226 FA_5VX1 $T=-209880 -322560 1 180 $X=-227110 $Y=-323200
X17403 2 1 181 1226 47 1208 178 FA_5VX1 $T=-208760 -277760 1 180 $X=-225990 $Y=-278400
X17404 2 1 1213 36 2669 49 1237 FA_5VX1 $T=-223880 -349440 0 0 $X=-224310 $Y=-350080
X17405 2 1 2669 894 1220 1195 1221 FA_5VX1 $T=-205400 -376320 1 180 $X=-222630 $Y=-376960
X17406 2 1 1258 55 1228 1221 1241 FA_5VX1 $T=-205400 -367360 1 180 $X=-222630 $Y=-368000
X17407 2 1 1271 55 1243 1242 1232 FA_5VX1 $T=-200360 -349440 0 180 $X=-217590 $Y=-354560
X17408 2 1 1243 894 956 2675 1247 FA_5VX1 $T=-213800 -358400 1 0 $X=-214230 $Y=-363520
X17409 2 1 197 187 1260 182 189 FA_5VX1 $T=-191960 -277760 1 180 $X=-209190 $Y=-278400
X17410 2 1 2681 1281 956 1268 1269 FA_5VX1 $T=-188600 -376320 1 180 $X=-205830 $Y=-376960
X17411 2 1 775 2672 1274 1269 1270 FA_5VX1 $T=-188600 -367360 1 180 $X=-205830 $Y=-368000
X17412 2 1 1310 894 1275 1270 1242 FA_5VX1 $T=-188600 -358400 1 180 $X=-205830 $Y=-359040
X17413 2 1 2684 23 2670 1248 1260 FA_5VX1 $T=-188040 -295680 1 180 $X=-205270 $Y=-296320
X17414 2 1 1307 1314 1310 171 3228 FA_5VX1 $T=-184120 -340480 0 180 $X=-201350 $Y=-345600
X17415 2 1 2691 32 3228 1290 1294 FA_5VX1 $T=-181320 -322560 0 180 $X=-198550 $Y=-327680
X17416 2 1 1323 2684 1294 190 195 FA_5VX1 $T=-181320 -295680 0 180 $X=-198550 $Y=-300800
X17417 2 1 1346 1324 1312 1329 1309 FA_5VX1 $T=-193640 -367360 1 0 $X=-194070 $Y=-372480
X17418 2 1 1339 2689 775 1298 1314 FA_5VX1 $T=-176280 -349440 0 180 $X=-193510 $Y=-354560
X17419 2 1 1340 2685 1284 1303 1315 FA_5VX1 $T=-175720 -421120 0 180 $X=-192950 $Y=-426240
X17420 2 1 1337 25 1307 36 1311 FA_5VX1 $T=-175160 -331520 1 180 $X=-192390 $Y=-332160
X17421 2 1 3229 2687 2681 1309 2689 FA_5VX1 $T=-173480 -358400 0 180 $X=-190710 $Y=-363520
X17422 2 1 1358 2691 1311 23 1322 FA_5VX1 $T=-173480 -322560 1 180 $X=-190710 $Y=-323200
X17423 2 1 1279 2695 49 3229 1318 FA_5VX1 $T=-188600 -358400 0 0 $X=-189030 $Y=-359040
X17424 2 1 2703 25 1318 2686 1330 FA_5VX1 $T=-169560 -331520 0 180 $X=-186790 $Y=-336640
X17425 2 1 776 2698 1346 51 2695 FA_5VX1 $T=-185240 -367360 0 0 $X=-185670 $Y=-368000
X17426 2 1 2686 31 47 1339 1331 FA_5VX1 $T=-185240 -349440 0 0 $X=-185670 $Y=-350080
X17427 2 1 1347 1330 1331 32 1351 FA_5VX1 $T=-163960 -322560 0 180 $X=-181190 $Y=-327680
X17428 2 1 1350 55 2693 1334 2698 FA_5VX1 $T=-162840 -376320 1 180 $X=-180070 $Y=-376960
X17429 2 1 1289 894 777 3290 1334 FA_5VX1 $T=-161160 -385280 1 180 $X=-178390 $Y=-385920
X17430 2 1 1367 894 2683 2696 1342 FA_5VX1 $T=-159480 -394240 0 180 $X=-176710 $Y=-399360
X17431 2 1 1363 1315 1327 1341 1345 FA_5VX1 $T=-158360 -421120 1 180 $X=-175590 $Y=-421760
X17432 2 1 1388 55 1336 1342 1361 FA_5VX1 $T=-156680 -394240 1 180 $X=-173910 $Y=-394880
X17433 2 1 2715 1324 2700 1345 1377 FA_5VX1 $T=-155560 -412160 0 180 $X=-172790 $Y=-417280
X17434 2 1 2717 1360 1350 47 1365 FA_5VX1 $T=-155000 -358400 1 180 $X=-172230 $Y=-359040
X17435 2 1 1395 2712 2702 1366 2707 FA_5VX1 $T=-154440 -286720 1 180 $X=-171670 $Y=-287360
X17436 2 1 2716 2707 2701 210 214 FA_5VX1 $T=-153880 -277760 1 180 $X=-171110 $Y=-278400
X17437 2 1 3231 2703 1356 1355 1372 FA_5VX1 $T=-152760 -331520 0 180 $X=-169990 $Y=-336640
X17438 2 1 1405 2713 1357 3267 1362 FA_5VX1 $T=-150520 -304640 0 180 $X=-167750 $Y=-309760
X17439 2 1 3291 2709 2706 1362 2712 FA_5VX1 $T=-150520 -295680 1 180 $X=-167750 $Y=-296320
X17440 2 1 1398 1459 1467 1457 233 FA_5VX1 $T=-143240 -286720 1 0 $X=-143670 $Y=-291840
X17441 2 1 1401 1478 1482 1475 1459 FA_5VX1 $T=-133160 -295680 1 0 $X=-133590 $Y=-300800
X17442 2 1 1458 2756 1484 1518 1445 FA_5VX1 $T=-131480 -322560 1 0 $X=-131910 $Y=-327680
X17443 2 1 1421 1458 1487 1486 1478 FA_5VX1 $T=-128680 -313600 0 0 $X=-129110 $Y=-314240
X17444 2 1 1497 1517 3235 2782 1518 FA_5VX1 $T=-97320 -322560 1 0 $X=-97750 $Y=-327680
X17445 2 1 1431 1497 1540 1528 1486 FA_5VX1 $T=-96760 -313600 1 0 $X=-97190 $Y=-318720
X17446 2 1 2767 1526 1537 1520 245 FA_5VX1 $T=-96760 -277760 1 0 $X=-97190 $Y=-282880
X17447 2 1 2771 1556 2787 1532 1526 FA_5VX1 $T=-90040 -304640 0 0 $X=-90470 $Y=-305280
X17448 2 1 1521 1559 2790 1598 1547 FA_5VX1 $T=-88920 -295680 1 0 $X=-89350 $Y=-300800
X17449 2 1 1524 1563 1569 1571 1531 FA_5VX1 $T=-86120 -331520 1 0 $X=-86550 $Y=-336640
X17450 2 1 1538 2793 1579 1583 2789 FA_5VX1 $T=-83320 -367360 1 0 $X=-83750 $Y=-372480
X17451 2 1 1533 2791 1570 1543 1564 FA_5VX1 $T=-82200 -412160 0 0 $X=-82630 $Y=-412800
X17452 2 1 1558 1564 1582 1588 1567 FA_5VX1 $T=-82200 -385280 1 0 $X=-82630 $Y=-390400
X17453 2 1 1536 2794 785 1589 1553 FA_5VX1 $T=-82200 -340480 1 0 $X=-82630 $Y=-345600
X17454 2 1 1541 1577 1587 1549 2791 FA_5VX1 $T=-81080 -421120 0 0 $X=-81510 $Y=-421760
X17455 2 1 1549 1585 1590 3292 1570 FA_5VX1 $T=-79960 -421120 1 0 $X=-80390 $Y=-426240
X17456 2 1 1543 1554 1591 1578 1582 FA_5VX1 $T=-79960 -394240 1 0 $X=-80390 $Y=-399360
X17457 2 1 3272 1584 1594 2797 1556 FA_5VX1 $T=-79400 -322560 0 0 $X=-79830 $Y=-323200
X17458 2 1 1511 255 1593 1595 262 FA_5VX1 $T=-79400 -277760 1 0 $X=-79830 $Y=-282880
X17459 2 1 1551 257 1599 261 249 FA_5VX1 $T=-76040 -277760 0 0 $X=-76470 $Y=-278400
X17460 2 1 1562 258 3293 2799 1583 FA_5VX1 $T=-74920 -376320 0 0 $X=-75350 $Y=-376960
X17461 2 1 1565 259 1601 267 1560 FA_5VX1 $T=-74920 -304640 1 0 $X=-75350 $Y=-309760
X17462 2 1 3236 1684 3258 1605 1584 FA_5VX1 $T=-73240 -322560 1 0 $X=-73670 $Y=-327680
X17463 2 1 1588 1562 1573 2792 1546 FA_5VX1 $T=-55320 -376320 0 180 $X=-72550 $Y=-381440
X17464 2 1 2790 261 2800 265 269 FA_5VX1 $T=-71560 -295680 1 0 $X=-71990 $Y=-300800
X17465 2 1 1563 261 2803 2801 1598 FA_5VX1 $T=-70440 -304640 0 0 $X=-70870 $Y=-305280
X17466 2 1 1559 1592 1608 259 1595 FA_5VX1 $T=-70440 -286720 0 0 $X=-70870 $Y=-287360
X17467 2 1 1554 264 2805 1612 1573 FA_5VX1 $T=-69880 -385280 0 0 $X=-70310 $Y=-385920
X17468 2 1 2793 265 1611 1604 1589 FA_5VX1 $T=-69320 -358400 0 0 $X=-69750 $Y=-359040
X17469 2 1 1569 267 2804 258 1592 FA_5VX1 $T=-69320 -340480 0 0 $X=-69750 $Y=-341120
X17470 2 1 1566 265 1613 3294 273 FA_5VX1 $T=-69320 -286720 1 0 $X=-69750 $Y=-291840
X17471 2 1 1578 268 1615 1616 2799 FA_5VX1 $T=-68760 -394240 0 0 $X=-69190 $Y=-394880
X17472 2 1 2794 267 1596 1606 1571 FA_5VX1 $T=-68760 -349440 1 0 $X=-69190 $Y=-354560
X17473 2 1 1568 258 1617 1619 1599 FA_5VX1 $T=-68200 -313600 0 0 $X=-68630 $Y=-314240
X17474 2 1 1611 268 2809 1649 1602 FA_5VX1 $T=-67640 -358400 1 0 $X=-68070 $Y=-363520
X17475 2 1 2808 2796 786 1586 1587 FA_5VX1 $T=-50280 -412160 0 180 $X=-67510 $Y=-417280
X17476 2 1 3257 1603 1618 2808 1577 FA_5VX1 $T=-67080 -403200 0 0 $X=-67510 $Y=-403840
X17477 2 1 2792 264 3217 1621 1604 FA_5VX1 $T=-67080 -367360 0 0 $X=-67510 $Y=-368000
X17478 2 1 1579 258 1628 1624 1606 FA_5VX1 $T=-66520 -367360 1 0 $X=-66950 $Y=-372480
X17479 2 1 1585 1614 1623 268 1591 FA_5VX1 $T=-65960 -403200 1 0 $X=-66390 $Y=-408320
X17480 2 1 785 265 787 1602 2801 FA_5VX1 $T=-65400 -340480 1 0 $X=-65830 $Y=-345600
X17481 2 1 1596 264 1639 2810 2804 FA_5VX1 $T=-63720 -349440 0 0 $X=-64150 $Y=-350080
X17482 2 1 1593 259 1633 1636 280 FA_5VX1 $T=-62040 -277760 1 0 $X=-62470 $Y=-282880
X17483 2 1 3292 274 1634 1656 1612 FA_5VX1 $T=-61480 -421120 1 0 $X=-61910 $Y=-426240
X17484 2 1 1605 1607 2798 270 1594 FA_5VX1 $T=-44680 -322560 1 180 $X=-61910 $Y=-323200
X17485 2 1 2796 274 1675 1644 1590 FA_5VX1 $T=-60920 -421120 0 0 $X=-61350 $Y=-421760
X17486 2 1 1607 278 2811 289 2786 FA_5VX1 $T=-59800 -313600 1 0 $X=-60230 $Y=-318720
X17487 2 1 1600 2802 2812 264 1601 FA_5VX1 $T=-58120 -331520 1 0 $X=-58550 $Y=-336640
X17488 2 1 272 258 1643 2822 283 FA_5VX1 $T=-58120 -277760 0 0 $X=-58550 $Y=-278400
X17489 2 1 3293 274 2823 1650 1624 FA_5VX1 $T=-57000 -376320 0 0 $X=-57430 $Y=-376960
X17490 2 1 786 277 1679 290 1614 FA_5VX1 $T=-56440 -412160 0 0 $X=-56870 $Y=-412800
X17491 2 1 2802 274 1645 3295 1617 FA_5VX1 $T=-56440 -331520 0 0 $X=-56870 $Y=-332160
X17492 2 1 1619 1640 1646 268 1613 FA_5VX1 $T=-56440 -304640 1 0 $X=-56870 $Y=-309760
X17493 2 1 1609 1627 2818 1649 1618 FA_5VX1 $T=-55320 -394240 1 0 $X=-55750 $Y=-399360
X17494 2 1 1610 788 2819 1650 1626 FA_5VX1 $T=-55320 -376320 1 0 $X=-55750 $Y=-381440
X17495 2 1 2803 2807 1655 1657 2800 FA_5VX1 $T=-54200 -295680 1 0 $X=-54630 $Y=-300800
X17496 2 1 1622 277 1660 1651 2812 FA_5VX1 $T=-51960 -340480 0 0 $X=-52390 $Y=-341120
X17497 2 1 3294 264 1662 2825 291 FA_5VX1 $T=-51400 -286720 1 0 $X=-51830 $Y=-291840
X17498 2 1 1652 1622 1635 268 1630 FA_5VX1 $T=-31800 -340480 0 180 $X=-49030 $Y=-345600
X17499 2 1 1651 304 3296 2837 1645 FA_5VX1 $T=-40760 -331520 1 0 $X=-41190 $Y=-336640
X17500 2 1 2818 2826 1667 304 1644 FA_5VX1 $T=-39640 -412160 0 0 $X=-40070 $Y=-412800
X17501 2 1 3295 290 1692 2833 1646 FA_5VX1 $T=-39640 -331520 0 0 $X=-40070 $Y=-332160
X17502 2 1 1640 285 1701 2836 1662 FA_5VX1 $T=-37960 -304640 0 0 $X=-38390 $Y=-305280
X17503 2 1 2825 277 2838 1686 1643 FA_5VX1 $T=-37400 -295680 0 0 $X=-37830 $Y=-296320
X17504 2 1 2822 2832 3297 274 307 FA_5VX1 $T=-37400 -277760 0 0 $X=-37830 $Y=-278400
X17505 2 1 1597 1698 1702 1696 1684 FA_5VX1 $T=-35720 -322560 1 0 $X=-36150 $Y=-327680
X17506 2 1 1639 290 1688 3298 297 FA_5VX1 $T=-31800 -340480 1 0 $X=-32230 $Y=-345600
X17507 2 1 1608 2839 2843 314 1633 FA_5VX1 $T=-31800 -277760 1 0 $X=-32230 $Y=-282880
X17508 2 1 2827 1691 1534 2844 1671 FA_5VX1 $T=-31240 -367360 1 0 $X=-31670 $Y=-372480
X17509 2 1 1675 2840 2841 795 1634 FA_5VX1 $T=-27880 -421120 1 0 $X=-28310 $Y=-426240
X17510 2 1 1725 285 1757 2834 1635 FA_5VX1 $T=-7720 -349440 0 180 $X=-24950 $Y=-354560
X17511 2 1 2834 795 1724 1729 1660 FA_5VX1 $T=-23400 -358400 0 0 $X=-23830 $Y=-359040
X17512 2 1 1699 1725 1728 274 1683 FA_5VX1 $T=-23400 -340480 0 0 $X=-23830 $Y=-341120
X17513 2 1 3259 2856 1747 2846 2849 FA_5VX1 $T=2920 -412160 0 180 $X=-14310 $Y=-417280
X17514 2 1 1723 2850 2862 274 1747 FA_5VX1 $T=-11080 -421120 0 0 $X=-11510 $Y=-421760
X17515 2 1 2846 1758 1765 2863 1726 FA_5VX1 $T=-10520 -367360 1 0 $X=-10950 $Y=-372480
X17516 2 1 1749 2849 1726 1727 2853 FA_5VX1 $T=6280 -358400 0 180 $X=-10950 $Y=-363520
X17517 2 1 3260 2866 1733 1723 2856 FA_5VX1 $T=8520 -421120 0 180 $X=-8710 $Y=-426240
X17518 2 1 1727 1769 1772 1763 1737 FA_5VX1 $T=-6600 -358400 0 0 $X=-7030 $Y=-359040
X17519 2 1 1766 2853 1737 2851 2860 FA_5VX1 $T=10200 -340480 0 180 $X=-7030 $Y=-345600
X17520 2 1 2851 324 1770 2870 1751 FA_5VX1 $T=-6600 -331520 1 0 $X=-7030 $Y=-336640
X17521 2 1 2873 304 1746 1691 1748 FA_5VX1 $T=11320 -394240 0 180 $X=-5910 $Y=-399360
X17522 2 1 2850 285 791 2873 2863 FA_5VX1 $T=-4920 -403200 0 0 $X=-5350 $Y=-403840
X17523 2 1 1765 290 795 1736 2861 FA_5VX1 $T=12440 -376320 1 180 $X=-4790 $Y=-376960
X17524 2 1 1758 268 1748 277 1763 FA_5VX1 $T=13000 -367360 1 180 $X=-4230 $Y=-368000
X17525 2 1 792 2860 1751 1750 1738 FA_5VX1 $T=13560 -331520 1 180 $X=-3670 $Y=-332160
X17526 2 1 2877 290 790 2857 2862 FA_5VX1 $T=14680 -403200 0 180 $X=-2550 $Y=-408320
X17527 2 1 1769 264 1759 2861 2870 FA_5VX1 $T=17480 -349440 0 180 $X=250 $Y=-354560
X17528 2 1 1790 2877 1762 277 1733 FA_5VX1 $T=19160 -412160 1 180 $X=1930 $Y=-412800
X17529 2 1 1770 2872 2885 277 1731 FA_5VX1 $T=5720 -340480 0 0 $X=5290 $Y=-341120
X17530 2 1 1759 304 1810 1799 2885 FA_5VX1 $T=10200 -358400 0 0 $X=9770 $Y=-359040
X17531 2 1 2872 290 1793 2888 1728 FA_5VX1 $T=10200 -340480 1 0 $X=9770 $Y=-345600
X17532 2 1 331 277 2887 1801 339 FA_5VX1 $T=10760 -286720 0 0 $X=10330 $Y=-287360
X17533 2 1 1786 1815 1809 1790 2866 FA_5VX1 $T=15800 -421120 1 0 $X=15370 $Y=-426240
X17534 2 1 2897 268 2882 2881 1796 FA_5VX1 $T=32600 -313600 0 180 $X=15370 $Y=-318720
X17535 2 1 1856 1807 2883 285 1809 FA_5VX1 $T=34840 -412160 0 180 $X=17610 $Y=-417280
X17536 2 1 2882 304 1840 2899 1818 FA_5VX1 $T=19160 -322560 0 0 $X=18730 $Y=-323200
X17537 2 1 1835 2890 1800 1796 1814 FA_5VX1 $T=36520 -304640 0 180 $X=19290 $Y=-309760
X17538 2 1 1802 342 1839 1827 346 FA_5VX1 $T=21400 -277760 0 0 $X=20970 $Y=-278400
X17539 2 1 1825 1806 2906 1837 2898 FA_5VX1 $T=23080 -295680 0 0 $X=22650 $Y=-296320
X17540 2 1 1806 258 1836 798 1827 FA_5VX1 $T=23080 -277760 1 0 $X=22650 $Y=-282880
X17541 2 1 2890 264 1813 1863 1837 FA_5VX1 $T=26440 -313600 0 0 $X=26010 $Y=-314240
X17542 2 1 3261 2904 1832 1856 1815 FA_5VX1 $T=27000 -421120 0 0 $X=26570 $Y=-421760
X17543 2 1 1833 290 1778 2889 1832 FA_5VX1 $T=43800 -412160 1 180 $X=26570 $Y=-412800
X17544 2 1 2892 2909 1848 304 1847 FA_5VX1 $T=28680 -376320 0 0 $X=28250 $Y=-376960
X17545 2 1 1836 285 1861 1877 354 FA_5VX1 $T=34840 -286720 0 0 $X=34410 $Y=-287360
X17546 2 1 1884 274 1849 1831 1850 FA_5VX1 $T=52760 -322560 1 180 $X=35530 $Y=-323200
X17547 2 1 2927 2897 1846 1850 1862 FA_5VX1 $T=54440 -313600 0 180 $X=37210 $Y=-318720
X17548 2 1 800 1857 1840 795 1849 FA_5VX1 $T=55000 -331520 0 180 $X=37770 $Y=-336640
X17549 2 1 1875 795 2923 2921 1873 FA_5VX1 $T=39320 -412160 1 0 $X=38890 $Y=-417280
X17550 2 1 1853 1691 801 1890 1878 FA_5VX1 $T=41560 -403200 1 0 $X=41130 $Y=-408320
X17551 2 1 2915 1896 1891 1894 2925 FA_5VX1 $T=46600 -376320 0 0 $X=46170 $Y=-376960
X17552 2 1 1897 1870 2905 1874 1888 FA_5VX1 $T=64520 -349440 1 180 $X=47290 $Y=-350080
X17553 2 1 1926 1884 1882 1865 2932 FA_5VX1 $T=70120 -322560 0 180 $X=52890 $Y=-327680
X17554 2 1 1935 258 1913 2941 1907 FA_5VX1 $T=53880 -304640 0 0 $X=53450 $Y=-305280
X17555 2 1 2924 304 2945 1924 2939 FA_5VX1 $T=55000 -421120 1 0 $X=54570 $Y=-426240
X17556 2 1 1906 1895 800 2926 2936 FA_5VX1 $T=71800 -331520 0 180 $X=54570 $Y=-336640
X17557 2 1 2928 2944 1921 1935 1915 FA_5VX1 $T=57240 -313600 1 0 $X=56810 $Y=-318720
X17558 2 1 2930 1915 1907 1911 1922 FA_5VX1 $T=58360 -295680 1 0 $X=57930 $Y=-300800
X17559 2 1 1899 277 3240 2947 2943 FA_5VX1 $T=58920 -385280 1 0 $X=58490 $Y=-390400
X17560 2 1 1902 264 802 1925 1921 FA_5VX1 $T=60600 -349440 1 0 $X=60170 $Y=-354560
X17561 2 1 1916 268 1940 1941 1909 FA_5VX1 $T=61160 -367360 0 0 $X=60730 $Y=-368000
X17562 2 1 2935 290 1910 1947 1905 FA_5VX1 $T=61720 -412160 0 0 $X=61290 $Y=-412800
X17563 2 1 1908 2948 1948 274 1920 FA_5VX1 $T=62840 -376320 1 0 $X=62410 $Y=-381440
X17564 2 1 2937 285 2953 1929 1932 FA_5VX1 $T=63960 -394240 1 0 $X=63530 $Y=-399360
X17565 2 1 1911 265 1944 2956 1919 FA_5VX1 $T=63960 -286720 0 0 $X=63530 $Y=-287360
X17566 2 1 2960 2946 801 804 1939 FA_5VX1 $T=83000 -322560 1 180 $X=65770 $Y=-323200
X17567 2 1 1918 1953 1550 1943 1951 FA_5VX1 $T=67320 -340480 1 0 $X=66890 $Y=-345600
X17568 2 1 1967 383 1931 1928 2954 FA_5VX1 $T=87480 -304640 1 180 $X=70250 $Y=-305280
X17569 2 1 1958 2955 1810 795 1931 FA_5VX1 $T=91400 -313600 0 180 $X=74170 $Y=-318720
X17570 2 1 2952 1951 2969 1959 2962 FA_5VX1 $T=76840 -331520 1 0 $X=76410 $Y=-336640
X17571 2 1 1954 395 1987 2973 398 FA_5VX1 $T=79640 -277760 0 0 $X=79210 $Y=-278400
X17572 2 1 2973 1955 304 285 397 FA_5VX1 $T=97000 -277760 0 180 $X=79770 $Y=-282880
X17573 2 1 2958 396 1977 2975 2966 FA_5VX1 $T=80760 -286720 1 0 $X=80330 $Y=-291840
X17574 2 1 2978 2964 1550 1810 1962 FA_5VX1 $T=98680 -340480 1 180 $X=81450 $Y=-341120
X17575 2 1 1928 1934 804 304 1977 FA_5VX1 $T=81880 -295680 1 0 $X=81450 $Y=-300800
X17576 2 1 2975 1949 795 290 1987 FA_5VX1 $T=98680 -295680 1 180 $X=81450 $Y=-296320
X17577 2 1 2974 1995 1550 801 2965 FA_5VX1 $T=99240 -358400 0 180 $X=82010 $Y=-363520
X17578 2 1 1991 394 1939 1958 1980 FA_5VX1 $T=99240 -313600 1 180 $X=82010 $Y=-314240
X17579 2 1 1986 400 1962 2960 1975 FA_5VX1 $T=100360 -322560 1 180 $X=83130 $Y=-323200
X17580 2 1 1961 401 2977 2978 2971 FA_5VX1 $T=85800 -331520 0 0 $X=85370 $Y=-332160
X17581 2 1 2008 2970 2965 285 1990 FA_5VX1 $T=105400 -349440 1 180 $X=88170 $Y=-350080
X17582 2 1 2992 2984 1965 1988 2000 FA_5VX1 $T=111000 -340480 0 180 $X=93770 $Y=-345600
X17583 2 1 415 405 1996 404 408 FA_5VX1 $T=113240 -277760 1 180 $X=96010 $Y=-278400
X17584 2 1 2996 290 1989 2974 2009 FA_5VX1 $T=114360 -367360 1 180 $X=97130 $Y=-368000
X17585 2 1 3299 285 795 290 1996 FA_5VX1 $T=114360 -286720 0 180 $X=97130 $Y=-291840
X17586 2 1 2038 2992 1984 277 2015 FA_5VX1 $T=118280 -340480 1 180 $X=101050 $Y=-341120
X17587 2 1 2034 2987 795 304 2039 FA_5VX1 $T=118840 -412160 1 180 $X=101610 $Y=-412800
X17588 2 1 2037 2013 1978 2004 2016 FA_5VX1 $T=118840 -313600 0 180 $X=101610 $Y=-318720
X17589 2 1 2998 2985 2983 2979 2019 FA_5VX1 $T=119400 -331520 1 180 $X=102170 $Y=-332160
X17590 2 1 2048 285 1992 2986 2022 FA_5VX1 $T=122760 -376320 0 180 $X=105530 $Y=-381440
X17591 2 1 3001 285 1985 795 2994 FA_5VX1 $T=123320 -385280 0 180 $X=106090 $Y=-390400
X17592 2 1 3002 277 1999 2014 2995 FA_5VX1 $T=123880 -367360 0 180 $X=106650 $Y=-372480
X17593 2 1 2060 3001 2017 277 2030 FA_5VX1 $T=126120 -385280 1 180 $X=108890 $Y=-385920
X17594 2 1 2045 2044 2000 274 2031 FA_5VX1 $T=126120 -331520 0 180 $X=108890 $Y=-336640
X17595 2 1 2070 3002 2994 274 2036 FA_5VX1 $T=128920 -376320 1 180 $X=111690 $Y=-376960
X17596 2 1 2046 2998 2040 268 424 FA_5VX1 $T=128920 -322560 1 180 $X=111690 $Y=-323200
X17597 2 1 2044 2027 2021 2018 2040 FA_5VX1 $T=131160 -358400 1 180 $X=113930 $Y=-359040
X17598 2 1 810 3242 2996 2995 2043 FA_5VX1 $T=131720 -367360 1 180 $X=114490 $Y=-368000
X17599 2 1 2042 2002 2029 3299 425 FA_5VX1 $T=133960 -286720 0 180 $X=116730 $Y=-291840
X17600 2 1 2049 2037 2019 264 426 FA_5VX1 $T=134520 -304640 0 180 $X=117290 $Y=-309760
X17601 2 1 2063 2988 2001 290 2059 FA_5VX1 $T=136200 -403200 1 180 $X=118970 $Y=-403840
X17602 2 1 2071 3000 2038 2011 2064 FA_5VX1 $T=136200 -340480 1 180 $X=118970 $Y=-341120
X17603 2 1 811 3004 2045 2012 2061 FA_5VX1 $T=137320 -313600 0 180 $X=120090 $Y=-318720
X17604 2 1 3009 3006 2046 3300 2087 FA_5VX1 $T=137320 -295680 0 180 $X=120090 $Y=-300800
X17605 2 1 438 258 2016 2042 428 FA_5VX1 $T=137320 -295680 1 180 $X=120090 $Y=-296320
X17606 2 1 2078 3010 2049 2999 809 FA_5VX1 $T=137320 -286720 1 180 $X=120090 $Y=-287360
X17607 2 1 2072 3007 2008 2041 2073 FA_5VX1 $T=138440 -349440 1 180 $X=121210 $Y=-350080
X17608 2 1 2150 3032 2108 2067 2131 FA_5VX1 $T=180440 -295680 1 180 $X=163210 $Y=-296320
X17609 2 1 2202 2131 2143 2141 472 FA_5VX1 $T=191640 -277760 0 180 $X=174410 $Y=-282880
X17610 2 1 3301 3038 2155 2152 3036 FA_5VX1 $T=196680 -322560 1 180 $X=179450 $Y=-323200
X17611 2 1 2181 3036 2157 2314 3032 FA_5VX1 $T=197240 -295680 1 180 $X=180010 $Y=-296320
X17612 2 1 2212 3059 3062 557 2223 FA_5VX1 $T=215160 -322560 0 0 $X=214730 $Y=-323200
X17613 2 1 2227 3060 2251 2254 2233 FA_5VX1 $T=216280 -295680 1 0 $X=215850 $Y=-300800
X17614 2 1 3057 2232 3244 549 2226 FA_5VX1 $T=218520 -331520 0 0 $X=218090 $Y=-332160
X17615 2 1 2232 511 2260 517 3062 FA_5VX1 $T=219080 -322560 1 0 $X=218650 $Y=-327680
X17616 2 1 2216 2252 3064 2250 2217 FA_5VX1 $T=219080 -313600 0 0 $X=218650 $Y=-314240
X17617 2 1 2218 3061 2241 565 2228 FA_5VX1 $T=219640 -286720 0 0 $X=219210 $Y=-287360
X17618 2 1 3059 549 510 3066 2250 FA_5VX1 $T=221880 -313600 1 0 $X=221450 $Y=-318720
X17619 2 1 2234 550 3065 572 531 FA_5VX1 $T=221880 -277760 0 0 $X=221450 $Y=-278400
X17620 2 1 2238 2246 2263 511 2235 FA_5VX1 $T=223000 -331520 1 0 $X=222570 $Y=-336640
X17621 2 1 2241 3063 2265 549 567 FA_5VX1 $T=226920 -286720 1 0 $X=226490 $Y=-291840
X17622 2 1 3074 524 2259 2257 2258 FA_5VX1 $T=249320 -340480 1 180 $X=232090 $Y=-341120
X17623 2 1 3063 2242 2277 2268 2270 FA_5VX1 $T=233640 -295680 1 0 $X=233210 $Y=-300800
X17624 2 1 3064 524 2278 3263 564 FA_5VX1 $T=234200 -304640 0 0 $X=233770 $Y=-305280
X17625 2 1 2251 511 2280 2283 568 FA_5VX1 $T=235320 -295680 0 0 $X=234890 $Y=-296320
X17626 2 1 2262 2275 2279 3074 2249 FA_5VX1 $T=235880 -340480 1 0 $X=235450 $Y=-345600
X17627 2 1 3065 3071 2270 557 584 FA_5VX1 $T=237000 -286720 0 0 $X=236570 $Y=-287360
X17628 2 1 3071 3075 2298 2292 2287 FA_5VX1 $T=243720 -286720 1 0 $X=243290 $Y=-291840
X17629 2 1 585 3076 2287 555 593 FA_5VX1 $T=245960 -277760 0 0 $X=245530 $Y=-278400
X17630 2 1 2282 2289 2301 2302 2294 FA_5VX1 $T=247640 -349440 1 0 $X=247210 $Y=-354560
X17631 2 1 2303 2291 2285 2274 2289 FA_5VX1 $T=266680 -340480 1 180 $X=249450 $Y=-341120
X17632 2 1 2296 3077 816 2299 2291 FA_5VX1 $T=267240 -331520 0 180 $X=250010 $Y=-336640
X17633 2 1 3076 2308 3084 3085 603 FA_5VX1 $T=256040 -286720 0 0 $X=255610 $Y=-287360
X17634 2 1 2283 2310 525 3082 2265 FA_5VX1 $T=257160 -295680 0 0 $X=256730 $Y=-296320
X17635 2 1 3086 2324 2219 3262 623 FA_5VX1 $T=272840 -286720 0 0 $X=272410 $Y=-287360
X17636 2 1 622 3093 2219 525 634 FA_5VX1 $T=282360 -277760 0 0 $X=281930 $Y=-278400
X17637 2 1 2332 517 2325 3096 2330 FA_5VX1 $T=305320 -295680 0 180 $X=288090 $Y=-300800
X17638 2 1 2336 510 2333 2331 3102 FA_5VX1 $T=311480 -286720 1 180 $X=294250 $Y=-287360
X17639 2 1 2344 511 3099 2332 642 FA_5VX1 $T=312040 -295680 1 180 $X=294810 $Y=-296320
X17640 2 1 653 549 2330 2336 648 FA_5VX1 $T=313720 -277760 0 180 $X=296490 $Y=-282880
X17641 2 1 657 650 3102 557 651 FA_5VX1 $T=317640 -277760 1 180 $X=300410 $Y=-278400
X17642 2 1 2350 524 3104 3302 3108 FA_5VX1 $T=323800 -304640 1 180 $X=306570 $Y=-305280
X17643 2 1 2355 510 2338 2342 2348 FA_5VX1 $T=325480 -340480 0 180 $X=308250 $Y=-345600
X17644 2 1 666 2344 3108 557 660 FA_5VX1 $T=329400 -286720 0 180 $X=312170 $Y=-291840
X17645 2 1 3126 543 2350 2354 661 FA_5VX1 $T=331640 -277760 0 180 $X=314410 $Y=-282880
X17646 2 1 3121 557 3110 511 2354 FA_5VX1 $T=333320 -295680 0 180 $X=316090 $Y=-300800
X17647 2 1 819 524 517 2353 3115 FA_5VX1 $T=336680 -304640 0 180 $X=319450 $Y=-309760
X17648 2 1 2368 544 2356 3115 3119 FA_5VX1 $T=340600 -304640 1 180 $X=323370 $Y=-305280
X17649 2 1 2357 3127 2210 517 2373 FA_5VX1 $T=326040 -340480 1 0 $X=325610 $Y=-345600
X17650 2 1 2367 2357 2345 524 3124 FA_5VX1 $T=343400 -340480 1 180 $X=326170 $Y=-341120
X17651 2 1 3303 524 2341 3120 2362 FA_5VX1 $T=346760 -322560 1 180 $X=329530 $Y=-323200
X17652 2 1 3118 510 2359 516 2369 FA_5VX1 $T=329960 -313600 0 0 $X=329530 $Y=-314240
X17653 2 1 2375 2368 3121 2360 2364 FA_5VX1 $T=347880 -295680 1 180 $X=330650 $Y=-296320
X17654 2 1 2376 511 3123 3118 2366 FA_5VX1 $T=348440 -313600 0 180 $X=331210 $Y=-318720
X17655 2 1 3132 3126 3122 3119 672 FA_5VX1 $T=348440 -277760 0 180 $X=331210 $Y=-282880
X17656 2 1 3137 3128 819 2366 3130 FA_5VX1 $T=354040 -304640 0 180 $X=336810 $Y=-309760
X17657 2 1 3129 525 2385 2219 2378 FA_5VX1 $T=342280 -358400 1 0 $X=341850 $Y=-363520
X17658 2 1 2389 2384 3130 2375 3133 FA_5VX1 $T=359080 -295680 0 180 $X=341850 $Y=-300800
X17659 2 1 2370 510 2340 3304 2379 FA_5VX1 $T=343400 -331520 0 0 $X=342970 $Y=-332160
X17660 2 1 2377 2372 3124 2371 3135 FA_5VX1 $T=361880 -340480 1 180 $X=344650 $Y=-341120
X17661 2 1 2371 2370 2373 511 2374 FA_5VX1 $T=362440 -331520 0 180 $X=345210 $Y=-336640
X17662 2 1 2390 3135 2374 3131 2380 FA_5VX1 $T=362440 -322560 0 180 $X=345210 $Y=-327680
X17663 2 1 3143 3133 2364 3132 679 FA_5VX1 $T=363560 -286720 0 180 $X=346330 $Y=-291840
X17664 2 1 3131 3303 2379 549 3139 FA_5VX1 $T=348440 -322560 0 0 $X=348010 $Y=-323200
X17665 2 1 2386 2376 2362 557 2383 FA_5VX1 $T=368040 -313600 1 180 $X=350810 $Y=-314240
X17666 2 1 3150 3144 2383 3137 2384 FA_5VX1 $T=369720 -304640 1 180 $X=352490 $Y=-305280
X17667 2 1 2305 680 2391 686 681 FA_5VX1 $T=352920 -277760 0 0 $X=352490 $Y=-278400
X17668 2 1 2387 3141 2400 516 3145 FA_5VX1 $T=356280 -340480 1 0 $X=355850 $Y=-345600
X17669 2 1 2393 2380 3139 2386 3144 FA_5VX1 $T=373640 -313600 0 180 $X=356410 $Y=-318720
X17670 2 1 2392 510 3156 3157 2403 FA_5VX1 $T=362440 -340480 0 0 $X=362010 $Y=-341120
X17671 2 1 2409 3148 2394 557 2413 FA_5VX1 $T=380360 -286720 1 180 $X=363130 $Y=-287360
X17672 2 1 3147 3158 3164 517 2407 FA_5VX1 $T=369720 -349440 0 0 $X=369290 $Y=-350080
X17673 2 1 3151 524 3160 2415 2404 FA_5VX1 $T=369720 -322560 1 0 $X=369290 $Y=-327680
X17674 2 1 3149 511 3161 2411 2402 FA_5VX1 $T=369720 -313600 0 0 $X=369290 $Y=-314240
X17675 2 1 3152 549 3162 3163 2412 FA_5VX1 $T=369720 -304640 0 0 $X=369290 $Y=-305280
X17676 2 1 2416 3174 2427 2423 2422 FA_5VX1 $T=401640 -322560 1 0 $X=401210 $Y=-327680
X17677 2 1 3166 3172 2425 2417 703 FA_5VX1 $T=401640 -286720 0 0 $X=401210 $Y=-287360
X17678 2 1 3165 3173 2428 2418 3172 FA_5VX1 $T=402200 -304640 0 0 $X=401770 $Y=-305280
X17679 2 1 2417 3170 3176 706 704 FA_5VX1 $T=402200 -277760 0 0 $X=401770 $Y=-278400
X17680 2 1 2437 3178 3168 699 2421 FA_5VX1 $T=419560 -322560 1 180 $X=402330 $Y=-323200
X17681 2 1 3167 2426 2421 2424 3173 FA_5VX1 $T=402760 -313600 1 0 $X=402330 $Y=-318720
X17682 2 1 2418 702 2422 3177 2425 FA_5VX1 $T=402760 -295680 0 0 $X=402330 $Y=-296320
X17683 2 1 3168 549 2431 524 3174 FA_5VX1 $T=404440 -331520 1 0 $X=404010 $Y=-336640
X17684 2 1 3170 543 3179 2436 705 FA_5VX1 $T=408360 -277760 1 0 $X=407930 $Y=-282880
X17685 2 1 2423 511 3181 2450 2435 FA_5VX1 $T=413400 -331520 0 0 $X=412970 $Y=-332160
X17686 2 1 2424 2416 3182 2433 2428 FA_5VX1 $T=413400 -313600 0 0 $X=412970 $Y=-314240
X17687 2 1 3175 2429 2438 2437 2426 FA_5VX1 $T=413960 -304640 1 0 $X=413530 $Y=-309760
X17688 2 1 3177 555 3184 2435 2436 FA_5VX1 $T=417320 -295680 1 0 $X=416890 $Y=-300800
X17689 2 1 2430 2440 2445 517 2427 FA_5VX1 $T=418440 -322560 1 0 $X=418010 $Y=-327680
X17690 2 1 2432 3180 3183 555 707 FA_5VX1 $T=418440 -286720 0 0 $X=418010 $Y=-287360
X17691 2 1 3178 557 2430 3186 3182 FA_5VX1 $T=420120 -313600 1 0 $X=419690 $Y=-318720
X17692 2 1 3176 544 2444 2446 708 FA_5VX1 $T=420120 -277760 0 0 $X=419690 $Y=-278400
X17693 2 1 3179 557 2462 715 711 FA_5VX1 $T=425720 -277760 1 0 $X=425290 $Y=-282880
X17694 2 1 3190 2439 2467 510 3186 FA_5VX1 $T=447000 -313600 1 180 $X=429770 $Y=-314240
X17695 2 1 2441 710 3190 718 2438 FA_5VX1 $T=431320 -304640 0 0 $X=430890 $Y=-305280
X17696 2 1 712 549 3191 3305 2446 FA_5VX1 $T=435240 -286720 0 0 $X=434810 $Y=-287360
X17697 2 1 2455 2444 717 3189 2451 FA_5VX1 $T=462680 -286720 0 180 $X=445450 $Y=-291840
X17698 2 1 2464 709 2450 3188 2459 FA_5VX1 $T=463800 -313600 1 180 $X=446570 $Y=-314240
X17699 2 1 2457 3195 3191 2454 2458 FA_5VX1 $T=464920 -304640 1 180 $X=447690 $Y=-305280
X17700 2 1 2466 2440 2456 517 2461 FA_5VX1 $T=469960 -322560 1 180 $X=452730 $Y=-323200
X17701 2 1 2479 3250 3203 510 2473 FA_5VX1 $T=491240 -295680 0 180 $X=474010 $Y=-300800
X17702 2 1 746 2482 737 517 742 FA_5VX1 $T=510840 -277760 1 180 $X=493610 $Y=-278400
X17703 2 1 3211 2485 2488 524 3213 FA_5VX1 $T=494600 -304640 0 0 $X=494170 $Y=-305280
X17704 2 1 745 517 2400 2481 743 FA_5VX1 $T=511400 -277760 0 180 $X=494170 $Y=-282880
X17705 2 1 2485 2486 2484 517 2483 FA_5VX1 $T=514200 -295680 1 180 $X=496970 $Y=-296320
X17706 2 1 2491 2487 3212 2483 2490 FA_5VX1 $T=514200 -286720 0 180 $X=496970 $Y=-291840
X17707 2 1 24 831 841 834 CAG_5VX1 $T=-418200 -286720 0 0 $X=-418630 $Y=-287365
X17708 2 1 2499 836 2503 2502 CAG_5VX1 $T=-403640 -340480 1 0 $X=-404070 $Y=-345600
X17709 2 1 38 854 849 844 CAG_5VX1 $T=-395240 -277760 0 180 $X=-402390 $Y=-282880
X17710 2 1 2502 2504 858 843 CAG_5VX1 $T=-398600 -358400 0 0 $X=-399030 $Y=-359045
X17711 2 1 864 2506 859 850 CAG_5VX1 $T=-389640 -331520 0 180 $X=-396790 $Y=-336640
X17712 2 1 854 860 2505 862 CAG_5VX1 $T=-389080 -304640 1 180 $X=-396230 $Y=-305285
X17713 2 1 2506 2509 2512 853 CAG_5VX1 $T=-393560 -340480 1 0 $X=-393990 $Y=-345600
X17714 2 1 860 864 2510 866 CAG_5VX1 $T=-393000 -322560 0 0 $X=-393430 $Y=-323205
X17715 2 1 2504 2511 869 867 CAG_5VX1 $T=-391320 -367360 1 0 $X=-391750 $Y=-372480
X17716 2 1 2509 865 852 36 CAG_5VX1 $T=-391320 -358400 0 0 $X=-391750 $Y=-359045
X17717 2 1 2511 863 879 2519 CAG_5VX1 $T=-383480 -376320 1 0 $X=-383910 $Y=-381440
X17718 2 1 865 889 47 2526 CAG_5VX1 $T=-373400 -358400 1 0 $X=-373830 $Y=-363520
X17719 2 1 2519 49 875 896 CAG_5VX1 $T=-369480 -376320 1 0 $X=-369910 $Y=-381440
X17720 2 1 2526 876 49 897 CAG_5VX1 $T=-368920 -367360 1 0 $X=-369350 $Y=-372480
X17721 2 1 896 51 909 937 CAG_5VX1 $T=-347640 -394240 1 0 $X=-348070 $Y=-399360
X17722 2 1 2538 911 761 55 CAG_5VX1 $T=-340920 -385280 0 180 $X=-348070 $Y=-390400
X17723 2 1 897 51 912 2538 CAG_5VX1 $T=-347640 -376320 1 0 $X=-348070 $Y=-381440
X17724 2 1 2560 929 2543 928 CAG_5VX1 $T=-333640 -295680 1 180 $X=-340790 $Y=-296325
X17725 2 1 911 925 906 894 CAG_5VX1 $T=-339800 -385280 1 0 $X=-340230 $Y=-390400
X17726 2 1 937 939 943 55 CAG_5VX1 $T=-333080 -394240 1 0 $X=-333510 $Y=-399360
X17727 2 1 925 2552 945 2558 CAG_5VX1 $T=-332520 -385280 1 0 $X=-332950 $Y=-390400
X17728 2 1 928 2557 948 2562 CAG_5VX1 $T=-331400 -295680 1 0 $X=-331830 $Y=-300800
X17729 2 1 75 2560 949 76 CAG_5VX1 $T=-331400 -277760 0 0 $X=-331830 $Y=-278405
X17730 2 1 2558 960 910 2567 CAG_5VX1 $T=-324120 -385280 0 0 $X=-324550 $Y=-385925
X17731 2 1 981 978 963 2565 CAG_5VX1 $T=-316840 -304640 0 180 $X=-323990 $Y=-309760
X17732 2 1 978 975 962 964 CAG_5VX1 $T=-312920 -331520 1 180 $X=-320070 $Y=-332165
X17733 2 1 967 981 976 958 CAG_5VX1 $T=-319640 -286720 1 0 $X=-320070 $Y=-291840
X17734 2 1 964 974 984 1002 CAG_5VX1 $T=-317400 -331520 1 0 $X=-317830 $Y=-336640
X17735 2 1 990 3222 991 973 CAG_5VX1 $T=-307320 -358400 1 180 $X=-314470 $Y=-359045
X17736 2 1 996 985 988 990 CAG_5VX1 $T=-306760 -349440 0 180 $X=-313910 $Y=-354560
X17737 2 1 91 982 992 967 CAG_5VX1 $T=-313480 -277760 1 0 $X=-313910 $Y=-282880
X17738 2 1 939 993 1000 894 CAG_5VX1 $T=-310680 -394240 1 0 $X=-311110 $Y=-399360
X17739 2 1 1007 996 2578 894 CAG_5VX1 $T=-300040 -349440 0 180 $X=-307190 $Y=-354560
X17740 2 1 2589 1006 991 2583 CAG_5VX1 $T=-296680 -349440 1 180 $X=-303830 $Y=-350085
X17741 2 1 993 2582 1010 2584 CAG_5VX1 $T=-302840 -394240 1 0 $X=-303270 $Y=-399360
X17742 2 1 2594 2593 51 1024 CAG_5VX1 $T=-289400 -331520 0 180 $X=-296550 $Y=-336640
X17743 2 1 2582 2590 921 1025 CAG_5VX1 $T=-295560 -403200 0 0 $X=-295990 $Y=-403845
X17744 2 1 2593 1007 1011 55 CAG_5VX1 $T=-288840 -349440 1 180 $X=-295990 $Y=-350085
X17745 2 1 1036 2594 2591 2592 CAG_5VX1 $T=-288840 -322560 1 180 $X=-295990 $Y=-323205
X17746 2 1 2596 1020 767 1029 CAG_5VX1 $T=-288280 -376320 1 180 $X=-295430 $Y=-376965
X17747 2 1 1029 765 767 922 CAG_5VX1 $T=-287160 -385280 0 0 $X=-287590 $Y=-385925
X17748 2 1 2599 1029 921 1039 CAG_5VX1 $T=-287160 -376320 1 0 $X=-287590 $Y=-381440
X17749 2 1 1048 1036 1023 1046 CAG_5VX1 $T=-286040 -304640 1 0 $X=-286470 $Y=-309760
X17750 2 1 2618 51 1053 1077 CAG_5VX1 $T=-269800 -394240 1 180 $X=-276950 $Y=-394885
X17751 2 1 1077 1081 2612 55 CAG_5VX1 $T=-269240 -403200 1 180 $X=-276390 $Y=-403845
X17752 2 1 1099 133 1108 1105 CAG_5VX1 $T=-266440 -277760 1 0 $X=-266870 $Y=-282880
X17753 2 1 1081 2631 1123 894 CAG_5VX1 $T=-260840 -403200 0 0 $X=-261270 $Y=-403845
X17754 2 1 1119 1126 2635 1117 CAG_5VX1 $T=-257480 -349440 0 0 $X=-257910 $Y=-350085
X17755 2 1 1114 2641 1124 33 CAG_5VX1 $T=-247400 -340480 1 180 $X=-254550 $Y=-341125
X17756 2 1 1133 1127 1114 1119 CAG_5VX1 $T=-254120 -322560 1 0 $X=-254550 $Y=-327680
X17757 2 1 772 1151 1143 25 CAG_5VX1 $T=-245720 -331520 0 180 $X=-252870 $Y=-336640
X17758 2 1 1156 1133 1141 1148 CAG_5VX1 $T=-245720 -322560 1 180 $X=-252870 $Y=-323205
X17759 2 1 1090 956 1162 1135 CAG_5VX1 $T=-251320 -403200 0 0 $X=-251750 $Y=-403845
X17760 2 1 1161 956 1167 1160 CAG_5VX1 $T=-239560 -385280 0 180 $X=-246710 $Y=-390400
X17761 2 1 1185 2650 772 1156 CAG_5VX1 $T=-233400 -313600 0 180 $X=-240550 $Y=-318720
X17762 2 1 1190 1177 1171 33 CAG_5VX1 $T=-232840 -331520 0 180 $X=-239990 $Y=-336640
X17763 2 1 3255 2651 921 1168 CAG_5VX1 $T=-231720 -412160 0 180 $X=-238870 $Y=-417280
X17764 2 1 1201 1199 1206 2656 CAG_5VX1 $T=-226680 -358400 0 180 $X=-233830 $Y=-363520
X17765 2 1 1202 1201 1187 2659 CAG_5VX1 $T=-225560 -313600 0 180 $X=-232710 $Y=-318720
X17766 2 1 173 1188 1163 1202 CAG_5VX1 $T=-225560 -304640 1 180 $X=-232710 $Y=-305285
X17767 2 1 1199 1212 1240 1219 CAG_5VX1 $T=-224440 -376320 1 0 $X=-224870 $Y=-381440
X17768 2 1 1219 1231 1233 2663 CAG_5VX1 $T=-213800 -385280 0 180 $X=-220950 $Y=-390400
X17769 2 1 1293 1214 1190 32 CAG_5VX1 $T=-213800 -313600 0 180 $X=-220950 $Y=-318720
X17770 2 1 184 33 1251 25 CAG_5VX1 $T=-207640 -277760 0 180 $X=-214790 $Y=-282880
X17771 2 1 1265 1244 1237 25 CAG_5VX1 $T=-205960 -331520 0 180 $X=-213110 $Y=-336640
X17772 2 1 1250 47 1258 33 CAG_5VX1 $T=-212120 -322560 1 0 $X=-212550 $Y=-327680
X17773 2 1 1276 2668 1250 32 CAG_5VX1 $T=-204840 -304640 1 180 $X=-211990 $Y=-305285
X17774 2 1 2666 922 921 1253 CAG_5VX1 $T=-210440 -394240 1 0 $X=-210870 $Y=-399360
X17775 2 1 1262 1213 1184 31 CAG_5VX1 $T=-203720 -340480 0 180 $X=-210870 $Y=-345600
X17776 2 1 185 1259 1277 23 CAG_5VX1 $T=-206520 -277760 1 0 $X=-206950 $Y=-282880
X17777 2 1 2675 922 765 1304 CAG_5VX1 $T=-198120 -385280 1 180 $X=-205270 $Y=-385925
X17778 2 1 1286 1272 1262 23 CAG_5VX1 $T=-198120 -322560 0 180 $X=-205270 $Y=-327680
X17779 2 1 1280 765 1288 2674 CAG_5VX1 $T=-202040 -403200 0 0 $X=-202470 $Y=-403845
X17780 2 1 1296 190 1265 1282 CAG_5VX1 $T=-194200 -304640 1 180 $X=-201350 $Y=-305285
X17781 2 1 188 182 1276 1295 CAG_5VX1 $T=-199240 -277760 1 0 $X=-199670 $Y=-282880
X17782 2 1 1305 1299 1293 1185 CAG_5VX1 $T=-190840 -313600 1 180 $X=-197990 $Y=-314245
X17783 2 1 1300 1302 1286 1305 CAG_5VX1 $T=-193640 -304640 1 0 $X=-194070 $Y=-309760
X17784 2 1 192 1308 1296 1300 CAG_5VX1 $T=-191960 -277760 1 0 $X=-192390 $Y=-282880
X17785 2 1 1329 2690 1316 1338 CAG_5VX1 $T=-178520 -403200 1 180 $X=-185670 $Y=-403845
X17786 2 1 193 1323 1322 1325 CAG_5VX1 $T=-184120 -304640 1 0 $X=-184550 $Y=-309760
X17787 2 1 2696 922 1353 1317 CAG_5VX1 $T=-172360 -403200 0 0 $X=-172790 $Y=-403845
X17788 2 1 1325 1358 1351 1343 CAG_5VX1 $T=-170120 -313600 1 0 $X=-170550 $Y=-318720
X17789 2 1 1379 2708 1367 55 CAG_5VX1 $T=-158920 -403200 1 180 $X=-166070 $Y=-403845
X17790 2 1 1355 1374 1354 2711 CAG_5VX1 $T=-163960 -340480 0 0 $X=-164390 $Y=-341125
X17791 2 1 1343 1372 1337 1347 CAG_5VX1 $T=-163400 -322560 1 0 $X=-163830 $Y=-327680
X17792 2 1 2711 1385 1365 1380 CAG_5VX1 $T=-160040 -349440 0 0 $X=-160470 $Y=-350085
X17793 2 1 1407 1388 51 1379 CAG_5VX1 $T=-149960 -394240 1 180 $X=-157110 $Y=-394885
X17794 2 1 1393 1370 1361 1407 CAG_5VX1 $T=-149960 -385280 1 180 $X=-157110 $Y=-385925
X17795 2 1 1396 1399 1371 1393 CAG_5VX1 $T=-149400 -376320 1 180 $X=-156550 $Y=-376965
X17796 2 1 1385 2717 36 1396 CAG_5VX1 $T=-155560 -358400 1 0 $X=-155990 $Y=-363520
X17797 2 1 234 1436 1428 1416 CAG_5VX1 $T=-133160 -277760 1 180 $X=-140310 $Y=-278405
X17798 2 1 1436 1445 2749 1451 CAG_5VX1 $T=-137080 -304640 0 0 $X=-137510 $Y=-305285
X17799 2 1 1522 1521 1531 1527 CAG_5VX1 $T=-87240 -304640 1 0 $X=-87670 $Y=-309760
X17800 2 1 252 1511 1547 1522 CAG_5VX1 $T=-80520 -286720 1 180 $X=-87670 $Y=-287365
X17801 2 1 784 1538 1546 1567 CAG_5VX1 $T=-74920 -376320 1 180 $X=-82070 $Y=-376965
X17802 2 1 3256 1560 1566 1551 CAG_5VX1 $T=-77720 -286720 0 0 $X=-78150 $Y=-287365
X17803 2 1 2785 2788 1568 1565 CAG_5VX1 $T=-76600 -313600 0 0 $X=-77030 $Y=-314245
X17804 2 1 1561 1536 2789 784 CAG_5VX1 $T=-76040 -349440 0 0 $X=-76470 $Y=-350085
X17805 2 1 1527 1524 1553 1561 CAG_5VX1 $T=-76040 -340480 0 0 $X=-76470 $Y=-341125
X17806 2 1 1603 1609 1626 1620 CAG_5VX1 $T=-54760 -385280 1 0 $X=-55190 $Y=-390400
X17807 2 1 2820 2814 1653 2813 CAG_5VX1 $T=-39640 -412160 0 180 $X=-46790 $Y=-417280
X17808 2 1 1620 1610 1647 2820 CAG_5VX1 $T=-45240 -385280 1 0 $X=-45670 $Y=-390400
X17809 2 1 2806 2815 1652 2816 CAG_5VX1 $T=-44120 -322560 1 0 $X=-44550 $Y=-327680
X17810 2 1 288 284 295 2817 CAG_5VX1 $T=-44120 -277760 1 0 $X=-44550 $Y=-282880
X17811 2 1 1616 1663 1654 285 CAG_5VX1 $T=-43560 -403200 1 0 $X=-43990 $Y=-408320
X17812 2 1 2813 2821 1634 2824 CAG_5VX1 $T=-40760 -421120 0 0 $X=-41190 $Y=-421765
X17813 2 1 301 1642 1648 1666 CAG_5VX1 $T=-38520 -313600 0 0 $X=-38950 $Y=-314245
X17814 2 1 1653 1663 1654 1656 CAG_5VX1 $T=-37960 -412160 1 0 $X=-38390 $Y=-417280
X17815 2 1 3217 1664 2827 277 CAG_5VX1 $T=-37400 -367360 0 0 $X=-37830 $Y=-368005
X17816 2 1 1647 1664 2827 1615 CAG_5VX1 $T=-36280 -385280 1 0 $X=-36710 $Y=-390400
X17817 2 1 2829 1673 1667 2826 CAG_5VX1 $T=-29000 -403200 0 180 $X=-36150 $Y=-408320
X17818 2 1 2824 1675 1679 2829 CAG_5VX1 $T=-32920 -421120 0 0 $X=-33350 $Y=-421765
X17819 2 1 1659 1668 1682 1685 CAG_5VX1 $T=-32360 -358400 0 0 $X=-32790 $Y=-359045
X17820 2 1 1661 308 2831 289 CAG_5VX1 $T=-29560 -313600 0 0 $X=-29990 $Y=-314245
X17821 2 1 1663 801 1697 1691 CAG_5VX1 $T=-27880 -403200 0 0 $X=-28310 $Y=-403845
X17822 2 1 292 1695 1687 1681 CAG_5VX1 $T=-18360 -286720 1 180 $X=-25510 $Y=-287365
X17823 2 1 1673 2842 2841 1670 CAG_5VX1 $T=-17240 -403200 1 0 $X=-17670 $Y=-408320
X17824 2 1 320 1719 1722 1716 CAG_5VX1 $T=-6600 -295680 1 180 $X=-13750 $Y=-296325
X17825 2 1 2855 1539 1756 1753 CAG_5VX1 $T=-3800 -304640 1 0 $X=-4230 $Y=-309760
X17826 2 1 1764 2855 1745 1754 CAG_5VX1 $T=-3800 -295680 0 0 $X=-4230 $Y=-296325
X17827 2 1 326 1764 1771 1767 CAG_5VX1 $T=1800 -277760 1 0 $X=1370 $Y=-282880
X17828 2 1 1762 2875 1724 304 CAG_5VX1 $T=9080 -394240 0 0 $X=8650 $Y=-394885
X17829 2 1 1803 1794 1724 304 CAG_5VX1 $T=23080 -394240 1 180 $X=15930 $Y=-394885
X17830 2 1 3306 1746 1580 2879 CAG_5VX1 $T=23640 -376320 0 180 $X=16490 $Y=-381440
X17831 2 1 343 1804 1785 2886 CAG_5VX1 $T=28680 -322560 0 180 $X=21530 $Y=-327680
X17832 2 1 1834 2892 1817 1829 CAG_5VX1 $T=33720 -367360 1 180 $X=26570 $Y=-368005
X17833 2 1 1829 1824 2893 1821 CAG_5VX1 $T=33720 -349440 0 180 $X=26570 $Y=-354560
X17834 2 1 344 1802 2898 1819 CAG_5VX1 $T=28120 -286720 0 0 $X=27690 $Y=-287365
X17835 2 1 1819 1825 1814 1826 CAG_5VX1 $T=29240 -295680 1 0 $X=28810 $Y=-300800
X17836 2 1 1824 1857 1840 2912 CAG_5VX1 $T=41000 -358400 0 0 $X=40570 $Y=-359045
X17837 2 1 1876 2915 1847 1834 CAG_5VX1 $T=48840 -367360 0 180 $X=41690 $Y=-372480
X17838 2 1 3238 1859 1858 1853 CAG_5VX1 $T=49400 -403200 1 180 $X=42250 $Y=-403845
X17839 2 1 1826 1835 1862 1869 CAG_5VX1 $T=43240 -313600 0 0 $X=42810 $Y=-314245
X17840 2 1 1859 2914 1580 2917 CAG_5VX1 $T=44360 -394240 1 0 $X=43930 $Y=-399360
X17841 2 1 1883 1875 1878 3238 CAG_5VX1 $T=52200 -412160 1 180 $X=45050 $Y=-412805
X17842 2 1 1894 1879 1534 1691 CAG_5VX1 $T=58920 -385280 1 180 $X=51770 $Y=-385925
X17843 2 1 1901 2924 1873 1883 CAG_5VX1 $T=59480 -412160 1 180 $X=52330 $Y=-412805
X17844 2 1 366 1889 1885 368 CAG_5VX1 $T=53880 -277760 1 0 $X=53450 $Y=-282880
X17845 2 1 2934 1897 2925 1876 CAG_5VX1 $T=61160 -367360 1 180 $X=54010 $Y=-368005
X17846 2 1 1869 2927 2932 2929 CAG_5VX1 $T=54440 -322560 0 0 $X=54010 $Y=-323205
X17847 2 1 2929 1926 2936 1903 CAG_5VX1 $T=57800 -331520 0 0 $X=57370 $Y=-332165
X17848 2 1 1903 1906 1888 2934 CAG_5VX1 $T=65080 -340480 0 180 $X=57930 $Y=-345600
X17849 2 1 2940 2937 1905 1898 CAG_5VX1 $T=66760 -403200 1 180 $X=59610 $Y=-403845
X17850 2 1 1898 2935 2939 1901 CAG_5VX1 $T=60600 -412160 1 0 $X=60170 $Y=-417280
X17851 2 1 2944 1902 1909 2938 CAG_5VX1 $T=67880 -358400 1 180 $X=60730 $Y=-359045
X17852 2 1 2942 1899 1932 2940 CAG_5VX1 $T=69000 -394240 1 180 $X=61850 $Y=-394885
X17853 2 1 1912 1908 2943 2942 CAG_5VX1 $T=65080 -385280 0 0 $X=64650 $Y=-385925
X17854 2 1 2938 1916 1920 1912 CAG_5VX1 $T=65080 -367360 1 0 $X=64650 $Y=-372480
X17855 2 1 380 378 1919 1922 CAG_5VX1 $T=72920 -277760 0 180 $X=65770 $Y=-282880
X17856 2 1 2950 1934 1933 1937 CAG_5VX1 $T=77960 -349440 1 180 $X=70810 $Y=-350085
X17857 2 1 2957 1949 1918 2950 CAG_5VX1 $T=80760 -331520 1 180 $X=73610 $Y=-332165
X17858 2 1 803 285 801 2951 CAG_5VX1 $T=81320 -358400 1 180 $X=74170 $Y=-359045
X17859 2 1 1956 2958 2954 1950 CAG_5VX1 $T=81880 -295680 0 180 $X=74730 $Y=-300800
X17860 2 1 2963 1955 2952 2957 CAG_5VX1 $T=83560 -322560 0 180 $X=76410 $Y=-327680
X17861 2 1 2967 1961 2962 2963 CAG_5VX1 $T=90840 -322560 0 180 $X=83690 $Y=-327680
X17862 2 1 1982 1971 1952 1966 CAG_5VX1 $T=91960 -403200 0 180 $X=84810 $Y=-408320
X17863 2 1 388 1954 2966 1956 CAG_5VX1 $T=85800 -286720 0 0 $X=85370 $Y=-287365
X17864 2 1 1966 801 1550 1972 CAG_5VX1 $T=86360 -394240 1 0 $X=85930 $Y=-399360
X17865 2 1 1984 1976 1810 1973 CAG_5VX1 $T=93640 -349440 0 180 $X=86490 $Y=-354560
X17866 2 1 1950 1967 1980 806 CAG_5VX1 $T=87480 -304640 0 0 $X=87050 $Y=-305285
X17867 2 1 1979 2967 2971 1986 CAG_5VX1 $T=91400 -322560 1 0 $X=90970 $Y=-327680
X17868 2 1 806 1991 1975 1979 CAG_5VX1 $T=92520 -313600 1 0 $X=92090 $Y=-318720
X17869 2 1 2001 1952 1981 801 CAG_5VX1 $T=100920 -394240 0 180 $X=93770 $Y=-399360
X17870 2 1 807 2976 1998 1982 CAG_5VX1 $T=104280 -412160 0 180 $X=97130 $Y=-417280
X17871 2 1 2017 804 1994 290 CAG_5VX1 $T=109880 -394240 1 180 $X=102730 $Y=-394885
X17872 2 1 2023 2989 1963 807 CAG_5VX1 $T=111560 -421120 1 180 $X=104410 $Y=-421765
X17873 2 1 2029 304 804 290 CAG_5VX1 $T=113800 -295680 1 180 $X=106650 $Y=-296325
X17874 2 1 2035 2034 2032 2023 CAG_5VX1 $T=122200 -412160 0 180 $X=115050 $Y=-417280
X17875 2 1 2050 2048 2059 2052 CAG_5VX1 $T=125560 -394240 1 180 $X=118410 $Y=-394885
X17876 2 1 2052 2063 2039 2035 CAG_5VX1 $T=126680 -403200 0 180 $X=119530 $Y=-408320
X17877 2 1 2053 2060 2022 2050 CAG_5VX1 $T=135640 -385280 1 180 $X=128490 $Y=-385925
X17878 2 1 2066 2070 2030 2053 CAG_5VX1 $T=131160 -376320 0 0 $X=130730 $Y=-376965
X17879 2 1 2075 2072 2043 2055 CAG_5VX1 $T=137880 -349440 0 180 $X=130730 $Y=-354560
X17880 2 1 2056 811 2064 2058 CAG_5VX1 $T=137880 -322560 0 180 $X=130730 $Y=-327680
X17881 2 1 2083 3009 2061 2056 CAG_5VX1 $T=137880 -304640 1 180 $X=130730 $Y=-305285
X17882 2 1 2055 810 2036 2066 CAG_5VX1 $T=131720 -367360 0 0 $X=131290 $Y=-368005
X17883 2 1 2058 2071 2073 2075 CAG_5VX1 $T=131720 -340480 1 0 $X=131290 $Y=-345600
X17884 2 1 813 2078 2087 2083 CAG_5VX1 $T=158600 -295680 1 180 $X=151450 $Y=-296325
X17885 2 1 450 447 809 813 CAG_5VX1 $T=158600 -277760 1 180 $X=151450 $Y=-278405
X17886 2 1 2236 2227 2217 2213 CAG_5VX1 $T=214600 -295680 0 180 $X=207450 $Y=-300800
X17887 2 1 2213 2216 2223 2220 CAG_5VX1 $T=209560 -313600 0 0 $X=209130 $Y=-314245
X17888 2 1 2220 2212 2226 2225 CAG_5VX1 $T=211240 -322560 1 0 $X=210810 $Y=-327680
X17889 2 1 537 2234 2228 3058 CAG_5VX1 $T=220760 -277760 0 180 $X=213610 $Y=-282880
X17890 2 1 2225 3057 2235 2231 CAG_5VX1 $T=215160 -331520 1 0 $X=214730 $Y=-336640
X17891 2 1 3058 2218 2233 2236 CAG_5VX1 $T=217960 -286720 1 0 $X=217530 $Y=-291840
X17892 2 1 2231 2238 2258 2249 CAG_5VX1 $T=226920 -340480 1 0 $X=226490 $Y=-345600
X17893 2 1 3244 516 2297 524 CAG_5VX1 $T=237000 -331520 0 0 $X=236570 $Y=-332165
X17894 2 1 2266 3069 2276 3072 CAG_5VX1 $T=244280 -313600 0 0 $X=243850 $Y=-314245
X17895 2 1 2275 2304 2313 3080 CAG_5VX1 $T=264440 -340480 1 0 $X=264010 $Y=-345600
X17896 2 1 2263 525 3081 510 CAG_5VX1 $T=264440 -322560 1 0 $X=264010 $Y=-327680
X17897 2 1 619 614 3086 3087 CAG_5VX1 $T=279560 -277760 0 180 $X=272410 $Y=-282880
X17898 2 1 3087 613 2320 3089 CAG_5VX1 $T=273960 -295680 0 0 $X=273530 $Y=-296325
X17899 2 1 2259 3090 2312 514 CAG_5VX1 $T=276760 -331520 0 0 $X=276330 $Y=-332165
X17900 2 1 2322 511 514 3092 CAG_5VX1 $T=281800 -295680 1 0 $X=281370 $Y=-300800
X17901 2 1 3099 516 2210 2328 CAG_5VX1 $T=295800 -304640 0 180 $X=288650 $Y=-309760
X17902 2 1 2351 2342 2338 3107 CAG_5VX1 $T=317080 -340480 1 180 $X=309930 $Y=-341125
X17903 2 1 2352 2349 2210 658 CAG_5VX1 $T=318760 -286720 1 180 $X=311610 $Y=-287365
X17904 2 1 3114 2345 3111 2351 CAG_5VX1 $T=323240 -331520 0 180 $X=316090 $Y=-336640
X17905 2 1 3117 2355 3116 3114 CAG_5VX1 $T=331080 -331520 0 180 $X=323930 $Y=-336640
X17906 2 1 2372 2367 2348 3117 CAG_5VX1 $T=342280 -331520 0 180 $X=335130 $Y=-336640
X17907 2 1 2382 3134 2210 3129 CAG_5VX1 $T=352360 -349440 0 180 $X=345210 $Y=-354560
X17908 2 1 2395 2382 2378 2387 CAG_5VX1 $T=362440 -349440 0 180 $X=355290 $Y=-354560
X17909 2 1 3155 3147 3145 2395 CAG_5VX1 $T=369720 -349440 0 180 $X=362570 $Y=-354560
X17910 2 1 3153 3151 2403 2401 CAG_5VX1 $T=374760 -331520 1 180 $X=367610 $Y=-332165
X17911 2 1 2406 3152 2402 2398 CAG_5VX1 $T=374760 -304640 0 180 $X=367610 $Y=-309760
X17912 2 1 2398 3149 2404 3153 CAG_5VX1 $T=370280 -322560 0 0 $X=369850 $Y=-323205
X17913 2 1 2401 2392 2407 3155 CAG_5VX1 $T=373080 -340480 1 0 $X=372650 $Y=-345600
X17914 2 1 2414 2409 2412 2406 CAG_5VX1 $T=387640 -286720 0 180 $X=380490 $Y=-291840
X17915 2 1 695 2432 2413 2414 CAG_5VX1 $T=388200 -286720 1 180 $X=381050 $Y=-287365
X17916 2 1 2429 2441 2451 3187 CAG_5VX1 $T=440840 -295680 1 0 $X=440410 $Y=-300800
X17917 2 1 2450 514 2453 692 CAG_5VX1 $T=446440 -331520 0 0 $X=446010 $Y=-332165
X17918 2 1 3187 2455 2458 3249 CAG_5VX1 $T=448680 -295680 1 0 $X=448250 $Y=-300800
X17919 2 1 3249 2457 2459 3193 CAG_5VX1 $T=452600 -304640 1 0 $X=452170 $Y=-309760
X17920 2 1 3193 2464 2461 2460 CAG_5VX1 $T=454280 -313600 1 0 $X=453850 $Y=-318720
X17921 2 1 2460 2466 3197 3196 CAG_5VX1 $T=462680 -313600 1 0 $X=462250 $Y=-318720
X17922 2 1 3196 3198 2467 3199 CAG_5VX1 $T=464920 -313600 0 0 $X=464490 $Y=-314245
X17923 2 1 3199 2465 730 3201 CAG_5VX1 $T=469400 -322560 1 0 $X=468970 $Y=-327680
X17924 2 1 2475 3206 3204 2479 CAG_5VX1 $T=485080 -304640 0 180 $X=477930 $Y=-309760
X17925 2 1 2477 2482 2471 2476 CAG_5VX1 $T=490680 -313600 1 180 $X=483530 $Y=-314245
X17926 2 1 2476 3208 693 3205 CAG_5VX1 $T=491240 -313600 0 180 $X=484090 $Y=-318720
X17927 2 1 3206 2477 3209 740 CAG_5VX1 $T=485640 -304640 1 0 $X=485210 $Y=-309760
X17928 2 1 2489 3211 2473 2475 CAG_5VX1 $T=499080 -295680 0 180 $X=491930 $Y=-300800
X17929 2 1 3214 2491 3213 2489 CAG_5VX1 $T=506920 -295680 0 180 $X=499770 $Y=-300800
X17930 2 1 747 3214 2490 744 CAG_5VX1 $T=512520 -286720 1 180 $X=505370 $Y=-287365
X17931 2 1 55 952 2562 51 913 AN22_5VX1 $T=-323000 -322560 1 180 $X=-327910 $Y=-323200
X17932 2 1 774 2658 1198 1189 1233 AN22_5VX1 $T=-228920 -394240 1 0 $X=-229350 $Y=-399360
X17933 2 1 2358 3100 2335 2346 2326 AN22_5VX1 $T=301400 -322560 0 180 $X=296490 $Y=-327680
X17934 2 1 945 913 955 938 OA21_5VX1 $T=-322440 -376320 0 180 $X=-327910 $Y=-381440
X17935 2 1 921 51 913 952 OA21_5VX1 $T=-321880 -331520 1 180 $X=-327350 $Y=-332160
X17936 2 1 1003 995 2577 3222 OA21_5VX1 $T=-303400 -367360 0 180 $X=-308870 $Y=-372480
X17937 2 1 1001 2581 768 1054 OA21_5VX1 $T=-300600 -358400 1 0 $X=-301030 $Y=-363520
X17938 2 1 769 2586 767 2605 OA21_5VX1 $T=-288840 -385280 1 0 $X=-289270 $Y=-390400
X17939 2 1 1198 1193 956 1125 OA21_5VX1 $T=-227800 -403200 1 180 $X=-233270 $Y=-403840
X17940 2 1 1688 2830 1665 1679 OA21_5VX1 $T=-24520 -394240 0 180 $X=-29990 $Y=-399360
X17941 2 1 1704 1665 1709 2842 OA21_5VX1 $T=-20600 -394240 0 0 $X=-21030 $Y=-394880
X17942 2 1 790 2864 1746 1757 OA21_5VX1 $T=6840 -385280 1 180 $X=1370 $Y=-385920
X17943 2 1 1774 801 1724 2879 OA21_5VX1 $T=11320 -376320 1 0 $X=10890 $Y=-381440
X17944 2 1 1788 1784 1730 791 OA21_5VX1 $T=18040 -403200 1 180 $X=12570 $Y=-403840
X17945 2 1 1788 1784 1746 2883 OA21_5VX1 $T=25320 -403200 1 180 $X=19850 $Y=-403840
X17946 2 1 1861 1823 1816 1817 OA21_5VX1 $T=36520 -340480 1 180 $X=31050 $Y=-341120
X17947 2 1 360 1818 2910 798 OA21_5VX1 $T=44920 -277760 0 180 $X=39450 $Y=-282880
X17948 2 1 2335 2334 525 3107 OA21_5VX1 $T=300280 -331520 1 0 $X=299850 $Y=-336640
X17949 2 1 2334 2347 2338 3110 OA21_5VX1 $T=312600 -313600 1 0 $X=312170 $Y=-318720
X17950 2 1 721 719 2452 3189 OA21_5VX1 $T=449800 -277760 0 180 $X=444330 $Y=-282880
X17951 2 1 2445 3192 2453 2452 OA21_5VX1 $T=452040 -313600 0 180 $X=446570 $Y=-318720
X17952 2 1 2456 2447 3194 2465 OA21_5VX1 $T=452040 -331520 1 0 $X=451610 $Y=-336640
X17953 2 1 733 2469 2463 3197 OA21_5VX1 $T=471080 -304640 1 180 $X=465610 $Y=-305280
X17954 2 1 736 734 735 3204 OA21_5VX1 $T=472760 -277760 0 0 $X=472330 $Y=-278400
X17955 2 1 2471 2219 820 3203 OA21_5VX1 $T=482840 -313600 1 180 $X=477370 $Y=-314240
X17956 2 1 24 26 21 20 EN3_5VX1 $T=-410920 -277760 1 180 $X=-423670 $Y=-278400
X17957 2 1 834 841 831 3220 EN3_5VX1 $T=-407560 -286720 0 180 $X=-420310 $Y=-291840
X17958 2 1 35 37 38 44 EN3_5VX1 $T=-401960 -277760 0 0 $X=-402390 $Y=-278400
X17959 2 1 849 844 854 43 EN3_5VX1 $T=-400840 -286720 0 0 $X=-401270 $Y=-287360
X17960 2 1 992 982 967 82 EN3_5VX1 $T=-310680 -277760 1 180 $X=-323430 $Y=-278400
X17961 2 1 964 962 975 977 EN3_5VX1 $T=-321320 -322560 1 0 $X=-321750 $Y=-327680
X17962 2 1 998 992 49 2592 EN3_5VX1 $T=-306200 -313600 0 0 $X=-306630 $Y=-314240
X17963 2 1 2585 992 49 1042 EN3_5VX1 $T=-298360 -304640 1 0 $X=-298790 $Y=-309760
X17964 2 1 1108 133 1105 2628 EN3_5VX1 $T=-271480 -286720 1 0 $X=-271910 $Y=-291840
X17965 2 1 1119 1114 1127 1147 EN3_5VX1 $T=-263640 -331520 0 0 $X=-264070 $Y=-332160
X17966 2 1 1126 2635 1117 2622 EN3_5VX1 $T=-249640 -349440 0 180 $X=-262390 $Y=-354560
X17967 2 1 1133 1141 1148 2649 EN3_5VX1 $T=-253000 -313600 0 0 $X=-253430 $Y=-314240
X17968 2 1 1165 1163 47 2641 EN3_5VX1 $T=-235640 -349440 1 180 $X=-248390 $Y=-350080
X17969 2 1 1171 1155 33 1151 EN3_5VX1 $T=-235080 -340480 1 180 $X=-247830 $Y=-341120
X17970 2 1 1156 772 2650 1169 EN3_5VX1 $T=-247400 -322560 1 0 $X=-247830 $Y=-327680
X17971 2 1 921 1168 2651 2652 EN3_5VX1 $T=-244040 -421120 0 0 $X=-244470 $Y=-421760
X17972 2 1 1163 1188 1202 1208 EN3_5VX1 $T=-236200 -304640 1 0 $X=-236630 $Y=-309760
X17973 2 1 55 171 47 1183 EN3_5VX1 $T=-221640 -295680 0 180 $X=-234390 $Y=-300800
X17974 2 1 1180 36 31 1248 EN3_5VX1 $T=-224440 -304640 0 0 $X=-224870 $Y=-305280
X17975 2 1 1200 36 31 1252 EN3_5VX1 $T=-222760 -313600 0 0 $X=-223190 $Y=-314240
X17976 2 1 1231 1211 2666 1220 EN3_5VX1 $T=-220520 -394240 0 0 $X=-220950 $Y=-394880
X17977 2 1 1240 1212 1219 1228 EN3_5VX1 $T=-217720 -376320 1 0 $X=-218150 $Y=-381440
X17978 2 1 1250 1252 32 1282 EN3_5VX1 $T=-210440 -313600 0 0 $X=-210870 $Y=-314240
X17979 2 1 1271 47 33 1290 EN3_5VX1 $T=-204280 -331520 0 0 $X=-204710 $Y=-332160
X17980 2 1 1293 1299 1185 3264 EN3_5VX1 $T=-197000 -313600 1 0 $X=-197430 $Y=-318720
X17981 2 1 1300 1296 1308 3266 EN3_5VX1 $T=-194200 -286720 1 0 $X=-194630 $Y=-291840
X17982 2 1 193 195 197 1326 EN3_5VX1 $T=-191960 -277760 0 0 $X=-192390 $Y=-278400
X17983 2 1 1286 1302 1305 2694 EN3_5VX1 $T=-190840 -313600 0 0 $X=-191270 $Y=-314240
X17984 2 1 1325 1322 1323 2705 EN3_5VX1 $T=-178520 -313600 0 0 $X=-178950 $Y=-314240
X17985 2 1 1337 1347 1372 1368 EN3_5VX1 $T=-175160 -331520 0 0 $X=-175590 $Y=-332160
X17986 2 1 1343 1351 1358 3268 EN3_5VX1 $T=-173480 -322560 0 0 $X=-173910 $Y=-323200
X17987 2 1 1354 1374 2711 1404 EN3_5VX1 $T=-169000 -340480 1 0 $X=-169430 $Y=-345600
X17988 2 1 1365 1380 1385 2720 EN3_5VX1 $T=-163400 -349440 1 0 $X=-163830 $Y=-354560
X17989 2 1 1371 1399 1393 2722 EN3_5VX1 $T=-162280 -376320 1 0 $X=-162710 $Y=-381440
X17990 2 1 51 1388 1379 1411 EN3_5VX1 $T=-157800 -394240 1 0 $X=-158230 $Y=-399360
X17991 2 1 1361 1370 1407 1409 EN3_5VX1 $T=-156120 -385280 1 0 $X=-156550 $Y=-390400
X17992 2 1 36 2717 1396 2736 EN3_5VX1 $T=-156120 -367360 0 0 $X=-156550 $Y=-368000
X17993 2 1 1522 1547 1511 2766 EN3_5VX1 $T=-83320 -295680 1 180 $X=-96070 $Y=-296320
X17994 2 1 1527 1531 1521 2770 EN3_5VX1 $T=-78280 -313600 1 180 $X=-91030 $Y=-314240
X17995 2 1 251 249 246 1520 EN3_5VX1 $T=-76600 -277760 1 180 $X=-89350 $Y=-278400
X17996 2 1 1561 1553 1524 2778 EN3_5VX1 $T=-76040 -340480 1 180 $X=-88790 $Y=-341120
X17997 2 1 1567 1546 1538 2780 EN3_5VX1 $T=-72680 -376320 0 180 $X=-85430 $Y=-381440
X17998 2 1 1560 1566 1551 1532 EN3_5VX1 $T=-70440 -295680 1 180 $X=-83190 $Y=-296320
X17999 2 1 784 2789 1536 1544 EN3_5VX1 $T=-68760 -349440 0 180 $X=-81510 $Y=-354560
X18000 2 1 292 264 258 1636 EN3_5VX1 $T=-40760 -286720 1 180 $X=-53510 $Y=-287360
X18001 2 1 1659 277 274 787 EN3_5VX1 $T=-39640 -349440 0 180 $X=-52390 $Y=-354560
X18002 2 1 1652 1661 300 1696 EN3_5VX1 $T=-37960 -322560 0 0 $X=-38390 $Y=-323200
X18003 2 1 1682 1685 1668 2809 EN3_5VX1 $T=-22280 -358400 0 180 $X=-35030 $Y=-363520
X18004 2 1 1687 1681 1695 2843 EN3_5VX1 $T=-27320 -286720 1 0 $X=-27750 $Y=-291840
X18005 2 1 313 285 274 1772 EN3_5VX1 $T=-17800 -349440 0 0 $X=-18230 $Y=-350080
X18006 2 1 320 268 264 2839 EN3_5VX1 $T=-4920 -286720 1 180 $X=-17670 $Y=-287360
X18007 2 1 1722 1716 1719 1655 EN3_5VX1 $T=-4360 -295680 0 180 $X=-17110 $Y=-300800
X18008 2 1 1534 1580 795 2857 EN3_5VX1 $T=-12760 -412160 0 0 $X=-13190 $Y=-412800
X18009 2 1 1808 1810 794 2905 EN3_5VX1 $T=24200 -349440 0 0 $X=23770 $Y=-350080
X18010 2 1 343 277 268 2906 EN3_5VX1 $T=25880 -286720 1 0 $X=25450 $Y=-291840
X18011 2 1 1867 290 277 1846 EN3_5VX1 $T=62280 -313600 1 180 $X=49530 $Y=-314240
X18012 2 1 799 795 290 1896 EN3_5VX1 $T=50520 -376320 1 0 $X=50090 $Y=-381440
X18013 2 1 1885 368 1889 364 EN3_5VX1 $T=63960 -286720 1 180 $X=51210 $Y=-287360
X18014 2 1 1922 1919 378 372 EN3_5VX1 $T=74600 -277760 1 180 $X=61850 $Y=-278400
X18015 2 1 1952 1971 1966 2972 EN3_5VX1 $T=80200 -412160 1 0 $X=79770 $Y=-417280
X18016 2 1 1998 2976 1982 1974 EN3_5VX1 $T=102600 -421120 1 180 $X=89850 $Y=-421760
X18017 2 1 285 2013 268 407 EN3_5VX1 $T=110440 -286720 1 180 $X=97690 $Y=-287360
X18018 2 1 807 1963 2989 3274 EN3_5VX1 $T=102040 -421120 1 0 $X=101610 $Y=-426240
X18019 2 1 277 2002 264 423 EN3_5VX1 $T=107080 -277760 1 0 $X=106650 $Y=-282880
X18020 2 1 2023 2032 2034 3003 EN3_5VX1 $T=113240 -421120 0 0 $X=112810 $Y=-421760
X18021 2 1 2035 2039 2063 2068 EN3_5VX1 $T=119960 -412160 0 0 $X=119530 $Y=-412800
X18022 2 1 2050 2022 2060 2092 EN3_5VX1 $T=124440 -385280 1 0 $X=124010 $Y=-390400
X18023 2 1 2053 2030 2070 2093 EN3_5VX1 $T=124440 -376320 1 0 $X=124010 $Y=-381440
X18024 2 1 2066 2036 810 2074 EN3_5VX1 $T=125000 -367360 1 0 $X=124570 $Y=-372480
X18025 2 1 2052 2059 2048 3011 EN3_5VX1 $T=125560 -394240 0 0 $X=125130 $Y=-394880
X18026 2 1 2055 2043 2072 3020 EN3_5VX1 $T=125560 -358400 1 0 $X=125130 $Y=-363520
X18027 2 1 2056 2061 3009 3013 EN3_5VX1 $T=125560 -313600 0 0 $X=125130 $Y=-314240
X18028 2 1 2058 2064 811 3012 EN3_5VX1 $T=126120 -331520 1 0 $X=125690 $Y=-336640
X18029 2 1 2075 2073 2071 2102 EN3_5VX1 $T=151880 -340480 1 0 $X=151450 $Y=-345600
X18030 2 1 2083 2087 2078 2095 EN3_5VX1 $T=151880 -304640 0 0 $X=151450 $Y=-305280
X18031 2 1 813 809 447 3024 EN3_5VX1 $T=152440 -277760 1 0 $X=152010 $Y=-282880
X18032 2 1 3058 2228 2234 2185 EN3_5VX1 $T=217960 -286720 1 180 $X=205210 $Y=-287360
X18033 2 1 2225 2226 2212 2201 EN3_5VX1 $T=218520 -331520 1 180 $X=205770 $Y=-332160
X18034 2 1 2220 2223 2216 3282 EN3_5VX1 $T=220760 -313600 0 180 $X=208010 $Y=-318720
X18035 2 1 2236 2233 2218 2198 EN3_5VX1 $T=220760 -295680 1 180 $X=208010 $Y=-296320
X18036 2 1 537 531 520 3283 EN3_5VX1 $T=220760 -277760 1 180 $X=208010 $Y=-278400
X18037 2 1 2213 2217 2227 2199 EN3_5VX1 $T=224680 -304640 1 180 $X=211930 $Y=-305280
X18038 2 1 2231 2235 3057 3055 EN3_5VX1 $T=226920 -340480 0 180 $X=214170 $Y=-345600
X18039 2 1 2249 2258 2238 3285 EN3_5VX1 $T=238120 -349440 1 180 $X=225370 $Y=-350080
X18040 2 1 525 2290 510 3085 EN3_5VX1 $T=260520 -286720 1 0 $X=260090 $Y=-291840
X18041 2 1 3109 510 2349 2356 EN3_5VX1 $T=317080 -313600 0 0 $X=316650 $Y=-314240
X18042 2 1 2352 549 555 3122 EN3_5VX1 $T=319320 -286720 0 0 $X=318890 $Y=-287360
X18043 2 1 709 557 555 2433 EN3_5VX1 $T=431320 -304640 1 180 $X=418570 $Y=-305280
X18044 2 1 716 510 524 3184 EN3_5VX1 $T=445880 -295680 1 180 $X=433130 $Y=-296320
X18045 2 1 832 833 828 AND2_5VX1 $T=-414840 -295680 0 180 $X=-419190 $Y=-300800
X18046 2 1 1363 1340 1373 AND2_5VX1 $T=-166760 -421120 1 0 $X=-167190 $Y=-426240
X18047 2 1 795 1580 1784 AND2_5VX1 $T=23640 -394240 0 180 $X=19290 $Y=-399360
X18048 2 1 2933 1893 371 AND2_5VX1 $T=65640 -286720 0 180 $X=61290 $Y=-291840
X18049 2 1 1974 2972 2054 AND2_5VX1 $T=93640 -421120 1 0 $X=93210 $Y=-426240
X18050 2 1 2303 2296 2273 AND2_5VX1 $T=259960 -340480 0 180 $X=255610 $Y=-345600
X18051 2 1 2494 12 824 NO2I1_5VX1 $T=-430520 -295680 1 180 $X=-434870 $Y=-296320
X18052 2 1 2495 12 823 NO2I1_5VX1 $T=-428280 -286720 1 180 $X=-432630 $Y=-287360
X18053 2 1 846 33 34 NO2I1_5VX1 $T=-402520 -286720 1 180 $X=-406870 $Y=-287360
X18054 2 1 848 36 846 NO2I1_5VX1 $T=-399160 -304640 1 180 $X=-403510 $Y=-305280
X18055 2 1 882 47 848 NO2I1_5VX1 $T=-373960 -304640 1 180 $X=-378310 $Y=-305280
X18056 2 1 890 55 2520 NO2I1_5VX1 $T=-370600 -367360 0 180 $X=-374950 $Y=-372480
X18057 2 1 887 894 58 NO2I1_5VX1 $T=-372840 -295680 1 0 $X=-373270 $Y=-300800
X18058 2 1 888 894 890 NO2I1_5VX1 $T=-366120 -385280 0 180 $X=-370470 $Y=-390400
X18059 2 1 901 764 887 NO2I1_5VX1 $T=-362760 -304640 0 180 $X=-367110 $Y=-309760
X18060 2 1 934 922 888 NO2I1_5VX1 $T=-334760 -394240 0 180 $X=-339110 $Y=-399360
X18061 2 1 1159 147 2642 NO2I1_5VX1 $T=-245160 -286720 1 180 $X=-249510 $Y=-287360
X18062 2 1 1166 147 2645 NO2I1_5VX1 $T=-242920 -295680 1 180 $X=-247270 $Y=-296320
X18063 2 1 1313 147 1033 NO2I1_5VX1 $T=-186920 -304640 0 0 $X=-187350 $Y=-305280
X18064 2 1 1172 147 1073 NO2I1_5VX1 $T=-186920 -295680 0 0 $X=-187350 $Y=-296320
X18065 2 1 1178 147 1223 NO2I1_5VX1 $T=-174040 -277760 0 180 $X=-178390 $Y=-282880
X18066 2 1 3291 227 1414 NO2I1_5VX1 $T=-149400 -295680 0 0 $X=-149830 $Y=-296320
X18067 2 1 1395 227 1422 NO2I1_5VX1 $T=-147160 -286720 1 0 $X=-147590 $Y=-291840
X18068 2 1 1429 227 2730 NO2I1_5VX1 $T=-141000 -277760 1 180 $X=-145350 $Y=-278400
X18069 2 1 1432 227 1415 NO2I1_5VX1 $T=-140440 -313600 1 180 $X=-144790 $Y=-314240
X18070 2 1 2745 227 1256 NO2I1_5VX1 $T=-137080 -295680 0 180 $X=-141430 $Y=-300800
X18071 2 1 1418 227 2742 NO2I1_5VX1 $T=-139320 -322560 1 0 $X=-139750 $Y=-327680
X18072 2 1 1405 227 1439 NO2I1_5VX1 $T=-139320 -313600 0 0 $X=-139750 $Y=-314240
X18073 2 1 2741 227 780 NO2I1_5VX1 $T=-138760 -367360 0 0 $X=-139190 $Y=-368000
X18074 2 1 1420 227 1453 NO2I1_5VX1 $T=-136520 -358400 0 0 $X=-136950 $Y=-359040
X18075 2 1 1442 227 2750 NO2I1_5VX1 $T=-136520 -340480 0 0 $X=-136950 $Y=-341120
X18076 2 1 1462 227 2746 NO2I1_5VX1 $T=-132040 -403200 1 180 $X=-136390 $Y=-403840
X18077 2 1 1446 227 1456 NO2I1_5VX1 $T=-135400 -322560 1 0 $X=-135830 $Y=-327680
X18078 2 1 1449 227 1176 NO2I1_5VX1 $T=-134280 -394240 1 0 $X=-134710 $Y=-399360
X18079 2 1 1460 227 1224 NO2I1_5VX1 $T=-134280 -313600 0 0 $X=-134710 $Y=-314240
X18080 2 1 1452 227 2751 NO2I1_5VX1 $T=-133160 -385280 1 0 $X=-133590 $Y=-390400
X18081 2 1 2752 227 2743 NO2I1_5VX1 $T=-129240 -376320 1 180 $X=-133590 $Y=-376960
X18082 2 1 1454 227 1466 NO2I1_5VX1 $T=-132040 -349440 0 0 $X=-132470 $Y=-350080
X18083 2 1 2747 227 1465 NO2I1_5VX1 $T=-131480 -358400 1 0 $X=-131910 $Y=-363520
X18084 2 1 2753 227 1131 NO2I1_5VX1 $T=-128680 -403200 0 0 $X=-129110 $Y=-403840
X18085 2 1 1469 227 1474 NO2I1_5VX1 $T=-125880 -385280 0 0 $X=-126310 $Y=-385920
X18086 2 1 1472 227 1477 NO2I1_5VX1 $T=-123640 -277760 0 0 $X=-124070 $Y=-278400
X18087 2 1 1464 227 1037 NO2I1_5VX1 $T=-118040 -385280 1 180 $X=-122390 $Y=-385920
X18088 2 1 2762 227 1239 NO2I1_5VX1 $T=-113000 -295680 1 180 $X=-117350 $Y=-296320
X18089 2 1 2761 227 1485 NO2I1_5VX1 $T=-113000 -277760 1 180 $X=-117350 $Y=-278400
X18090 2 1 1493 227 1249 NO2I1_5VX1 $T=-112440 -367360 1 180 $X=-116790 $Y=-368000
X18091 2 1 2759 227 1100 NO2I1_5VX1 $T=-112440 -340480 0 180 $X=-116790 $Y=-345600
X18092 2 1 3273 227 930 NO2I1_5VX1 $T=-111880 -331520 0 180 $X=-116230 $Y=-336640
X18093 2 1 1514 227 1062 NO2I1_5VX1 $T=-111880 -286720 1 180 $X=-116230 $Y=-287360
X18094 2 1 1403 227 1489 NO2I1_5VX1 $T=-97880 -358400 0 0 $X=-98310 $Y=-359040
X18095 2 1 1496 227 1499 NO2I1_5VX1 $T=-97880 -349440 0 0 $X=-98310 $Y=-350080
X18096 2 1 2764 2768 2769 NO2I1_5VX1 $T=-97320 -385280 1 0 $X=-97750 $Y=-390400
X18097 2 1 1369 227 1502 NO2I1_5VX1 $T=-97320 -376320 0 0 $X=-97750 $Y=-376960
X18098 2 1 1504 227 2763 NO2I1_5VX1 $T=-93400 -304640 1 180 $X=-97750 $Y=-305280
X18099 2 1 1498 227 2772 NO2I1_5VX1 $T=-96200 -367360 0 0 $X=-96630 $Y=-368000
X18100 2 1 2841 1706 1674 NO2I1_5VX1 $T=-17240 -394240 0 180 $X=-21590 $Y=-399360
X18101 2 1 2716 334 1787 NO2I1_5VX1 $T=11880 -277760 0 0 $X=11450 $Y=-278400
X18102 2 1 1797 334 1781 NO2I1_5VX1 $T=21400 -277760 1 180 $X=17050 $Y=-278400
X18103 2 1 1840 2907 1848 NO2I1_5VX1 $T=35960 -367360 0 0 $X=35530 $Y=-368000
X18104 2 1 2896 1830 1844 NO2I1_5VX1 $T=42120 -394240 0 180 $X=37770 $Y=-399360
X18105 2 1 1550 1534 2919 NO2I1_5VX1 $T=53320 -385280 0 180 $X=48970 $Y=-390400
X18106 2 1 2923 2922 1858 NO2I1_5VX1 $T=55000 -403200 1 180 $X=50650 $Y=-403840
X18107 2 1 1534 1550 2922 NO2I1_5VX1 $T=58920 -394240 1 180 $X=54570 $Y=-394880
X18108 2 1 2118 460 815 NO2I1_5VX1 $T=167000 -376320 0 0 $X=166570 $Y=-376960
X18109 2 1 2119 460 3031 NO2I1_5VX1 $T=167000 -331520 1 0 $X=166570 $Y=-336640
X18110 2 1 2116 460 3033 NO2I1_5VX1 $T=167560 -376320 1 0 $X=167130 $Y=-381440
X18111 2 1 2117 460 2142 NO2I1_5VX1 $T=167560 -367360 0 0 $X=167130 $Y=-368000
X18112 2 1 2123 460 3030 NO2I1_5VX1 $T=168680 -358400 1 0 $X=168250 $Y=-363520
X18113 2 1 2127 460 2133 NO2I1_5VX1 $T=169800 -358400 0 0 $X=169370 $Y=-359040
X18114 2 1 2121 460 2135 NO2I1_5VX1 $T=169800 -349440 0 0 $X=169370 $Y=-350080
X18115 2 1 2129 460 2146 NO2I1_5VX1 $T=169800 -313600 1 0 $X=169370 $Y=-318720
X18116 2 1 2130 460 2138 NO2I1_5VX1 $T=169800 -304640 1 0 $X=169370 $Y=-309760
X18117 2 1 2144 460 2137 NO2I1_5VX1 $T=177640 -304640 0 180 $X=173290 $Y=-309760
X18118 2 1 2132 460 3034 NO2I1_5VX1 $T=173720 -286720 0 0 $X=173290 $Y=-287360
X18119 2 1 2160 460 2140 NO2I1_5VX1 $T=184360 -331520 1 180 $X=180010 $Y=-332160
X18120 2 1 3280 460 3023 NO2I1_5VX1 $T=190520 -322560 0 180 $X=186170 $Y=-327680
X18121 2 1 3281 460 3037 NO2I1_5VX1 $T=191080 -340480 1 180 $X=186730 $Y=-341120
X18122 2 1 2253 460 1789 NO2I1_5VX1 $T=192200 -304640 1 180 $X=187850 $Y=-305280
X18123 2 1 3043 460 2151 NO2I1_5VX1 $T=196120 -331520 0 180 $X=191770 $Y=-336640
X18124 2 1 2189 460 2136 NO2I1_5VX1 $T=197240 -340480 0 180 $X=192890 $Y=-345600
X18125 2 1 2305 460 2311 NO2I1_5VX1 $T=263880 -277760 0 180 $X=259530 $Y=-282880
X18126 2 1 605 460 2307 NO2I1_5VX1 $T=268920 -277760 0 180 $X=264570 $Y=-282880
X18127 2 1 3154 689 2399 NO2I1_5VX1 $T=373640 -277760 1 180 $X=369290 $Y=-278400
X18128 2 1 2405 689 3159 NO2I1_5VX1 $T=375320 -277760 0 0 $X=374890 $Y=-278400
X18129 2 1 49 47 3287 EN2_5VX1 $T=-380680 -349440 1 180 $X=-387270 $Y=-350080
X18130 2 1 956 922 2570 EN2_5VX1 $T=-325240 -394240 1 0 $X=-325670 $Y=-399360
X18131 2 1 910 2571 973 EN2_5VX1 $T=-321320 -358400 0 0 $X=-321750 $Y=-359040
X18132 2 1 913 765 2574 EN2_5VX1 $T=-317960 -394240 1 0 $X=-318390 $Y=-399360
X18133 2 1 2571 764 994 EN2_5VX1 $T=-315720 -358400 1 0 $X=-316150 $Y=-363520
X18134 2 1 913 765 995 EN2_5VX1 $T=-315160 -367360 1 0 $X=-315590 $Y=-372480
X18135 2 1 974 997 986 EN2_5VX1 $T=-304520 -331520 1 180 $X=-311110 $Y=-332160
X18136 2 1 765 956 2573 EN2_5VX1 $T=-303960 -403200 1 180 $X=-310550 $Y=-403840
X18137 2 1 110 999 94 EN2_5VX1 $T=-302840 -277760 1 180 $X=-309430 $Y=-278400
X18138 2 1 1039 1034 1057 EN2_5VX1 $T=-273720 -376320 1 180 $X=-280310 $Y=-376960
X18139 2 1 1160 2646 1115 EN2_5VX1 $T=-244040 -394240 1 180 $X=-250630 $Y=-394880
X18140 2 1 956 774 1168 EN2_5VX1 $T=-241800 -403200 0 0 $X=-242230 $Y=-403840
X18141 2 1 1182 1210 174 EN2_5VX1 $T=-227800 -277760 1 0 $X=-228230 $Y=-282880
X18142 2 1 1280 1267 1336 EN2_5VX1 $T=-198680 -394240 0 0 $X=-199110 $Y=-394880
X18143 2 1 1316 922 1328 EN2_5VX1 $T=-185800 -403200 1 0 $X=-186230 $Y=-408320
X18144 2 1 2764 2768 2775 EN2_5VX1 $T=-96760 -394240 0 0 $X=-97190 $Y=-394880
X18145 2 1 1658 285 1623 EN2_5VX1 $T=-43000 -403200 1 180 $X=-49590 $Y=-403840
X18146 2 1 1658 1656 2821 EN2_5VX1 $T=-34600 -421120 0 180 $X=-41190 $Y=-426240
X18147 2 1 1677 1676 2823 EN2_5VX1 $T=-26760 -376320 0 180 $X=-33350 $Y=-381440
X18148 2 1 1654 1663 1658 EN2_5VX1 $T=-25080 -412160 0 180 $X=-31670 $Y=-417280
X18149 2 1 304 290 1686 EN2_5VX1 $T=-31240 -295680 1 0 $X=-31670 $Y=-300800
X18150 2 1 795 304 2836 EN2_5VX1 $T=-17800 -295680 0 180 $X=-24390 $Y=-300800
X18151 2 1 1580 1691 2837 EN2_5VX1 $T=-16120 -331520 1 180 $X=-22710 $Y=-332160
X18152 2 1 1534 801 1690 EN2_5VX1 $T=-12760 -412160 1 180 $X=-19350 $Y=-412800
X18153 2 1 1691 795 2833 EN2_5VX1 $T=-9960 -331520 1 180 $X=-16550 $Y=-332160
X18154 2 1 1691 795 3298 EN2_5VX1 $T=-8840 -340480 0 180 $X=-15430 $Y=-345600
X18155 2 1 290 285 2832 EN2_5VX1 $T=-8840 -277760 1 180 $X=-15430 $Y=-278400
X18156 2 1 795 290 1801 EN2_5VX1 $T=16360 -295680 0 0 $X=15930 $Y=-296320
X18157 2 1 801 1580 2921 EN2_5VX1 $T=47160 -421120 0 0 $X=46730 $Y=-421760
X18158 2 1 804 304 1877 EN2_5VX1 $T=56680 -295680 0 180 $X=50090 $Y=-300800
X18159 2 1 277 274 1925 EN2_5VX1 $T=65080 -349440 0 0 $X=64650 $Y=-350080
X18160 2 1 285 277 1941 EN2_5VX1 $T=66200 -358400 1 0 $X=65770 $Y=-363520
X18161 2 1 274 268 2941 EN2_5VX1 $T=72920 -313600 1 180 $X=66330 $Y=-314240
X18162 2 1 795 304 1929 EN2_5VX1 $T=67320 -403200 0 0 $X=66890 $Y=-403840
X18163 2 1 1580 1691 1924 EN2_5VX1 $T=68440 -412160 1 0 $X=68010 $Y=-417280
X18164 2 1 304 290 2947 EN2_5VX1 $T=71240 -394240 0 0 $X=70810 $Y=-394880
X18165 2 1 1691 795 1947 EN2_5VX1 $T=77400 -403200 1 0 $X=76970 $Y=-408320
X18166 2 1 290 285 2948 EN2_5VX1 $T=85800 -376320 0 180 $X=79210 $Y=-381440
X18167 2 1 1550 1810 2968 EN2_5VX1 $T=84120 -385280 0 0 $X=83690 $Y=-385920
X18168 2 1 1952 1976 2032 EN2_5VX1 $T=91960 -412160 0 0 $X=91530 $Y=-412800
X18169 2 1 804 2968 1988 EN2_5VX1 $T=102040 -376320 0 180 $X=95450 $Y=-381440
X18170 2 1 801 804 2007 EN2_5VX1 $T=97000 -376320 0 0 $X=96570 $Y=-376960
X18171 2 1 795 1993 2979 EN2_5VX1 $T=97560 -331520 1 0 $X=97130 $Y=-336640
X18172 2 1 2984 2990 2004 EN2_5VX1 $T=105400 -349440 0 0 $X=104970 $Y=-350080
X18173 2 1 2219 525 2269 EN2_5VX1 $T=234200 -322560 0 0 $X=233770 $Y=-323200
X18174 2 1 2276 516 2272 EN2_5VX1 $T=253240 -313600 0 180 $X=246650 $Y=-318720
X18175 2 1 514 516 2271 EN2_5VX1 $T=257160 -313600 1 180 $X=250570 $Y=-314240
X18176 2 1 525 516 2331 EN2_5VX1 $T=304200 -286720 0 180 $X=297610 $Y=-291840
X18177 2 1 2358 525 2349 EN2_5VX1 $T=299720 -322560 0 0 $X=299290 $Y=-323200
X18178 2 1 2328 3103 3302 EN2_5VX1 $T=300840 -304640 0 0 $X=300410 $Y=-305280
X18179 2 1 516 517 659 EN2_5VX1 $T=323800 -277760 1 180 $X=317210 $Y=-278400
X18180 2 1 2219 525 3127 EN2_5VX1 $T=333880 -349440 1 0 $X=333450 $Y=-354560
X18181 2 1 2219 514 3141 EN2_5VX1 $T=356280 -349440 0 0 $X=355850 $Y=-350080
X18182 2 1 514 516 3304 EN2_5VX1 $T=367480 -331520 1 180 $X=360890 $Y=-332160
X18183 2 1 516 517 2415 EN2_5VX1 $T=363560 -322560 1 0 $X=363130 $Y=-327680
X18184 2 1 524 511 3148 EN2_5VX1 $T=373640 -295680 0 180 $X=367050 $Y=-300800
X18185 2 1 525 516 3157 EN2_5VX1 $T=381480 -331520 1 180 $X=374890 $Y=-332160
X18186 2 1 517 510 2411 EN2_5VX1 $T=377560 -304640 1 0 $X=377130 $Y=-309760
X18187 2 1 510 524 3163 EN2_5VX1 $T=378120 -295680 0 0 $X=377690 $Y=-296320
X18188 2 1 514 525 3158 EN2_5VX1 $T=387080 -340480 0 180 $X=380490 $Y=-345600
X18189 2 1 511 549 3180 EN2_5VX1 $T=419000 -286720 1 0 $X=418570 $Y=-291840
X18190 2 1 2219 514 2447 EN2_5VX1 $T=450920 -340480 1 180 $X=444330 $Y=-341120
X18191 2 1 723 726 2462 EN2_5VX1 $T=464360 -277760 0 180 $X=457770 $Y=-282880
X18192 2 1 2219 693 2481 EN2_5VX1 $T=481720 -286720 0 0 $X=481290 $Y=-287360
X18193 2 1 2481 2472 3212 EN2_5VX1 $T=504680 -286720 1 180 $X=498090 $Y=-287360
X18194 2 1 921 914 764 NA2_5VX1 $T=-331400 -349440 0 180 $X=-334630 $Y=-354560
X18195 2 1 767 1001 965 NA2_5VX1 $T=-307880 -349440 0 0 $X=-308310 $Y=-350080
X18196 2 1 1163 168 165 NA2_5VX1 $T=-235080 -277760 0 0 $X=-235510 $Y=-278400
X18197 2 1 2655 1132 1179 NA2_5VX1 $T=-225560 -394240 1 180 $X=-228790 $Y=-394880
X18198 2 1 1218 1160 1146 NA2_5VX1 $T=-222200 -385280 0 180 $X=-225430 $Y=-390400
X18199 2 1 921 1193 1218 NA2_5VX1 $T=-221640 -403200 0 180 $X=-224870 $Y=-408320
X18200 2 1 2655 1211 1218 NA2_5VX1 $T=-217160 -394240 0 180 $X=-220390 $Y=-399360
X18201 2 1 913 1278 1283 NA2_5VX1 $T=-202040 -394240 1 0 $X=-202470 $Y=-399360
X18202 2 1 956 2679 922 NA2_5VX1 $T=-184680 -385280 1 180 $X=-187910 $Y=-385920
X18203 2 1 2688 1319 922 NA2_5VX1 $T=-184680 -394240 0 0 $X=-185110 $Y=-394880
X18204 2 1 51 1352 49 NA2_5VX1 $T=-157800 -358400 0 180 $X=-161030 $Y=-363520
X18205 2 1 1392 225 1398 NA2_5VX1 $T=-150520 -286720 1 180 $X=-153750 $Y=-287360
X18206 2 1 1434 2768 1448 NA2_5VX1 $T=-96760 -403200 0 0 $X=-97190 $Y=-403840
X18207 2 1 1712 2838 1708 NA2_5VX1 $T=-16680 -295680 1 180 $X=-19910 $Y=-296320
X18208 2 1 1708 3297 311 NA2_5VX1 $T=-16680 -277760 1 180 $X=-19910 $Y=-278400
X18209 2 1 1718 1701 1712 NA2_5VX1 $T=-15000 -304640 1 180 $X=-18230 $Y=-305280
X18210 2 1 1697 2841 1717 NA2_5VX1 $T=-15560 -403200 0 0 $X=-15990 $Y=-403840
X18211 2 1 1717 1704 1707 NA2_5VX1 $T=-8840 -385280 0 180 $X=-12070 $Y=-390400
X18212 2 1 1534 2869 1718 NA2_5VX1 $T=12440 -385280 1 180 $X=9210 $Y=-385920
X18213 2 1 1730 1724 2884 NA2_5VX1 $T=15240 -385280 0 0 $X=14810 $Y=-385920
X18214 2 1 1778 2895 793 NA2_5VX1 $T=28680 -385280 0 0 $X=28250 $Y=-385920
X18215 2 1 1820 2896 796 NA2_5VX1 $T=30360 -394240 1 0 $X=29930 $Y=-399360
X18216 2 1 1795 793 1744 NA2_5VX1 $T=34280 -376320 0 180 $X=31050 $Y=-381440
X18217 2 1 1810 2903 1808 NA2_5VX1 $T=34840 -340480 1 0 $X=34410 $Y=-345600
X18218 2 1 1860 1840 2911 NA2_5VX1 $T=47720 -358400 0 180 $X=44490 $Y=-363520
X18219 2 1 1810 1960 804 NA2_5VX1 $T=79080 -385280 0 0 $X=78650 $Y=-385920
X18220 2 1 1810 1970 304 NA2_5VX1 $T=85240 -376320 0 0 $X=84810 $Y=-376960
X18221 2 1 1981 1952 1969 NA2_5VX1 $T=91960 -385280 0 180 $X=88730 $Y=-390400
X18222 2 1 804 1997 1973 NA2_5VX1 $T=95880 -358400 0 0 $X=95450 $Y=-359040
X18223 2 1 1994 1998 1968 NA2_5VX1 $T=97560 -403200 0 0 $X=97130 $Y=-403840
X18224 2 1 804 2006 795 NA2_5VX1 $T=103720 -403200 0 0 $X=103290 $Y=-403840
X18225 2 1 2981 2990 1997 NA2_5VX1 $T=107640 -349440 1 0 $X=107210 $Y=-354560
X18226 2 1 274 2026 268 NA2_5VX1 $T=116600 -340480 1 0 $X=116170 $Y=-345600
X18227 2 1 516 3083 517 NA2_5VX1 $T=276760 -304640 0 180 $X=273530 $Y=-309760
X18228 2 1 525 2315 516 NA2_5VX1 $T=279000 -331520 0 180 $X=275770 $Y=-336640
X18229 2 1 2210 2334 3101 NA2_5VX1 $T=295800 -313600 1 0 $X=295370 $Y=-318720
X18230 2 1 3101 2333 2337 NA2_5VX1 $T=300840 -304640 0 180 $X=297610 $Y=-309760
X18231 2 1 3101 2341 652 NA2_5VX1 $T=305320 -313600 1 0 $X=304890 $Y=-318720
X18232 2 1 3105 2340 2337 NA2_5VX1 $T=310920 -331520 1 180 $X=307690 $Y=-332160
X18233 2 1 2337 654 652 NA2_5VX1 $T=310920 -295680 1 0 $X=310490 $Y=-300800
X18234 2 1 3109 2338 3105 NA2_5VX1 $T=315960 -331520 1 180 $X=312730 $Y=-332160
X18235 2 1 525 2365 517 NA2_5VX1 $T=335000 -331520 1 180 $X=331770 $Y=-332160
X18236 2 1 549 3125 555 NA2_5VX1 $T=347880 -286720 1 180 $X=344650 $Y=-287360
X18237 2 1 2400 2478 692 NA2_5VX1 $T=485640 -286720 1 0 $X=485210 $Y=-291840
X18238 2 1 765 913 1022 2590 AO21_5VX1 $T=-288840 -394240 1 180 $X=-294310 $Y=-394880
X18239 2 1 1297 2680 2682 2685 AO21_5VX1 $T=-191960 -412160 1 0 $X=-192390 $Y=-417280
X18240 2 1 1852 799 1860 3237 AO21_5VX1 $T=47160 -349440 0 180 $X=41690 $Y=-354560
X18241 2 1 2306 2295 3078 3077 AO21_5VX1 $T=261080 -322560 0 180 $X=255610 $Y=-327680
X18242 2 1 818 2315 2210 2301 AO21_5VX1 $T=277880 -340480 0 180 $X=272410 $Y=-345600
X18243 2 1 514 2219 2385 3134 AO21_5VX1 $T=342280 -349440 0 0 $X=341850 $Y=-350080
X18244 2 1 910 913 916 OR2_5VX1 $T=-345400 -331520 1 0 $X=-345830 $Y=-336640
X18245 2 1 765 913 2548 OR2_5VX1 $T=-329160 -376320 0 180 $X=-333510 $Y=-381440
X18246 2 1 956 765 959 OR2_5VX1 $T=-326360 -412160 0 0 $X=-326790 $Y=-412800
X18247 2 1 765 913 979 OR2_5VX1 $T=-306200 -412160 1 180 $X=-310550 $Y=-412800
X18248 2 1 956 913 769 OR2_5VX1 $T=-278200 -385280 0 180 $X=-282550 $Y=-390400
X18249 2 1 1263 2667 1210 OR2_5VX1 $T=-206520 -295680 1 180 $X=-210870 $Y=-296320
X18250 2 1 1691 1580 1688 OR2_5VX1 $T=-18360 -367360 1 180 $X=-22710 $Y=-368000
X18251 2 1 1580 801 3296 OR2_5VX1 $T=-17240 -331520 0 180 $X=-21590 $Y=-336640
X18252 2 1 795 1580 1788 OR2_5VX1 $T=29240 -394240 0 180 $X=24890 $Y=-399360
X18253 2 1 795 1810 1861 OR2_5VX1 $T=34280 -331520 1 0 $X=33850 $Y=-336640
X18254 2 1 801 2919 2914 OR2_5VX1 $T=43240 -385280 1 0 $X=42810 $Y=-390400
X18255 2 1 1550 1534 2923 OR2_5VX1 $T=58920 -394240 0 180 $X=54570 $Y=-399360
X18256 2 1 804 1580 1910 OR2_5VX1 $T=61160 -403200 1 0 $X=60730 $Y=-408320
X18257 2 1 274 277 1913 OR2_5VX1 $T=62280 -313600 0 0 $X=61850 $Y=-314240
X18258 2 1 1580 801 2945 OR2_5VX1 $T=67320 -421120 0 0 $X=66890 $Y=-421760
X18259 2 1 277 285 802 OR2_5VX1 $T=69560 -358400 0 0 $X=69130 $Y=-359040
X18260 2 1 268 274 1944 OR2_5VX1 $T=69560 -286720 1 0 $X=69130 $Y=-291840
X18261 2 1 304 795 3240 OR2_5VX1 $T=77400 -385280 1 180 $X=73050 $Y=-385920
X18262 2 1 285 290 1940 OR2_5VX1 $T=78520 -367360 0 180 $X=74170 $Y=-372480
X18263 2 1 795 804 2953 OR2_5VX1 $T=75160 -403200 0 0 $X=74730 $Y=-403840
X18264 2 1 290 304 1948 OR2_5VX1 $T=84120 -376320 1 180 $X=79770 $Y=-376960
X18265 2 1 514 2219 2325 OR2_5VX1 $T=289080 -313600 1 0 $X=288650 $Y=-318720
X18266 2 1 524 510 2394 OR2_5VX1 $T=377000 -295680 1 180 $X=372650 $Y=-296320
X18267 2 1 514 2219 3164 OR2_5VX1 $T=377560 -349440 1 0 $X=377130 $Y=-354560
X18268 2 1 517 692 3161 OR2_5VX1 $T=378120 -313600 1 0 $X=377690 $Y=-318720
X18269 2 1 693 514 3156 OR2_5VX1 $T=387080 -340480 1 180 $X=382730 $Y=-341120
X18270 2 1 692 693 3160 OR2_5VX1 $T=387080 -322560 1 180 $X=382730 $Y=-323200
X18271 2 1 510 517 3162 OR2_5VX1 $T=387640 -304640 0 180 $X=383290 $Y=-309760
X18272 2 1 511 524 3183 OR2_5VX1 $T=426840 -286720 1 0 $X=426410 $Y=-291840
X18273 2 1 693 2219 2445 OR2_5VX1 $T=439720 -322560 0 180 $X=435370 $Y=-327680
X18274 2 1 514 2219 730 OR2_5VX1 $T=475000 -313600 0 180 $X=470650 $Y=-318720
X18275 2 1 692 693 733 OR2_5VX1 $T=475000 -286720 0 180 $X=470650 $Y=-291840
X18276 2 1 693 2219 737 OR2_5VX1 $T=474440 -277760 1 0 $X=474010 $Y=-282880
X18277 2 1 514 2219 2484 OR2_5VX1 $T=483960 -295680 0 0 $X=483530 $Y=-296320
X18278 2 1 49 882 47 NO2_5VX1 $T=-379560 -295680 1 0 $X=-379990 $Y=-300800
X18279 2 1 910 901 915 NO2_5VX1 $T=-339800 -322560 1 180 $X=-343030 $Y=-323200
X18280 2 1 921 918 764 NO2_5VX1 $T=-334760 -358400 1 180 $X=-337990 $Y=-359040
X18281 2 1 765 935 764 NO2_5VX1 $T=-335880 -322560 1 0 $X=-336310 $Y=-327680
X18282 2 1 910 934 922 NO2_5VX1 $T=-326920 -394240 1 180 $X=-330150 $Y=-394880
X18283 2 1 765 962 910 NO2_5VX1 $T=-325240 -331520 1 0 $X=-325670 $Y=-336640
X18284 2 1 910 968 764 NO2_5VX1 $T=-321320 -331520 1 0 $X=-321750 $Y=-336640
X18285 2 1 955 947 765 NO2_5VX1 $T=-316840 -376320 1 180 $X=-320070 $Y=-376960
X18286 2 1 913 984 765 NO2_5VX1 $T=-315720 -340480 1 0 $X=-316150 $Y=-345600
X18287 2 1 51 97 49 NO2_5VX1 $T=-311800 -286720 1 0 $X=-312230 $Y=-291840
X18288 2 1 49 98 47 NO2_5VX1 $T=-307320 -286720 1 180 $X=-310550 $Y=-287360
X18289 2 1 47 1043 36 NO2_5VX1 $T=-271480 -304640 1 180 $X=-274710 $Y=-305280
X18290 2 1 771 1130 1118 NO2_5VX1 $T=-254680 -412160 1 180 $X=-257910 $Y=-412800
X18291 2 1 36 151 31 NO2_5VX1 $T=-247400 -295680 1 0 $X=-247830 $Y=-300800
X18292 2 1 2654 158 773 NO2_5VX1 $T=-238440 -295680 1 180 $X=-241670 $Y=-296320
X18293 2 1 51 1154 47 NO2_5VX1 $T=-237320 -358400 0 180 $X=-240550 $Y=-363520
X18294 2 1 1163 1136 164 NO2_5VX1 $T=-237880 -313600 0 0 $X=-238310 $Y=-314240
X18295 2 1 36 2654 1182 NO2_5VX1 $T=-237320 -295680 0 0 $X=-237750 $Y=-296320
X18296 2 1 1204 773 31 NO2_5VX1 $T=-227240 -295680 1 180 $X=-230470 $Y=-296320
X18297 2 1 1204 1238 1235 NO2_5VX1 $T=-221080 -295680 0 0 $X=-221510 $Y=-296320
X18298 2 1 1235 1246 1182 NO2_5VX1 $T=-213240 -295680 1 180 $X=-216470 $Y=-296320
X18299 2 1 33 1236 31 NO2_5VX1 $T=-211560 -304640 0 180 $X=-214790 $Y=-309760
X18300 2 1 36 1225 33 NO2_5VX1 $T=-211560 -313600 1 0 $X=-211990 $Y=-318720
X18301 2 1 47 2667 1235 NO2_5VX1 $T=-211560 -295680 1 0 $X=-211990 $Y=-300800
X18302 2 1 913 1284 765 NO2_5VX1 $T=-206520 -412160 0 0 $X=-206950 $Y=-412800
X18303 2 1 913 2671 1283 NO2_5VX1 $T=-206520 -403200 0 0 $X=-206950 $Y=-403840
X18304 2 1 1264 1263 33 NO2_5VX1 $T=-203720 -322560 1 180 $X=-206950 $Y=-323200
X18305 2 1 171 2673 1264 NO2_5VX1 $T=-203720 -340480 0 0 $X=-204150 $Y=-341120
X18306 2 1 921 1297 913 NO2_5VX1 $T=-195880 -403200 1 0 $X=-196310 $Y=-408320
X18307 2 1 1288 1301 2677 NO2_5VX1 $T=-194200 -403200 0 0 $X=-194630 $Y=-403840
X18308 2 1 1301 1316 1297 NO2_5VX1 $T=-189160 -403200 0 0 $X=-189590 $Y=-403840
X18309 2 1 49 2678 47 NO2_5VX1 $T=-186360 -349440 1 180 $X=-189590 $Y=-350080
X18310 2 1 956 1306 922 NO2_5VX1 $T=-184680 -385280 0 180 $X=-187910 $Y=-390400
X18311 2 1 2688 2692 922 NO2_5VX1 $T=-180200 -394240 0 0 $X=-180630 $Y=-394880
X18312 2 1 51 1349 49 NO2_5VX1 $T=-165640 -367360 0 0 $X=-166070 $Y=-368000
X18313 2 1 290 295 285 NO2_5VX1 $T=-32920 -295680 0 180 $X=-36150 $Y=-300800
X18314 2 1 285 281 277 NO2_5VX1 $T=-31240 -286720 0 180 $X=-34470 $Y=-291840
X18315 2 1 304 1648 290 NO2_5VX1 $T=-25640 -313600 0 180 $X=-28870 $Y=-318720
X18316 2 1 801 1682 1580 NO2_5VX1 $T=-23960 -367360 1 180 $X=-27190 $Y=-368000
X18317 2 1 795 1687 304 NO2_5VX1 $T=-20600 -304640 0 180 $X=-23830 $Y=-309760
X18318 2 1 1717 1709 1707 NO2_5VX1 $T=-12200 -394240 1 180 $X=-15430 $Y=-394880
X18319 2 1 1704 1693 795 NO2_5VX1 $T=-11640 -367360 0 180 $X=-14870 $Y=-372480
X18320 2 1 2848 3307 315 NO2_5VX1 $T=-7720 -322560 1 180 $X=-10950 $Y=-323200
X18321 2 1 1691 1722 795 NO2_5VX1 $T=-4920 -304640 0 180 $X=-8150 $Y=-309760
X18322 2 1 2880 1793 1795 NO2_5VX1 $T=18040 -367360 1 0 $X=17610 $Y=-372480
X18323 2 1 801 1785 1691 NO2_5VX1 $T=19720 -349440 1 0 $X=19290 $Y=-354560
X18324 2 1 1810 1855 1808 NO2_5VX1 $T=37640 -349440 0 0 $X=37210 $Y=-350080
X18325 2 1 290 355 277 NO2_5VX1 $T=52200 -286720 0 180 $X=48970 $Y=-291840
X18326 2 1 2919 1890 2922 NO2_5VX1 $T=49960 -394240 0 0 $X=49530 $Y=-394880
X18327 2 1 795 1885 290 NO2_5VX1 $T=50520 -304640 1 0 $X=50090 $Y=-309760
X18328 2 1 304 348 285 NO2_5VX1 $T=57240 -286720 0 180 $X=54010 $Y=-291840
X18329 2 1 1860 1852 801 NO2_5VX1 $T=59480 -358400 1 180 $X=56250 $Y=-359040
X18330 2 1 1810 1964 804 NO2_5VX1 $T=78520 -394240 0 0 $X=78090 $Y=-394880
X18331 2 1 1810 1983 304 NO2_5VX1 $T=86920 -376320 1 0 $X=86490 $Y=-381440
X18332 2 1 1981 1989 1969 NO2_5VX1 $T=93640 -385280 0 0 $X=93210 $Y=-385920
X18333 2 1 268 2003 264 NO2_5VX1 $T=100360 -313600 0 0 $X=99930 $Y=-314240
X18334 2 1 2002 2982 405 NO2_5VX1 $T=100920 -295680 1 0 $X=100490 $Y=-300800
X18335 2 1 405 2980 374 NO2_5VX1 $T=101480 -295680 0 0 $X=101050 $Y=-296320
X18336 2 1 804 2010 795 NO2_5VX1 $T=109320 -403200 0 180 $X=106090 $Y=-408320
X18337 2 1 264 2991 258 NO2_5VX1 $T=114920 -304640 0 180 $X=111690 $Y=-309760
X18338 2 1 274 2028 268 NO2_5VX1 $T=113240 -340480 1 0 $X=112810 $Y=-345600
X18339 2 1 258 2997 265 NO2_5VX1 $T=119400 -295680 1 180 $X=116170 $Y=-296320
X18340 2 1 265 2051 267 NO2_5VX1 $T=121640 -277760 0 0 $X=121210 $Y=-278400
X18341 2 1 2219 816 514 NO2_5VX1 $T=258840 -313600 0 180 $X=255610 $Y=-318720
X18342 2 1 2278 2276 2306 NO2_5VX1 $T=262200 -313600 1 0 $X=261770 $Y=-318720
X18343 2 1 516 2309 517 NO2_5VX1 $T=263880 -304640 1 0 $X=263450 $Y=-309760
X18344 2 1 2312 2278 3081 NO2_5VX1 $T=272280 -322560 1 180 $X=269050 $Y=-323200
X18345 2 1 525 818 516 NO2_5VX1 $T=270600 -340480 0 0 $X=270170 $Y=-341120
X18346 2 1 517 3088 510 NO2_5VX1 $T=281800 -304640 0 180 $X=278570 $Y=-309760
X18347 2 1 2210 2306 2219 NO2_5VX1 $T=286280 -322560 1 180 $X=283050 $Y=-323200
X18348 2 1 525 2363 517 NO2_5VX1 $T=331080 -331520 1 0 $X=330650 $Y=-336640
X18349 2 1 549 2361 555 NO2_5VX1 $T=343960 -286720 1 180 $X=340730 $Y=-287360
X18350 2 1 2400 2448 692 NO2_5VX1 $T=437480 -340480 0 0 $X=437050 $Y=-341120
X18351 2 1 514 729 693 NO2_5VX1 $T=468280 -286720 1 180 $X=465050 $Y=-287360
X18352 2 1 820 2470 514 NO2_5VX1 $T=472760 -313600 0 0 $X=472330 $Y=-314240
X18353 2 1 2400 821 692 NO2_5VX1 $T=490680 -286720 1 0 $X=490250 $Y=-291840
X18354 2 1 51 2520 2507 NA2I1_5VX1 $T=-377880 -358400 0 180 $X=-382230 $Y=-363520
X18355 2 1 913 955 945 NA2I1_5VX1 $T=-316280 -376320 0 180 $X=-320630 $Y=-381440
X18356 2 1 913 767 1003 NA2I1_5VX1 $T=-298360 -376320 0 180 $X=-302710 $Y=-381440
X18357 2 1 2671 1278 1267 NA2I1_5VX1 $T=-203720 -394240 0 0 $X=-204150 $Y=-394880
X18358 2 1 2692 1319 2676 NA2I1_5VX1 $T=-176840 -376320 0 180 $X=-181190 $Y=-381440
X18359 2 1 1580 1718 1692 NA2I1_5VX1 $T=-10520 -322560 0 180 $X=-14870 $Y=-327680
X18360 2 1 801 1534 1774 NA2I1_5VX1 $T=2920 -394240 0 0 $X=2490 $Y=-394880
X18361 2 1 304 794 2887 NA2I1_5VX1 $T=22520 -313600 0 0 $X=22090 $Y=-314240
X18362 2 1 2886 795 1886 NA2I1_5VX1 $T=29240 -331520 1 0 $X=28810 $Y=-336640
X18363 2 1 1983 1970 1993 NA2I1_5VX1 $T=92520 -367360 1 0 $X=92090 $Y=-372480
X18364 2 1 1989 1952 1972 NA2I1_5VX1 $T=98120 -385280 1 0 $X=97690 $Y=-390400
X18365 2 1 804 304 2981 NA2I1_5VX1 $T=100360 -358400 0 0 $X=99930 $Y=-359040
X18366 2 1 2219 2453 2456 NA2I1_5VX1 $T=459880 -322560 0 180 $X=455530 $Y=-327680
X18367 2 1 2219 820 2471 NA2I1_5VX1 $T=477800 -322560 0 0 $X=477370 $Y=-323200
X18368 2 1 2622 2621 3224 1074 1111 AND4_5VX1 $T=-264760 -349440 0 0 $X=-265190 $Y=-350080
X18369 2 1 2629 1098 2625 1088 2633 AND4_5VX1 $T=-261400 -304640 0 0 $X=-261830 $Y=-305280
X18370 2 1 1169 2649 1147 1111 1158 AND4_5VX1 $T=-239000 -322560 1 180 $X=-245030 $Y=-323200
X18371 2 1 2783 1542 1557 1530 1516 AND4_5VX1 $T=-78840 -403200 0 180 $X=-84870 $Y=-408320
X18372 2 1 1752 2858 2854 1742 1576 AND4_5VX1 $T=120 -340480 1 180 $X=-5910 $Y=-341120
X18373 2 1 2867 2874 1777 1780 1742 AND4_5VX1 $T=10760 -421120 0 0 $X=10330 $Y=-421760
X18374 2 1 3138 3136 2381 3247 675 AND4_5VX1 $T=355720 -286720 1 180 $X=349690 $Y=-287360
X18375 2 1 2388 3146 3142 3140 2381 AND4_5VX1 $T=365240 -295680 1 180 $X=359210 $Y=-296320
X18376 2 1 3171 2419 3169 2420 700 AND4_5VX1 $T=411720 -295680 0 180 $X=405690 $Y=-300800
X18377 2 1 995 768 1002 1001 ON21_5VX1 $T=-307880 -358400 1 0 $X=-308310 $Y=-363520
X18378 2 1 1134 1164 2651 1193 ON21_5VX1 $T=-237320 -412160 0 0 $X=-237750 $Y=-412800
X18379 2 1 2671 1280 1285 1278 ON21_5VX1 $T=-202040 -385280 1 0 $X=-202470 $Y=-390400
X18380 2 1 1724 1741 313 1774 ON21_5VX1 $T=680 -376320 0 180 $X=-3670 $Y=-381440
X18381 2 1 765 945 2567 947 NO22_5VX1 $T=-326920 -376320 0 0 $X=-327350 $Y=-376960
X18382 2 1 2569 910 2564 947 NO22_5VX1 $T=-321880 -358400 0 180 $X=-327350 $Y=-363520
X18383 2 1 2566 972 971 968 NO22_5VX1 $T=-320200 -349440 1 0 $X=-320630 $Y=-354560
X18384 2 1 2568 767 988 962 NO22_5VX1 $T=-306760 -340480 1 180 $X=-312230 $Y=-341120
X18385 2 1 1008 2585 2580 97 NO22_5VX1 $T=-300040 -295680 0 180 $X=-305510 $Y=-300800
X18386 2 1 1008 998 1023 97 NO22_5VX1 $T=-297800 -304640 0 0 $X=-298230 $Y=-305280
X18387 2 1 1027 1013 2601 98 NO22_5VX1 $T=-292200 -295680 0 0 $X=-292630 $Y=-296320
X18388 2 1 1027 1018 1040 98 NO22_5VX1 $T=-291640 -295680 1 0 $X=-292070 $Y=-300800
X18389 2 1 1066 1019 121 1043 NO22_5VX1 $T=-281560 -295680 0 180 $X=-287030 $Y=-300800
X18390 2 1 1066 1064 1079 1043 NO22_5VX1 $T=-278200 -304640 1 0 $X=-278630 $Y=-309760
X18391 2 1 1090 1130 1097 1096 NO22_5VX1 $T=-262520 -403200 1 180 $X=-267990 $Y=-403840
X18392 2 1 1130 1125 2631 1096 NO22_5VX1 $T=-254680 -403200 0 180 $X=-260150 $Y=-408320
X18393 2 1 1136 1140 2639 1154 NO22_5VX1 $T=-253000 -358400 1 0 $X=-253430 $Y=-363520
X18394 2 1 1136 1165 2648 1154 NO22_5VX1 $T=-240680 -358400 1 180 $X=-246150 $Y=-359040
X18395 2 1 157 1107 1141 151 NO22_5VX1 $T=-240680 -304640 0 180 $X=-246150 $Y=-309760
X18396 2 1 1136 1174 1184 1154 NO22_5VX1 $T=-236760 -358400 0 0 $X=-237190 $Y=-359040
X18397 2 1 2654 1180 1173 773 NO22_5VX1 $T=-232280 -286720 1 0 $X=-232710 $Y=-291840
X18398 2 1 157 1200 1277 151 NO22_5VX1 $T=-225560 -286720 1 0 $X=-225990 $Y=-291840
X18399 2 1 1238 49 176 1225 NO22_5VX1 $T=-216600 -304640 0 180 $X=-222070 $Y=-309760
X18400 2 1 1246 47 179 1236 NO22_5VX1 $T=-213800 -295680 0 180 $X=-219270 $Y=-300800
X18401 2 1 2667 1271 2670 1263 NO22_5VX1 $T=-206520 -295680 1 0 $X=-206950 $Y=-300800
X18402 2 1 1246 1279 1356 1236 NO22_5VX1 $T=-202600 -313600 1 0 $X=-203030 $Y=-318720
X18403 2 1 2673 1289 1360 2678 NO22_5VX1 $T=-199800 -349440 1 0 $X=-200230 $Y=-354560
X18404 2 1 1291 1301 1281 1284 NO22_5VX1 $T=-194200 -412160 0 180 $X=-199670 $Y=-417280
X18405 2 1 2673 55 191 2678 NO22_5VX1 $T=-198680 -340480 0 0 $X=-199110 $Y=-341120
X18406 2 1 1238 776 1354 1225 NO22_5VX1 $T=-191960 -340480 0 0 $X=-192390 $Y=-341120
X18407 2 1 1641 1637 2810 281 NO22_5VX1 $T=-45240 -358400 1 180 $X=-50710 $Y=-359040
X18408 2 1 1641 1638 1586 281 NO22_5VX1 $T=-44120 -358400 0 180 $X=-49590 $Y=-363520
X18409 2 1 1672 1671 1649 295 NO22_5VX1 $T=-31800 -349440 0 180 $X=-37270 $Y=-354560
X18410 2 1 2828 1674 1650 1648 NO22_5VX1 $T=-29560 -349440 1 180 $X=-35030 $Y=-350080
X18411 2 1 2835 1697 1667 1682 NO22_5VX1 $T=-22840 -385280 0 180 $X=-28310 $Y=-390400
X18412 2 1 2845 1580 1664 1687 NO22_5VX1 $T=-18920 -322560 1 180 $X=-24390 $Y=-323200
X18413 2 1 1711 1670 1638 1693 NO22_5VX1 $T=-11640 -376320 1 180 $X=-17110 $Y=-376960
X18414 2 1 1795 1744 1811 3306 NO22_5VX1 $T=29800 -376320 0 180 $X=24330 $Y=-381440
X18415 2 1 1811 2895 2894 2889 NO22_5VX1 $T=33720 -385280 0 180 $X=28250 $Y=-390400
X18416 2 1 1845 1823 2881 348 NO22_5VX1 $T=37640 -313600 0 180 $X=32170 $Y=-318720
X18417 2 1 797 1811 2901 1778 NO22_5VX1 $T=41000 -385280 0 180 $X=35530 $Y=-390400
X18418 2 1 1866 1864 1865 355 NO22_5VX1 $T=42120 -295680 1 0 $X=41690 $Y=-300800
X18419 2 1 1810 1880 1887 1852 NO22_5VX1 $T=49400 -349440 1 0 $X=48970 $Y=-354560
X18420 2 1 1845 1887 2926 348 NO22_5VX1 $T=51640 -331520 0 0 $X=51210 $Y=-332160
X18421 2 1 2982 2009 2011 2003 NO22_5VX1 $T=103720 -322560 0 0 $X=103290 $Y=-323200
X18422 2 1 2982 277 410 2003 NO22_5VX1 $T=104280 -304640 1 0 $X=103850 $Y=-309760
X18423 2 1 2980 1990 2012 2991 NO22_5VX1 $T=104840 -313600 0 0 $X=104410 $Y=-314240
X18424 2 1 2980 274 411 2991 NO22_5VX1 $T=105400 -295680 1 0 $X=104970 $Y=-300800
X18425 2 1 414 268 418 2997 NO22_5VX1 $T=112680 -286720 0 0 $X=112250 $Y=-287360
X18426 2 1 414 2015 3300 2997 NO22_5VX1 $T=113240 -295680 1 0 $X=112810 $Y=-300800
X18427 2 1 417 264 421 2051 NO22_5VX1 $T=114360 -277760 0 0 $X=113930 $Y=-278400
X18428 2 1 417 2031 2999 2051 NO22_5VX1 $T=119960 -277760 1 0 $X=119530 $Y=-282880
X18429 2 1 578 2266 2254 570 NO22_5VX1 $T=243160 -277760 0 180 $X=237690 $Y=-282880
X18430 2 1 2290 817 2280 816 NO22_5VX1 $T=262200 -304640 0 180 $X=256730 $Y=-309760
X18431 2 1 2316 2321 2279 3088 NO22_5VX1 $T=280120 -313600 1 180 $X=274650 $Y=-314240
X18432 2 1 2321 525 617 3088 NO22_5VX1 $T=281800 -304640 1 180 $X=276330 $Y=-305280
X18433 2 1 3185 2442 2431 2448 NO22_5VX1 $T=435240 -331520 0 180 $X=429770 $Y=-336640
X18434 2 1 3185 2447 714 2448 NO22_5VX1 $T=437480 -331520 1 0 $X=437050 $Y=-336640
X18435 2 1 725 2453 3305 724 NO22_5VX1 $T=457080 -286720 1 180 $X=451610 $Y=-287360
X18436 2 1 725 2400 2454 724 NO22_5VX1 $T=463240 -286720 1 180 $X=457770 $Y=-287360
X18437 2 1 3200 2453 2467 729 NO22_5VX1 $T=468280 -286720 0 180 $X=462810 $Y=-291840
X18438 2 1 3202 693 732 2470 NO22_5VX1 $T=470520 -295680 0 0 $X=470090 $Y=-296320
X18439 2 1 514 2471 3205 2470 NO22_5VX1 $T=477800 -313600 1 0 $X=477370 $Y=-318720
X18440 2 1 2536 914 2539 918 AN21_5VX1 $T=-344840 -349440 1 0 $X=-345270 $Y=-354560
X18441 2 1 914 942 2545 918 AN21_5VX1 $T=-339800 -349440 1 0 $X=-340230 $Y=-354560
X18442 2 1 2677 2679 1304 1306 AN21_5VX1 $T=-193080 -385280 1 0 $X=-193510 $Y=-390400
X18443 2 1 921 2679 1317 1306 AN21_5VX1 $T=-190280 -394240 0 0 $X=-190710 $Y=-394880
X18444 2 1 1319 1285 3290 2692 AN21_5VX1 $T=-183000 -385280 0 0 $X=-183430 $Y=-385920
X18445 2 1 1324 1352 1192 1349 AN21_5VX1 $T=-167320 -367360 0 180 $X=-171670 $Y=-372480
X18446 2 1 1321 1352 1371 1349 AN21_5VX1 $T=-166200 -367360 1 0 $X=-166630 $Y=-372480
X18447 2 1 1659 305 1657 303 AN21_5VX1 $T=-31240 -286720 1 180 $X=-35590 $Y=-287360
X18448 2 1 1677 1689 1637 1693 AN21_5VX1 $T=-27320 -376320 0 0 $X=-27750 $Y=-376960
X18449 2 1 2903 794 1864 1855 AN21_5VX1 $T=39320 -340480 1 0 $X=38890 $Y=-345600
X18450 2 1 2903 3237 2912 1855 AN21_5VX1 $T=42120 -349440 0 0 $X=41690 $Y=-350080
X18451 2 1 1867 2913 1863 355 AN21_5VX1 $T=48280 -304640 0 180 $X=43930 $Y=-309760
X18452 2 1 799 1886 1874 1885 AN21_5VX1 $T=56120 -340480 1 180 $X=51770 $Y=-341120
X18453 2 1 1534 1960 1963 1964 AN21_5VX1 $T=83000 -394240 0 0 $X=82570 $Y=-394880
X18454 2 1 1969 1960 2021 1964 AN21_5VX1 $T=83560 -385280 1 0 $X=83130 $Y=-390400
X18455 2 1 1995 1970 1978 1983 AN21_5VX1 $T=87480 -367360 1 0 $X=87050 $Y=-372480
X18456 2 1 1550 1970 1992 1983 AN21_5VX1 $T=90840 -376320 0 0 $X=90410 $Y=-376960
X18457 2 1 1994 2006 2983 2010 AN21_5VX1 $T=102600 -394240 1 0 $X=102170 $Y=-399360
X18458 2 1 2024 2006 2987 2010 AN21_5VX1 $T=114920 -403200 0 180 $X=110570 $Y=-408320
X18459 2 1 2020 2026 2041 2028 AN21_5VX1 $T=113240 -349440 0 0 $X=112810 $Y=-350080
X18460 2 1 2027 2026 422 2028 AN21_5VX1 $T=121640 -349440 1 180 $X=117290 $Y=-350080
X18461 2 1 2297 3083 3084 2309 AN21_5VX1 $T=268360 -304640 1 0 $X=267930 $Y=-309760
X18462 2 1 2276 3083 2316 2309 AN21_5VX1 $T=268920 -313600 0 0 $X=268490 $Y=-314240
X18463 2 1 3081 2315 2298 818 AN21_5VX1 $T=270040 -331520 0 0 $X=269610 $Y=-332160
X18464 2 1 2358 2365 3116 2363 AN21_5VX1 $T=329960 -331520 1 180 $X=325610 $Y=-332160
X18465 2 1 2352 3125 670 2361 AN21_5VX1 $T=333320 -286720 0 0 $X=332890 $Y=-287360
X18466 2 1 2210 2365 3123 2363 AN21_5VX1 $T=340600 -322560 0 180 $X=336250 $Y=-327680
X18467 2 1 3246 3125 2360 2361 AN21_5VX1 $T=341160 -286720 1 180 $X=336810 $Y=-287360
X18468 2 1 2474 2478 2486 821 AN21_5VX1 $T=489560 -295680 0 0 $X=489130 $Y=-296320
X18469 2 1 2478 3210 741 821 AN21_5VX1 $T=490120 -286720 0 0 $X=489690 $Y=-287360
X18470 2 1 921 2658 1211 1193 956 ON211_5VX1 $T=-221080 -403200 1 180 $X=-226550 $Y=-403840
X18471 2 1 1808 1867 795 1861 2916 ON211_5VX1 $T=42120 -331520 0 0 $X=41690 $Y=-332160
X18472 2 1 1550 2959 290 304 1534 ON211_5VX1 $T=85240 -367360 1 180 $X=79770 $Y=-368000
X18473 2 1 2219 3094 524 510 2210 ON211_5VX1 $T=288520 -304640 0 180 $X=283050 $Y=-309760
X18474 2 1 2210 3100 2325 2334 525 ON211_5VX1 $T=294120 -322560 0 0 $X=293690 $Y=-323200
X18475 2 1 2400 716 693 2445 2456 ON211_5VX1 $T=439720 -322560 0 0 $X=439290 $Y=-323200
X18476 2 1 1193 1160 1194 1135 NO3I2_5VX1 $T=-226680 -412160 1 180 $X=-231590 $Y=-412800
X18477 2 1 2896 1803 1830 2900 NO3I2_5VX1 $T=31480 -403200 0 0 $X=31050 $Y=-403840
X18478 2 1 2338 2340 2346 3104 NO3I2_5VX1 $T=304200 -322560 1 0 $X=303770 $Y=-327680
X18479 2 1 2334 2341 3106 2345 NO3I2_5VX1 $T=307560 -322560 0 0 $X=307130 $Y=-323200
X18480 2 1 1285 2676 1321 EN2_5VX0 $T=-188600 -376320 1 0 $X=-189030 $Y=-381440
X18481 2 1 1328 1317 2700 EN2_5VX0 $T=-175720 -412160 0 0 $X=-176150 $Y=-412800
X18482 2 1 922 777 1341 EN2_5VX0 $T=-162840 -403200 0 180 $X=-169430 $Y=-408320
X18483 2 1 801 1580 1729 EN2_5VX0 $T=-19480 -358400 1 0 $X=-19910 $Y=-363520
X18484 2 1 1550 801 2844 EN2_5VX0 $T=-9400 -367360 1 180 $X=-15990 $Y=-368000
X18485 2 1 1731 264 3219 EN2_5VX0 $T=-6040 -313600 1 180 $X=-12630 $Y=-314240
X18486 2 1 516 2260 2274 EN2_5VX0 $T=242600 -331520 1 0 $X=242170 $Y=-336640
X18487 2 1 517 2272 2302 EN2_5VX0 $T=250440 -322560 0 0 $X=250010 $Y=-323200
X18488 2 1 2219 514 2328 EN2_5VX0 $T=287960 -313600 0 0 $X=287530 $Y=-314240
X18489 2 1 514 525 3096 EN2_5VX0 $T=300840 -304640 1 180 $X=294250 $Y=-305280
X18490 2 1 3112 517 3120 EN2_5VX0 $T=327160 -322560 1 0 $X=326730 $Y=-327680
X18491 2 1 915 2561 932 947 NO3I1_5VX1 $T=-326360 -349440 1 180 $X=-331830 $Y=-350080
X18492 2 1 1132 1189 1209 771 NO3I1_5VX1 $T=-233960 -385280 1 0 $X=-234390 $Y=-390400
X18493 2 1 1972 804 808 EO2_5VX0 $T=108200 -394240 1 0 $X=107770 $Y=-399360
X18494 2 1 913 921 945 960 NA22_5VX1 $T=-312360 -385280 0 180 $X=-317270 $Y=-390400
X18495 2 1 290 1550 2959 2951 NA22_5VX1 $T=74600 -358400 1 0 $X=74170 $Y=-363520
X18496 2 1 2981 1972 1997 2020 NA22_5VX1 $T=106520 -358400 0 0 $X=106090 $Y=-359040
X18497 2 1 524 2219 3094 3092 NA22_5VX1 $T=288520 -304640 1 180 $X=283610 $Y=-305280
X18498 2 1 2219 2400 2471 3208 NA22_5VX1 $T=483960 -322560 1 0 $X=483530 $Y=-327680
X18499 2 1 1852 1823 2902 1785 NO3_5VX1 $T=39880 -349440 0 180 $X=35530 $Y=-354560
X18500 2 1 2470 734 739 3207 NO3_5VX1 $T=480040 -277760 0 0 $X=479610 $Y=-278400
X18501 2 1 956 921 1003 769 2598 OA211_5VX1 $T=-277640 -367360 1 180 $X=-283670 $Y=-368000
X18502 2 1 1390 1391 3230 1402 AND3_5VX1 $T=-156120 -412160 0 0 $X=-156550 $Y=-412800
X18503 2 1 790 2869 1774 1778 AND3_5VX1 $T=6840 -385280 1 0 $X=6410 $Y=-390400
X18504 2 1 2057 3008 2062 2076 AND3_5VX1 $T=132280 -412160 0 0 $X=131850 $Y=-412800
X18505 2 1 3067 2264 3070 2214 AND3_5VX1 $T=242600 -358400 1 180 $X=237690 $Y=-359040
X18506 2 1 1392 1398 2714 49 MU2_5VX4 $T=-150520 -286720 0 180 $X=-161590 $Y=-291840
X18507 2 1 55 1394 1421 1412 HA_5VX4 $T=-159480 -313600 1 0 $X=-159910 $Y=-318720
X18508 2 1 51 1401 1412 1392 HA_5VX4 $T=-157240 -304640 0 0 $X=-157670 $Y=-305280
X18509 2 1 894 1389 1431 1394 HA_5VX4 $T=-156120 -322560 1 0 $X=-156550 $Y=-327680
X18510 2 1 795 1739 1694 2852 HA_5VX4 $T=6280 -313600 0 180 $X=-9830 $Y=-318720
X18511 2 1 304 1768 2852 2859 HA_5VX4 $T=11320 -304640 1 180 $X=-4790 $Y=-305280
X18512 2 1 285 325 332 1773 HA_5VX4 $T=-3800 -277760 0 0 $X=-4230 $Y=-278400
X18513 2 1 290 2871 2859 327 HA_5VX4 $T=15800 -286720 0 180 $X=-310 $Y=-291840
X18514 2 1 510 2181 2177 3048 HA_5VX4 $T=210120 -304640 0 180 $X=194010 $Y=-309760
X18515 2 1 511 2202 2178 496 HA_5VX4 $T=210120 -277760 0 180 $X=194010 $Y=-282880
X18516 2 1 517 3301 2184 2177 HA_5VX4 $T=212360 -322560 1 180 $X=196250 $Y=-323200
X18517 2 1 524 2150 3048 2178 HA_5VX4 $T=214600 -286720 0 180 $X=198490 $Y=-291840
X18518 2 1 922 1381 2721 1389 HA_5VX2 $T=-162840 -331520 0 0 $X=-163270 $Y=-332160
X18519 2 1 956 1761 2739 2721 HA_5VX2 $T=-151640 -331520 0 0 $X=-152070 $Y=-332160
X18520 2 1 765 1427 2748 2739 HA_5VX2 $T=-145480 -331520 1 0 $X=-145910 $Y=-336640
X18521 2 1 913 1438 1461 2748 HA_5VX2 $T=-140440 -331520 0 0 $X=-140870 $Y=-332160
X18522 2 1 1534 2779 2775 2777 HA_5VX2 $T=-80520 -394240 0 180 $X=-92150 $Y=-399360
X18523 2 1 801 1555 782 2781 HA_5VX2 $T=-73800 -385280 1 180 $X=-85430 $Y=-385920
X18524 2 1 1580 1535 2781 789 HA_5VX2 $T=-68200 -358400 0 180 $X=-79830 $Y=-363520
X18525 2 1 1691 1700 789 1694 HA_5VX2 $T=-18360 -349440 1 180 $X=-29990 $Y=-350080
X18526 2 1 921 1779 2077 1438 HA_5VX2 $T=10200 -331520 1 0 $X=9770 $Y=-336640
X18527 2 1 2210 2207 2179 3050 HA_5VX2 $T=210120 -358400 0 180 $X=198490 $Y=-363520
X18528 2 1 525 2209 2190 2200 HA_5VX2 $T=210680 -340480 0 180 $X=199050 $Y=-345600
X18529 2 1 516 2176 2200 2184 HA_5VX2 $T=210680 -331520 0 180 $X=199050 $Y=-336640
X18530 2 1 514 3054 2194 2190 HA_5VX2 $T=211240 -349440 0 180 $X=199610 $Y=-354560
X18531 2 1 2219 2211 3050 2194 HA_5VX2 $T=213480 -358400 1 180 $X=201850 $Y=-359040
X18532 2 1 826 14 2495 DFRQ_5VX1 $T=-438360 -286720 1 0 $X=-438790 $Y=-291840
X18533 2 1 3216 14 17 DFRQ_5VX1 $T=-438360 -277760 0 0 $X=-438790 $Y=-278400
X18534 2 1 2642 153 1172 DFRQ_5VX1 $T=-253000 -286720 1 0 $X=-253430 $Y=-291840
X18535 2 1 2645 153 1313 DFRQ_5VX1 $T=-251320 -304640 0 0 $X=-251750 $Y=-305280
X18536 2 1 149 153 1178 DFRQ_5VX1 $T=-251320 -277760 0 0 $X=-251750 $Y=-278400
X18537 2 1 1254 204 1348 DFRQ_5VX1 $T=-185800 -286720 0 0 $X=-186230 $Y=-287360
X18538 2 1 1113 204 1375 DFRQ_5VX1 $T=-181880 -295680 0 0 $X=-182310 $Y=-296320
X18539 2 1 1076 204 1357 DFRQ_5VX1 $T=-181320 -295680 1 0 $X=-181750 $Y=-300800
X18540 2 1 1415 1447 2745 DFRQ_5VX1 $T=-149960 -304640 1 0 $X=-150390 $Y=-309760
X18541 2 1 2730 229 1443 DFRQ_5VX1 $T=-149400 -277760 1 0 $X=-149830 $Y=-282880
X18542 2 1 1433 229 1548 DFRQ_5VX1 $T=-145480 -295680 0 0 $X=-145910 $Y=-296320
X18543 2 1 2742 1447 1460 DFRQ_5VX1 $T=-141560 -322560 0 0 $X=-141990 $Y=-323200
X18544 2 1 2751 1479 1435 DFRQ_5VX1 $T=-126440 -394240 1 180 $X=-141430 $Y=-394880
X18545 2 1 2743 1455 1463 DFRQ_5VX1 $T=-141000 -376320 1 0 $X=-141430 $Y=-381440
X18546 2 1 780 1455 1464 DFRQ_5VX1 $T=-141000 -367360 1 0 $X=-141430 $Y=-372480
X18547 2 1 2746 1479 2753 DFRQ_5VX1 $T=-139880 -412160 0 0 $X=-140310 $Y=-412800
X18548 2 1 2750 1468 2759 DFRQ_5VX1 $T=-134840 -340480 1 0 $X=-135270 $Y=-345600
X18549 2 1 1453 1455 781 DFRQ_5VX1 $T=-132600 -367360 0 0 $X=-133030 $Y=-368000
X18550 2 1 1466 1455 2747 DFRQ_5VX1 $T=-115800 -358400 1 180 $X=-130790 $Y=-359040
X18551 2 1 1456 1447 1480 DFRQ_5VX1 $T=-130360 -331520 1 0 $X=-130790 $Y=-336640
X18552 2 1 1292 1447 2754 DFRQ_5VX1 $T=-114120 -340480 1 180 $X=-129110 $Y=-341120
X18553 2 1 1257 1447 1494 DFRQ_5VX1 $T=-128120 -313600 1 0 $X=-128550 $Y=-318720
X18554 2 1 1215 1479 1382 DFRQ_5VX1 $T=-127560 -394240 1 0 $X=-127990 $Y=-399360
X18555 2 1 1157 1479 1423 DFRQ_5VX1 $T=-127000 -403200 1 0 $X=-127430 $Y=-408320
X18556 2 1 1473 1479 1483 DFRQ_5VX1 $T=-126440 -394240 0 0 $X=-126870 $Y=-394880
X18557 2 1 1089 1479 1471 DFRQ_5VX1 $T=-126440 -376320 1 0 $X=-126870 $Y=-381440
X18558 2 1 1287 1455 1476 DFRQ_5VX1 $T=-126440 -367360 1 0 $X=-126870 $Y=-372480
X18559 2 1 1138 1455 1495 DFRQ_5VX1 $T=-126440 -358400 1 0 $X=-126870 $Y=-363520
X18560 2 1 1129 1468 1491 DFRQ_5VX1 $T=-126440 -349440 0 0 $X=-126870 $Y=-350080
X18561 2 1 2763 1447 2762 DFRQ_5VX1 $T=-126440 -304640 0 0 $X=-126870 $Y=-305280
X18562 2 1 1266 229 2755 DFRQ_5VX1 $T=-111880 -286720 0 180 $X=-126870 $Y=-291840
X18563 2 1 1070 229 2761 DFRQ_5VX1 $T=-126440 -277760 1 0 $X=-126870 $Y=-282880
X18564 2 1 1519 1468 3233 DFRQ_5VX1 $T=-83320 -367360 0 180 $X=-98310 $Y=-372480
X18565 2 1 1506 1468 1513 DFRQ_5VX1 $T=-96760 -340480 1 0 $X=-97190 $Y=-345600
X18566 2 1 1509 1468 3235 DFRQ_5VX1 $T=-96200 -358400 1 0 $X=-96630 $Y=-363520
X18567 2 1 783 1468 1501 DFRQ_5VX1 $T=-81080 -349440 0 180 $X=-96070 $Y=-354560
X18568 2 1 321 318 1482 DFRQ_5VX1 $T=-440 -286720 0 180 $X=-15430 $Y=-291840
X18569 2 1 1477 318 1735 DFRQ_5VX1 $T=-12760 -277760 1 0 $X=-13190 $Y=-282880
X18570 2 1 2876 1783 2865 DFRQ_5VX1 $T=18600 -322560 1 180 $X=3610 $Y=-323200
X18571 2 1 2878 1783 1540 DFRQ_5VX1 $T=19720 -304640 0 180 $X=4730 $Y=-309760
X18572 2 1 1789 1783 1525 DFRQ_5VX1 $T=22520 -313600 1 180 $X=7530 $Y=-314240
X18573 2 1 337 1783 1467 DFRQ_5VX1 $T=23080 -277760 0 180 $X=8090 $Y=-282880
X18574 2 1 338 1783 1487 DFRQ_5VX1 $T=23640 -295680 0 180 $X=8650 $Y=-300800
X18575 2 1 3023 3021 1917 DFRQ_5VX1 $T=166440 -322560 0 180 $X=151450 $Y=-327680
X18576 2 1 2089 3021 2109 DFRQ_5VX1 $T=152440 -313600 0 0 $X=152010 $Y=-314240
X18577 2 1 3022 2165 2103 DFRQ_5VX1 $T=155240 -286720 1 0 $X=154810 $Y=-291840
X18578 2 1 2107 459 2134 DFRQ_5VX1 $T=159160 -277760 0 0 $X=158730 $Y=-278400
X18579 2 1 2106 2165 2145 DFRQ_5VX1 $T=159720 -295680 1 0 $X=159290 $Y=-300800
X18580 2 1 2136 3021 3243 DFRQ_5VX1 $T=178760 -340480 0 180 $X=163770 $Y=-345600
X18581 2 1 2140 3021 1782 DFRQ_5VX1 $T=179880 -322560 1 180 $X=164890 $Y=-323200
X18582 2 1 3034 2165 2033 DFRQ_5VX1 $T=184360 -286720 0 180 $X=169370 $Y=-291840
X18583 2 1 2151 3021 2088 DFRQ_5VX1 $T=184920 -340480 1 180 $X=169930 $Y=-341120
X18584 2 1 2138 2165 2164 DFRQ_5VX1 $T=170920 -304640 0 0 $X=170490 $Y=-305280
X18585 2 1 815 2149 2158 DFRQ_5VX1 $T=172040 -367360 1 0 $X=171610 $Y=-372480
X18586 2 1 3031 3021 2159 DFRQ_5VX1 $T=172040 -331520 1 0 $X=171610 $Y=-336640
X18587 2 1 482 459 2139 DFRQ_5VX1 $T=188280 -277760 1 180 $X=173290 $Y=-278400
X18588 2 1 2146 3021 2154 DFRQ_5VX1 $T=174280 -313600 1 0 $X=173850 $Y=-318720
X18589 2 1 3030 2149 3056 DFRQ_5VX1 $T=174840 -358400 1 0 $X=174410 $Y=-363520
X18590 2 1 3033 2149 2182 DFRQ_5VX1 $T=175400 -376320 0 0 $X=174970 $Y=-376960
X18591 2 1 2133 2149 2222 DFRQ_5VX1 $T=175400 -349440 1 0 $X=174970 $Y=-354560
X18592 2 1 2135 2149 2167 DFRQ_5VX1 $T=175960 -349440 0 0 $X=175530 $Y=-350080
X18593 2 1 3037 2149 2128 DFRQ_5VX1 $T=193320 -340480 0 180 $X=178330 $Y=-345600
X18594 2 1 3040 2165 2156 DFRQ_5VX1 $T=195560 -286720 1 180 $X=180570 $Y=-287360
X18595 2 1 2170 2165 1923 DFRQ_5VX1 $T=196680 -313600 1 180 $X=181690 $Y=-314240
X18596 2 1 2174 2165 2086 DFRQ_5VX1 $T=198920 -286720 0 180 $X=183930 $Y=-291840
X18597 2 1 2142 2149 2193 DFRQ_5VX1 $T=187720 -367360 1 0 $X=187290 $Y=-372480
X18598 2 1 2396 685 2391 DFRQ_5VX1 $T=373640 -277760 0 180 $X=358650 $Y=-282880
X18599 2 1 3159 685 3154 DFRQ_5VX1 $T=388200 -277760 0 180 $X=373210 $Y=-282880
X18600 2 1 1738 1698 IN_5VX0 $T=-6600 -331520 1 180 $X=-8710 $Y=-332160
X18601 2 1 792 1752 IN_5VX0 $T=15240 -331520 1 180 $X=13130 $Y=-332160
X18602 2 1 1699 1714 1702 3307 1715 ON22_5VX1 $T=-17240 -322560 0 0 $X=-17670 $Y=-323200
X18603 2 1 3219 289 265 1715 MU2_5VX1 $T=-19480 -313600 0 0 $X=-19910 $Y=-314240
X18604 2 1 2847 1718 1691 1744 MU2_5VX1 $T=-11080 -376320 1 0 $X=-11510 $Y=-381440
X18605 2 1 1775 1792 1805 1807 MU2_5VX1 $T=17480 -385280 1 0 $X=17050 $Y=-390400
X18606 2 1 1794 1792 1805 796 MU2_5VX1 $T=23640 -394240 0 0 $X=23210 $Y=-394880
X18607 2 1 1795 1708 304 1805 MU2_5VX1 $T=24760 -367360 1 0 $X=24330 $Y=-372480
X18608 2 1 1803 1844 2900 1833 2904 OA22_5VX1 $T=31480 -403200 1 0 $X=31050 $Y=-408320
X18609 2 1 2894 2901 796 1820 1830 OA22_5VX1 $T=34280 -394240 0 0 $X=33850 $Y=-394880
X18610 2 1 1691 801 790 OR2_5VX0 $T=-2120 -394240 0 0 $X=-2550 $Y=-394880
D0 1 2 p_dnw5 AREA=3.78021e-09 PJ=0.00246305 perimeter=0.00246305 $X=-611830 $Y=-426240 $dt=1
D1 1 2 p_dnw5 AREA=6.02124e-09 PJ=0.00247301 perimeter=0.00247301 $X=-611830 $Y=-419140 $dt=1
D2 1 2 p_dnw5 AREA=6.0537e-09 PJ=0.00246811 perimeter=0.00246811 $X=-611830 $Y=-410180 $dt=1
D3 1 2 p_dnw5 AREA=6.05804e-09 PJ=0.00246893 perimeter=0.00246893 $X=-611830 $Y=-401220 $dt=1
D4 1 2 p_dnw5 AREA=6.07289e-09 PJ=0.0024661 perimeter=0.0024661 $X=-611830 $Y=-383300 $dt=1
D5 1 2 p_dnw5 AREA=6.07701e-09 PJ=0.00246317 perimeter=0.00246317 $X=-611830 $Y=-374340 $dt=1
D6 1 2 p_dnw5 AREA=6.06995e-09 PJ=0.00246646 perimeter=0.00246646 $X=-611830 $Y=-365380 $dt=1
D7 1 2 p_dnw5 AREA=6.06942e-09 PJ=0.00246665 perimeter=0.00246665 $X=-611830 $Y=-356420 $dt=1
D8 1 2 p_dnw5 AREA=6.06805e-09 PJ=0.00246758 perimeter=0.00246758 $X=-611830 $Y=-338500 $dt=1
D9 1 2 p_dnw5 AREA=6.09325e-09 PJ=0.00246275 perimeter=0.00246275 $X=-611830 $Y=-329540 $dt=1
D10 1 2 p_dnw5 AREA=6.08855e-09 PJ=0.00246429 perimeter=0.00246429 $X=-611830 $Y=-320580 $dt=1
D11 1 2 p_dnw5 AREA=6.07589e-09 PJ=0.00246534 perimeter=0.00246534 $X=-611830 $Y=-311620 $dt=1
D12 1 2 p_dnw5 AREA=6.07359e-09 PJ=0.0024662 perimeter=0.0024662 $X=-611830 $Y=-302660 $dt=1
D13 1 2 p_dnw5 AREA=6.07394e-09 PJ=0.00246417 perimeter=0.00246417 $X=-611830 $Y=-293700 $dt=1
D14 1 2 p_dnw5 AREA=6.09276e-09 PJ=0.0024632 perimeter=0.0024632 $X=-611830 $Y=-284740 $dt=1
D15 1 2 p_dnw5 AREA=6.07357e-09 PJ=0.00246688 perimeter=0.00246688 $X=-291950 $Y=-392690 $dt=1
D16 1 2 p_dnw5 AREA=6.09046e-09 PJ=0.00246362 perimeter=0.00246362 $X=343070 $Y=-347890 $dt=1
.ends MASCO__P1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX16                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX16 vdd5! gnd! A Q
** N=5 EP=4 FDC=40
M0 5 A gnd! gnd! ne5 L=5e-07 W=8e-07 AD=2.16e-13 AS=6.008e-13 PD=1.34e-06 PS=3.52e-06 $X=660 $Y=750 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=1700 $Y=750 $dt=2
M2 5 A gnd! gnd! ne5 L=5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=2820 $Y=750 $dt=2
M3 gnd! A 5 gnd! ne5 L=5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=3860 $Y=750 $dt=2
M4 5 A gnd! gnd! ne5 L=5e-07 W=8e-07 AD=3.84e-13 AS=3.404e-13 PD=2.56e-06 PS=1.86e-06 $X=4980 $Y=750 $dt=2
M5 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=4.224e-13 PD=1.86e-06 PS=2.72e-06 $X=8300 $Y=670 $dt=2
M6 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=9420 $Y=670 $dt=2
M7 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=10460 $Y=670 $dt=2
M8 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=11580 $Y=670 $dt=2
M9 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=12620 $Y=670 $dt=2
M10 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=13740 $Y=670 $dt=2
M11 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=14780 $Y=670 $dt=2
M12 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=15900 $Y=670 $dt=2
M13 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.639e-13 AS=2.376e-13 PD=1.885e-06 PS=1.42e-06 $X=16940 $Y=670 $dt=2
M14 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.639e-13 PD=1.42e-06 PS=1.885e-06 $X=18085 $Y=670 $dt=2
M15 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=19125 $Y=670 $dt=2
M16 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=4.224e-13 AS=3.484e-13 PD=2.72e-06 PS=1.86e-06 $X=20245 $Y=670 $dt=2
M17 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=5.83087e-13 PD=1.86506e-06 PS=3.71506e-06 $X=475 $Y=2410 $dt=5
M18 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1515 $Y=2410 $dt=5
M19 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2265 $Y=2410 $dt=5
M20 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=3305 $Y=2410 $dt=5
M21 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4055 $Y=2410 $dt=5
M22 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=5095 $Y=2410 $dt=5
M23 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=5845 $Y=2410 $dt=5
M24 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.10912e-13 AS=2.43675e-13 PD=1.91506e-06 PS=1.86506e-06 $X=6885 $Y=2410 $dt=5
M25 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=3.10912e-13 PD=1.86506e-06 PS=1.91506e-06 $X=7675 $Y=2410 $dt=5
M26 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.79563e-13 AS=2.46937e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8715 $Y=2410 $dt=5
M27 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.03337e-13 AS=2.79563e-13 PD=1.94506e-06 PS=1.86506e-06 $X=9465 $Y=2410 $dt=5
M28 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.28912e-13 AS=3.03337e-13 PD=1.93506e-06 PS=1.94506e-06 $X=10585 $Y=2410 $dt=5
M29 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=3.28912e-13 PD=1.86506e-06 PS=1.93506e-06 $X=11405 $Y=2410 $dt=5
M30 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.09462e-13 AS=2.46937e-13 PD=2.29506e-06 PS=1.86506e-06 $X=12445 $Y=2410 $dt=5
M31 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=4.09462e-13 PD=1.86506e-06 PS=2.29506e-06 $X=13275 $Y=2410 $dt=5
M32 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.53462e-13 AS=2.46937e-13 PD=2.34506e-06 PS=1.86506e-06 $X=14315 $Y=2410 $dt=5
M33 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=4.53462e-13 PD=1.86506e-06 PS=2.34506e-06 $X=15195 $Y=2410 $dt=5
M34 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.79563e-13 AS=2.46937e-13 PD=1.86506e-06 PS=1.86506e-06 $X=16235 $Y=2410 $dt=5
M35 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=2.79563e-13 PD=1.86506e-06 PS=1.86506e-06 $X=16985 $Y=2410 $dt=5
M36 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.79563e-13 AS=2.46937e-13 PD=1.86506e-06 PS=1.86506e-06 $X=18025 $Y=2410 $dt=5
M37 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.46937e-13 AS=2.79563e-13 PD=1.86506e-06 PS=1.86506e-06 $X=18775 $Y=2410 $dt=5
M38 vdd5! 5 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=4.75463e-13 AS=2.46937e-13 PD=2.37006e-06 PS=1.86506e-06 $X=19815 $Y=2410 $dt=5
M39 Q 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=5.43037e-13 AS=4.75463e-13 PD=3.69506e-06 PS=2.37006e-06 $X=20720 $Y=2410 $dt=5
.ends BU_5VX16

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX16                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX16 vdd5! gnd! A Q
** N=6 EP=4 FDC=40
M0 5 A gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=1.782e-13 AS=3.168e-13 PD=1.2e-06 PS=2.28e-06 $X=620 $Y=720 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=6.6e-07 AD=1.91001e-13 AS=1.782e-13 PD=1.21369e-06 PS=1.2e-06 $X=1660 $Y=720 $dt=2
M2 6 5 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=2.40199e-13 PD=1.37e-06 PS=1.52631e-06 $X=2700 $Y=720 $dt=2
M3 gnd! 5 6 gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=3740 $Y=720 $dt=2
M4 6 5 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=3.984e-13 AS=3.434e-13 PD=2.62e-06 PS=1.86e-06 $X=4860 $Y=720 $dt=2
M5 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=3.984e-13 PD=1.86e-06 PS=2.62e-06 $X=6600 $Y=720 $dt=2
M6 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=7720 $Y=720 $dt=2
M7 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=8760 $Y=720 $dt=2
M8 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=9880 $Y=720 $dt=2
M9 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=10920 $Y=720 $dt=2
M10 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=12040 $Y=720 $dt=2
M11 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=13080 $Y=720 $dt=2
M12 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=14200 $Y=720 $dt=2
M13 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=15240 $Y=720 $dt=2
M14 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=16360 $Y=720 $dt=2
M15 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=3.434e-13 AS=2.241e-13 PD=1.86e-06 PS=1.37e-06 $X=17400 $Y=720 $dt=2
M16 Q 6 gnd! gnd! ne5 L=5e-07 W=8.3e-07 AD=2.241e-13 AS=3.434e-13 PD=1.37e-06 PS=1.86e-06 $X=18520 $Y=720 $dt=2
M17 gnd! 6 Q gnd! ne5 L=5e-07 W=8.3e-07 AD=6.038e-13 AS=2.241e-13 PD=3.52e-06 PS=1.37e-06 $X=19560 $Y=720 $dt=2
M18 5 A vdd5! vdd5! pe5 L=5.00121e-07 W=1.43485e-06 AD=3.252e-13 AS=8.737e-13 PD=1.91485e-06 PS=4.56485e-06 $X=620 $Y=2410 $dt=5
M19 vdd5! A 5 vdd5! pe5 L=5.00121e-07 W=1.43485e-06 AD=3.02668e-13 AS=3.252e-13 PD=1.86705e-06 PS=1.91485e-06 $X=1660 $Y=2410 $dt=5
M20 6 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.52738e-13 AS=3.10095e-13 PD=1.86506e-06 PS=1.91286e-06 $X=2495 $Y=2410 $dt=5
M21 vdd5! 5 6 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.73763e-13 AS=2.52738e-13 PD=1.86506e-06 PS=1.86506e-06 $X=3535 $Y=2410 $dt=5
M22 6 5 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.52738e-13 AS=2.73763e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4285 $Y=2410 $dt=5
M23 vdd5! 5 6 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.34512e-13 AS=2.52738e-13 PD=1.94506e-06 PS=1.86506e-06 $X=5325 $Y=2410 $dt=5
M24 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=3.34512e-13 PD=1.86506e-06 PS=1.94506e-06 $X=6155 $Y=2410 $dt=5
M25 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=7195 $Y=2410 $dt=5
M26 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=7945 $Y=2410 $dt=5
M27 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8985 $Y=2410 $dt=5
M28 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=9735 $Y=2410 $dt=5
M29 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=10775 $Y=2410 $dt=5
M30 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=11525 $Y=2410 $dt=5
M31 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=12565 $Y=2410 $dt=5
M32 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=13315 $Y=2410 $dt=5
M33 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=14355 $Y=2410 $dt=5
M34 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=15105 $Y=2410 $dt=5
M35 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=16145 $Y=2410 $dt=5
M36 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=16895 $Y=2410 $dt=5
M37 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.821e-13 AS=2.444e-13 PD=1.86506e-06 PS=1.86506e-06 $X=17935 $Y=2410 $dt=5
M38 Q 6 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.444e-13 AS=2.821e-13 PD=1.86506e-06 PS=1.86506e-06 $X=18685 $Y=2410 $dt=5
M39 vdd5! 6 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=5.77837e-13 AS=2.444e-13 PD=3.69506e-06 PS=1.86506e-06 $X=19725 $Y=2410 $dt=5
.ends IN_5VX16

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: IN_5VX4                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt IN_5VX4 vdd5! gnd! A Q
** N=4 EP=4 FDC=7
M0 Q A gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=2
M1 gnd! A Q gnd! ne5 L=5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=1700 $Y=660 $dt=2
M2 Q A gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=3.494e-13 PD=2.74e-06 PS=1.86e-06 $X=2820 $Y=660 $dt=2
M3 Q A vdd5! vdd5! pe5 L=5.0019e-07 W=1.44935e-06 AD=3.01612e-13 AS=6.01988e-13 PD=1.89435e-06 PS=3.72435e-06 $X=525 $Y=2410 $dt=5
M4 vdd5! A Q vdd5! pe5 L=5.0019e-07 W=1.44935e-06 AD=3.05887e-13 AS=3.01612e-13 PD=1.89435e-06 PS=1.89435e-06 $X=1565 $Y=2410 $dt=5
M5 Q A vdd5! vdd5! pe5 L=5.0019e-07 W=1.44935e-06 AD=3.01612e-13 AS=3.05887e-13 PD=1.89435e-06 PS=1.89435e-06 $X=2415 $Y=2410 $dt=5
M6 vdd5! A Q vdd5! pe5 L=5.0019e-07 W=1.44935e-06 AD=6.01988e-13 AS=3.01612e-13 PD=3.72435e-06 PS=1.89435e-06 $X=3455 $Y=2410 $dt=5
.ends IN_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX4                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX4 vdd5! gnd! A Q
** N=5 EP=4 FDC=11
M0 5 A gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=2.496e-13 PD=1.06e-06 PS=2e-06 $X=620 $Y=1030 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=5.2e-07 AD=2.47074e-13 AS=1.404e-13 PD=1.38543e-06 PS=1.06e-06 $X=1660 $Y=1030 $dt=2
M2 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=4.18126e-13 PD=1.42e-06 PS=2.34457e-06 $X=2785 $Y=670 $dt=2
M3 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=3825 $Y=670 $dt=2
M4 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=4.224e-13 AS=3.484e-13 PD=2.72e-06 PS=1.86e-06 $X=4945 $Y=670 $dt=2
M5 5 A vdd5! vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=3.443e-13 AS=6.766e-13 PD=1.92657e-06 PS=3.79657e-06 $X=600 $Y=2410 $dt=5
M6 vdd5! A 5 vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=3.523e-13 AS=3.443e-13 PD=1.92657e-06 PS=1.92657e-06 $X=1640 $Y=2410 $dt=5
M7 Q 5 vdd5! vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=3.443e-13 AS=3.523e-13 PD=1.92657e-06 PS=1.92657e-06 $X=2600 $Y=2410 $dt=5
M8 vdd5! 5 Q vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=3.523e-13 AS=3.443e-13 PD=1.92657e-06 PS=1.92657e-06 $X=3640 $Y=2410 $dt=5
M9 Q 5 vdd5! vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=3.443e-13 AS=3.523e-13 PD=1.92657e-06 PS=1.92657e-06 $X=4600 $Y=2410 $dt=5
M10 vdd5! 5 Q vdd5! pe5 L=5.00081e-07 W=1.42657e-06 AD=6.484e-13 AS=3.443e-13 PD=3.75657e-06 PS=1.92657e-06 $X=5640 $Y=2410 $dt=5
.ends BU_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON21_5VX4                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON21_5VX4 vdd5! gnd! B A C Q
** N=10 EP=6 FDC=16
M0 gnd! B 7 gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.352e-13 AS=4.19588e-13 PD=1.43621e-06 PS=2.73121e-06 $X=605 $Y=660 $dt=2
M1 7 A gnd! gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.32688e-13 AS=2.352e-13 PD=1.42121e-06 PS=1.43621e-06 $X=1645 $Y=660 $dt=2
M2 8 C 7 gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=4.19075e-13 AS=2.32688e-13 PD=2.91213e-06 PS=1.42121e-06 $X=2655 $Y=660 $dt=2
M3 gnd! 8 9 gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.35237e-13 AS=3.63787e-13 PD=1.43621e-06 PS=2.66092e-06 $X=4300 $Y=660 $dt=2
M4 Q 9 gnd! gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.32688e-13 AS=2.35237e-13 PD=1.42121e-06 PS=1.43621e-06 $X=5340 $Y=660 $dt=2
M5 gnd! 9 Q gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.35237e-13 AS=2.32688e-13 PD=1.43621e-06 PS=1.42121e-06 $X=6350 $Y=660 $dt=2
M6 Q 9 gnd! gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=2.32688e-13 AS=2.35237e-13 PD=1.42121e-06 PS=1.43621e-06 $X=7390 $Y=660 $dt=2
M7 gnd! 9 Q gnd! ne5 L=4.98626e-07 W=8.96213e-07 AD=4.25287e-13 AS=2.32688e-13 PD=2.76121e-06 PS=1.42121e-06 $X=8400 $Y=660 $dt=2
M8 10 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=8.802e-13 PD=1.66e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M9 8 A 10 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=1.7625e-13 PD=1.95e-06 PS=1.66e-06 $X=1410 $Y=2410 $dt=5
M10 vdd5! C 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.0914e-12 AS=3.807e-13 PD=4.8e-06 PS=1.95e-06 $X=2450 $Y=2410 $dt=5
M11 vdd5! 8 9 vdd5! pe5 L=4.98703e-07 W=1.43071e-06 AD=4.43076e-13 AS=6.478e-13 PD=2.3318e-06 PS=3.75071e-06 $X=4350 $Y=2410 $dt=5
M12 Q 9 vdd5! vdd5! pe5 L=4.99329e-07 W=1.44314e-06 AD=3.335e-13 AS=4.46924e-13 PD=1.90314e-06 PS=2.35205e-06 $X=5340 $Y=2410 $dt=5
M13 vdd5! 9 Q vdd5! pe5 L=4.99329e-07 W=1.44314e-06 AD=4.382e-13 AS=3.335e-13 PD=2.34314e-06 PS=1.90314e-06 $X=6380 $Y=2410 $dt=5
M14 Q 9 vdd5! vdd5! pe5 L=4.99329e-07 W=1.44314e-06 AD=3.335e-13 AS=4.382e-13 PD=1.90314e-06 PS=2.34314e-06 $X=7350 $Y=2410 $dt=5
M15 vdd5! 9 Q vdd5! pe5 L=4.99329e-07 W=1.44314e-06 AD=8.87e-13 AS=3.335e-13 PD=4.61314e-06 PS=1.90314e-06 $X=8390 $Y=2410 $dt=5
.ends ON21_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: FA_5VX4                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt FA_5VX4 vdd5! gnd! S CI B A CO
** N=19 EP=7 FDC=40
M0 S 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.46975e-13 AS=4.31e-13 PD=1.445e-06 PS=2.76e-06 $X=620 $Y=660 $dt=2
M1 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=2.42e-13 AS=2.46975e-13 PD=1.44e-06 PS=1.445e-06 $X=1675 $Y=660 $dt=2
M2 S 8 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=2.42e-13 PD=1.43e-06 PS=1.44e-06 $X=2715 $Y=660 $dt=2
M3 gnd! 8 S gnd! ne5 L=5e-07 W=8.9e-07 AD=4.808e-13 AS=2.403e-13 PD=3.40284e-06 PS=1.43e-06 $X=3755 $Y=660 $dt=2
M4 9 CI 8 gnd! ne5 L=5e-07 W=5.9e-07 AD=7.375e-14 AS=2.6e-13 PD=8.4e-07 PS=2.04627e-06 $X=5335 $Y=960 $dt=2
M5 10 B 9 gnd! ne5 L=5e-07 W=5.9e-07 AD=7.375e-14 AS=7.375e-14 PD=8.4e-07 PS=8.4e-07 $X=6085 $Y=960 $dt=2
M6 gnd! A 10 gnd! ne5 L=5e-07 W=5.9e-07 AD=2.34033e-13 AS=7.375e-14 PD=1.52158e-06 PS=8.4e-07 $X=6835 $Y=960 $dt=2
M7 11 CI gnd! gnd! ne5 L=5e-07 W=5.5e-07 AD=1.485e-13 AS=2.18167e-13 PD=1.09e-06 PS=1.41842e-06 $X=7915 $Y=660 $dt=2
M8 gnd! A 11 gnd! ne5 L=5e-07 W=5.5e-07 AD=2.5017e-13 AS=1.485e-13 PD=1.58058e-06 PS=1.09e-06 $X=8955 $Y=660 $dt=2
M9 11 B gnd! gnd! ne5 L=5e-07 W=4.8e-07 AD=1.296e-13 AS=2.1833e-13 PD=1.02e-06 PS=1.37942e-06 $X=10085 $Y=960 $dt=2
M10 8 13 11 gnd! ne5 L=5e-07 W=4.8e-07 AD=2.304e-13 AS=1.296e-13 PD=1.92e-06 PS=1.02e-06 $X=11125 $Y=960 $dt=2
M11 CO 13 gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=3.3335e-13 PD=1.13e-06 PS=2.31e-06 $X=12950 $Y=960 $dt=2
M12 gnd! 13 CO gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=13990 $Y=960 $dt=2
M13 CO 13 gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=15030 $Y=960 $dt=2
M14 gnd! 13 CO gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=16070 $Y=960 $dt=2
M15 14 A gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=8.26e-14 AS=1.593e-13 PD=8.7e-07 PS=1.13e-06 $X=17110 $Y=960 $dt=2
M16 13 B 14 gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=8.26e-14 PD=1.13e-06 PS=8.7e-07 $X=17890 $Y=960 $dt=2
M17 12 CI 13 gnd! ne5 L=5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=18930 $Y=960 $dt=2
M18 gnd! B 12 gnd! ne5 L=5e-07 W=5.9e-07 AD=3.4785e-13 AS=1.593e-13 PD=1.76e-06 PS=1.13e-06 $X=19970 $Y=960 $dt=2
M19 12 A gnd! gnd! ne5 L=5e-07 W=5.9e-07 AD=2.832e-13 AS=3.4785e-13 PD=2.14e-06 PS=1.76e-06 $X=21280 $Y=960 $dt=2
M20 S 8 vdd5! vdd5! pe5 L=5.00779e-07 W=1.47006e-06 AD=2.55638e-13 AS=5.70037e-13 PD=1.86506e-06 PS=3.71506e-06 $X=475 $Y=2410 $dt=5
M21 vdd5! 8 S vdd5! pe5 L=5.00779e-07 W=1.47006e-06 AD=2.70137e-13 AS=2.55638e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1515 $Y=2410 $dt=5
M22 S 8 vdd5! vdd5! pe5 L=5.00779e-07 W=1.47006e-06 AD=2.55638e-13 AS=2.70137e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2265 $Y=2410 $dt=5
M23 vdd5! 8 S vdd5! pe5 L=5.00779e-07 W=1.47006e-06 AD=7.13675e-13 AS=2.55638e-13 PD=4.44284e-06 PS=1.86506e-06 $X=3305 $Y=2410 $dt=5
M24 vdd5! CI 15 vdd5! pe5 L=5e-07 W=1.03e-06 AD=4.558e-13 AS=4.56087e-13 PD=2.3e-06 PS=2.98778e-06 $X=4885 $Y=2490 $dt=5
M25 15 B vdd5! vdd5! pe5 L=5e-07 W=1.03e-06 AD=2.781e-13 AS=4.558e-13 PD=1.57e-06 PS=2.3e-06 $X=6005 $Y=2490 $dt=5
M26 vdd5! A 15 vdd5! pe5 L=5e-07 W=1.03e-06 AD=4.12725e-13 AS=2.781e-13 PD=2.015e-06 PS=1.57e-06 $X=7045 $Y=2490 $dt=5
M27 17 A vdd5! vdd5! pe5 L=5e-07 W=1.03e-06 AD=1.2875e-13 AS=4.12725e-13 PD=1.28e-06 PS=2.015e-06 $X=8220 $Y=2490 $dt=5
M28 18 B 17 vdd5! pe5 L=5e-07 W=1.03e-06 AD=1.2875e-13 AS=1.2875e-13 PD=1.28e-06 PS=1.28e-06 $X=8970 $Y=2490 $dt=5
M29 8 CI 18 vdd5! pe5 L=5e-07 W=1.03e-06 AD=2.781e-13 AS=1.2875e-13 PD=1.57e-06 PS=1.28e-06 $X=9720 $Y=2490 $dt=5
M30 15 13 8 vdd5! pe5 L=5e-07 W=1.03e-06 AD=5.496e-13 AS=2.781e-13 PD=3.63799e-06 PS=1.57e-06 $X=10760 $Y=2490 $dt=5
M31 CO 13 vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=6.2605e-13 PD=1.65e-06 PS=3.34799e-06 $X=12525 $Y=2410 $dt=5
M32 vdd5! 13 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=4.218e-13 AS=2.997e-13 PD=2.1e-06 PS=1.65e-06 $X=13565 $Y=2410 $dt=5
M33 CO 13 vdd5! vdd5! pe5 L=5e-07 W=1.11e-06 AD=2.997e-13 AS=4.218e-13 PD=1.65e-06 PS=2.1e-06 $X=14685 $Y=2410 $dt=5
M34 vdd5! 13 CO vdd5! pe5 L=5e-07 W=1.11e-06 AD=4.34803e-13 AS=2.997e-13 PD=2.20943e-06 PS=1.65e-06 $X=15725 $Y=2410 $dt=5
M35 16 A vdd5! vdd5! pe5 L=5e-07 W=9.9e-07 AD=2.69775e-13 AS=3.87797e-13 PD=1.535e-06 PS=1.97057e-06 $X=16845 $Y=2530 $dt=5
M36 vdd5! B 16 vdd5! pe5 L=5e-07 W=9.9e-07 AD=5.35687e-13 AS=2.69775e-13 PD=3.54335e-06 PS=1.535e-06 $X=17890 $Y=2530 $dt=5
M37 13 CI 16 vdd5! pe5 L=5e-07 W=1e-06 AD=2.7e-13 AS=4.29312e-13 PD=1.54e-06 PS=2.87335e-06 $X=19510 $Y=2410 $dt=5
M38 19 B 13 vdd5! pe5 L=5e-07 W=1e-06 AD=1.25e-13 AS=2.7e-13 PD=1.25e-06 PS=1.54e-06 $X=20550 $Y=2410 $dt=5
M39 vdd5! A 19 vdd5! pe5 L=5e-07 W=1e-06 AD=7.597e-13 AS=1.25e-13 PD=4.56e-06 PS=1.25e-06 $X=21300 $Y=2410 $dt=5
.ends FA_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2_5VX0                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2_5VX0 vdd5! gnd! B Q A
** N=6 EP=5 FDC=4
M0 6 B gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=8.852e-13 PD=6.7e-07 PS=4.04e-06 $X=920 $Y=1130 $dt=2
M1 Q A 6 gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=5.25e-14 PD=1.8e-06 PS=6.7e-07 $X=1670 $Y=1130 $dt=2
M2 Q B vdd5! vdd5! pe5 L=5e-07 W=5e-07 AD=1.35e-13 AS=7.74e-13 PD=1.04e-06 PS=4.58e-06 $X=630 $Y=2410 $dt=5
M3 vdd5! A Q vdd5! pe5 L=5e-07 W=5e-07 AD=7.74e-13 AS=1.35e-13 PD=4.58e-06 PS=1.04e-06 $X=1670 $Y=2410 $dt=5
.ends NA2_5VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__P2                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__P2 1 3 4 5 6 7 8 9 10 11
+ 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31
+ 32 33 34 35 36 37 38 39 40 41
+ 42 43 44 45 46 47 48 49 51 52
+ 53 54 55 56 57 58 59 60 61 62
+ 63 64 65 66 67 68 69 70 71 72
+ 73 74 75 76 77 78 79 80 81 82
+ 83 84 85 86 87 88 89 90 91 92
+ 93 94 95 96 97 98 99 100 101 102
+ 103 104 105 106 107 108 109 110 111 112
+ 113 115 116 117 118 119 120 121 122 123
+ 124 125 126 127 128 129 130 131 132 133
+ 134 135 136 137 138 139 140 141 142 143
+ 144 145 146 147 148 149 150 151 152 153
+ 154 155 156 157 158 159 160 161 162 163
+ 164 165 166 167 168 169 170 171 172 173
+ 174 175 176 177 178 179 180 181 182 183
+ 184 185 186 187 188 189 190 191 192 193
+ 194 195 196 197 198 199 200 201 202 203
+ 204 205 206 207 208 209 210 211 212 213
+ 214 215 216 217 218 219 220 221 222 223
+ 224 225 226 227 228 229 230 231 232 233
+ 234 235 236 237 238 239 240 241 242 243
+ 244 245 246 247 248 249 250 251 252 253
+ 254 255 256 257 258 259 260 261 262 263
+ 264 265 266 267 268 269 270 271 272 273
+ 274 275 276 277 278 279 280 281 282 283
+ 284 285 286 287 288 289 290 291 292 293
+ 294 295 296 297 298 299 300 301 302 303
+ 304 305 306 307 308 309 310 311 312 313
+ 314 315 316 317 318 319 320 321 322 323
+ 324 326 327 328 329 330 331 332 333 334
+ 335 336 337 338 339 340 341 342 343 344
+ 345 346 347 348 349 350 351 352 353 354
+ 355 356 357 358 359 360 361 362 363 364
+ 365 366 367 368 369 370 371 372 373 374
+ 375 376 377 378 379 380 381 382 383 384
+ 385 386 387 388 389 390 391 392 393 394
+ 395 396 397 398 399 400 401 402 403 404
+ 405 406 407 408 409 410 411 412 413 414
+ 415 416 417 418 419 420 421 422 423 424
+ 425 426 427 428 429 430 431 432 433 434
+ 435 436 438 439 440 441 442 443 444 445
+ 446 447 448 449 450 451 452 453 454 455
+ 456 457 458 459 460 461 462 463 464 465
+ 466 467 468 469 470 471 472 473 474 475
+ 476 477 478 479 480 481 482 483 484 485
+ 486 487 488 489 490 491 492 493 494 495
+ 496 497 498 499 500 501 502 503 504 505
+ 506 507 508 509 510 511 512 513 514 515
+ 516 517 518 519 520 521 522 523 524 525
+ 526 527 528 529 530 531 532 533 534 535
+ 536 537 538 539 540 541 542 543 544 545
+ 546 547 548 549 550 551 552 553 554 555
+ 556 557 558 559 560 561 562 563 564 565
+ 566 567 568 569 570 571 572 573 574 575
+ 576 577 578 579 580 581 582 583 584 585
+ 586 587 588 589 590 591 592 593 594 595
+ 596 597 598 599 600 601 602 603 604 605
+ 606 607 608 609 610 611 612 613 614 615
+ 616 617 618 619 620 621 622 623 624 625
+ 626 627 628 629 630 631 632 633 634 635
+ 636 637 638 639 640 641 642 643 644 645
+ 646 647 648 649 650 651 652 653 654 655
+ 656 657 658 659 660 661 662 663 664 665
+ 666 667 668 669 670 671 672 673 674 675
+ 676 677 678 679 680 681 682 683 684 685
+ 686 687 688 689 690 691 692 693 694 695
+ 696 697 698 699 700 701 702 703 704 705
+ 706 707 708 709 710 711 712 713 714 715
+ 716 717 718 719 720 721 722 723 724 725
+ 726 727 728 729 730 731 732 733 734 735
+ 736 737 738 739 740 741 742 743 744 745
+ 746 747 748 749 750 751 752 753 754 755
+ 756 757 758 759 760 761 762 763 764 765
+ 766 767 768 769 770 771 772 773 774 775
+ 776 777 778 779 780 781 782 783 784 785
+ 786 787 788 789 790 791 792 793 794 795
+ 796 797 798 799 800 801 802 803 804 805
+ 806 807 808 809 810 811 812 813 814 815
+ 816 817 818 819 820 821 822 823 824 825
+ 826 827 828 829 830 832 833 834 835 836
+ 837 838 839 840 841 842 843 844 845 846
+ 847 848 849 850 851 852 853 854 855 856
+ 857 858 859 860 861 862 863 864 865 866
+ 867 868 869 870 871 872 873 874 875 876
+ 877 878 879 880 881 882 884 885 886 887
+ 888 889 890 891 892 893 894 895 896 897
+ 898 899 900 901 902 903 904 905 906 907
+ 908 909 910 911 912 913 914 915 916 917
+ 918 919 920 921 922 923 924 925 926 927
+ 928 929 930 931 932 933 934 935 936 937
+ 938 939 940 941 942 943 944 945 946 947
+ 948 949 950 951 952 953 954 955 956 957
+ 958 959 960 961 962 963 964 965 966 967
+ 968 969 970 971 972 973 974 975 976 977
+ 978 979 980 981 982 983 984 985 986 987
+ 988 989 990 991 992 993 994 995 996 997
+ 998 999 1000 1001 1002 1003 1004 1005 1006 1007
+ 1008 1009 1010 1011 1012 1013 1014 1015 1016 1017
+ 1018 1019 1020 1021 1022 1023 1024 1025 1026 1027
+ 1028 1029 1030 1031 1032 1033 1034 1035 1036 1037
+ 1038 1039 1040 1041 1042 1043 1044 1045 1046 1047
+ 1048 1049 1050 1051 1052 1053 1054 1055 1056 1057
+ 1058 1059 1060 1061 1062 1063 1064 1065 1066 1067
+ 1068 1069 1070 1071 1072 1073 1074 1075 1076 1077
+ 1078 1079 1080 1081 1082 1083 1084 1085 1086 1087
+ 1088 1089 1090 1091 1092 1093 1094 1095 1096 1097
+ 1098 1099 1100 1101 1102 1103 1104 1105 1106 1107
+ 1108 1109 1110 1111 1112 1113 1114 1115 1116 1117
+ 1118 1119 1120 1121 1122 1123 1124 1125 1126 1127
+ 1128 1129 1130 1131 1132 1133 1134 1135 1136 1137
+ 1138 1139 1140 1141 1142 1143 1144 1145 1146 1147
+ 1148 1149 1150 1151 1152 1153 1154 1155 1156 1157
+ 1158 1159 1160 1161 1162 1163 1164 1165 1166 1167
+ 1168 1169 1170 1171 1172 1173 1174 1175 1176 1177
+ 1178 1179 1180 1181 1182 1183 1184 1185 1186 1187
+ 1188 1189 1190 1191 1192 1193 1194 1195 1196 1197
+ 1198 1199 1200 1201 1202 1203 1204 1205 1206 1207
+ 1208 1209 1210 1211 1212 1213 1214 1215 1216 1217
+ 1218 1219 1220 1221 1222 1223 1224 1225 1226 1227
+ 1228 1229 1230 1231 1232 1233 1234 1235 1236 1237
+ 1238 1239 1240 1241 1242 1243 1244 1245 1246 1247
+ 1248 1249 1250 1251 1252 1253 1254 1255 1256 1257
+ 1258 1259 1260 1261 1262 1263 1264 1265 1266 1267
+ 1268 1269 1270 1271 1272 1273 1274 1275 1276 1277
+ 1278 1279 1280 1281 1282 1283 1284 1285 1286 1287
+ 1288 1289 1290 1291 1292 1293 1294 1295 1296 1297
+ 1298 1299 1300 1302 1303 1304 1305 1306 1307 1308
+ 1309 1310 1311 1312 1313 1314 1315 1316 1317 1318
+ 1319 1320 1321 1322 1323 1324 1325 1326 1327 1328
+ 1329 1330 1331 1332 1333 1334 1335 1336 1338 1339
+ 1340 1341 1342 1343 1344 1345 1346 1347 1348 1349
+ 1350 1351 1352 1353 1354 1355 1356 1357 1358 1359
+ 1360 1361 1362 1363 1364 1365 1366 1367 1368 1369
+ 1370 1371 1372 1373 1374 1375 1376 1377 1378 1379
+ 1380 1381 1382 1383 1384 1385 1386 1387 1388 1389
+ 1390 1391 1392 1393 1394 1395 1396 1397 1398 1399
+ 1400 1401 1402 1403 1404 1405 1406 1407 1408 1409
+ 1410 1411 1412 1413 1414 1415 1416 1417 1418 1419
+ 1420 1421 1422 1423 1424 1425
** N=8121 EP=1416 FDC=90587
X42177 5 4 1550 1533 BU_5VX1 $T=-515640 0 0 0 $X=-516070 $Y=-640
X42178 5 4 20 6229 BU_5VX1 $T=-513960 -44800 0 0 $X=-514390 $Y=-45440
X42179 5 4 1531 6228 BU_5VX1 $T=-513960 -35840 1 0 $X=-514390 $Y=-40960
X42180 5 4 6228 7932 BU_5VX1 $T=-511160 -44800 0 0 $X=-511590 $Y=-45440
X42181 5 4 1548 1550 BU_5VX1 $T=-506120 0 0 0 $X=-506550 $Y=-640
X42182 5 4 1597 1588 BU_5VX1 $T=-493240 -170240 1 0 $X=-493670 $Y=-175360
X42183 5 4 1801 1787 BU_5VX1 $T=-447880 -268800 0 0 $X=-448310 $Y=-269440
X42184 5 4 74 1446 BU_5VX1 $T=-426600 -44800 0 0 $X=-427030 $Y=-45440
X42185 5 4 6335 6340 BU_5VX1 $T=-422680 -44800 0 0 $X=-423110 $Y=-45440
X42186 5 4 2061 1904 BU_5VX1 $T=-392440 -80640 1 0 $X=-392870 $Y=-85760
X42187 5 4 2167 156 BU_5VX1 $T=-369480 -268800 1 0 $X=-369910 $Y=-273920
X42188 5 4 2169 2195 BU_5VX1 $T=-365560 -89600 0 0 $X=-365990 $Y=-90240
X42189 5 4 2190 2225 BU_5VX1 $T=-364440 -26880 0 0 $X=-364870 $Y=-27520
X42190 5 4 2191 2204 BU_5VX1 $T=-364440 -8960 1 0 $X=-364870 $Y=-14080
X42191 5 4 2226 6452 BU_5VX1 $T=-345400 8960 0 0 $X=-345830 $Y=8320
X42192 5 4 2286 2290 BU_5VX1 $T=-335320 -197120 0 0 $X=-335750 $Y=-197760
X42193 5 4 7 2219 BU_5VX1 $T=-312920 -215040 1 180 $X=-316150 $Y=-215680
X42194 5 4 2449 2453 BU_5VX1 $T=-282120 -224000 1 0 $X=-282550 $Y=-229120
X42195 5 4 2534 2539 BU_5VX1 $T=-281560 -197120 1 0 $X=-281990 $Y=-202240
X42196 5 4 2517 2527 BU_5VX1 $T=-279320 -224000 1 0 $X=-279750 $Y=-229120
X42197 5 4 3325 2623 BU_5VX1 $T=-269240 -179200 1 0 $X=-269670 $Y=-184320
X42198 5 4 2599 2608 BU_5VX1 $T=-268680 -8960 1 0 $X=-269110 $Y=-14080
X42199 5 4 2743 316 BU_5VX1 $T=-237320 0 1 0 $X=-237750 $Y=-5120
X42200 5 4 2750 2757 BU_5VX1 $T=-236200 -125440 0 0 $X=-236630 $Y=-126080
X42201 5 4 2799 313 BU_5VX1 $T=-222200 8960 1 0 $X=-222630 $Y=3840
X42202 5 4 2895 2910 BU_5VX1 $T=-193640 -107520 1 0 $X=-194070 $Y=-112640
X42203 5 4 373 378 BU_5VX1 $T=-191400 0 0 0 $X=-191830 $Y=-640
X42204 5 4 3040 3046 BU_5VX1 $T=-177960 -53760 0 0 $X=-178390 $Y=-54400
X42205 5 4 3045 3058 BU_5VX1 $T=-177400 -80640 0 0 $X=-177830 $Y=-81280
X42206 5 4 3041 3059 BU_5VX1 $T=-176840 -35840 1 0 $X=-177270 $Y=-40960
X42207 5 4 3075 3045 BU_5VX1 $T=-165080 -71680 1 0 $X=-165510 $Y=-76800
X42208 5 4 3115 3087 BU_5VX1 $T=-155560 -107520 1 0 $X=-155990 $Y=-112640
X42209 5 4 3326 3330 BU_5VX1 $T=-106280 -250880 0 0 $X=-106710 $Y=-251520
X42210 5 4 3690 1488 BU_5VX1 $T=-26760 -170240 0 0 $X=-27190 $Y=-170880
X42211 5 4 3715 3722 BU_5VX1 $T=-21160 -197120 0 0 $X=-21590 $Y=-197760
X42212 5 4 3822 3825 BU_5VX1 $T=5720 -224000 1 0 $X=5290 $Y=-229120
X42213 5 4 4161 4168 BU_5VX1 $T=68440 -62720 0 0 $X=68010 $Y=-63360
X42214 5 4 3441 3557 BU_5VX1 $T=93080 -179200 1 0 $X=92650 $Y=-184320
X42215 5 4 4303 831 BU_5VX1 $T=99240 -161280 1 0 $X=98810 $Y=-166400
X42216 5 4 4582 4067 BU_5VX1 $T=175400 -35840 1 0 $X=174970 $Y=-40960
X42217 5 4 7379 7988 BU_5VX1 $T=256040 -134400 0 0 $X=255610 $Y=-135040
X42218 5 4 7382 7969 BU_5VX1 $T=256600 -44800 1 0 $X=256170 $Y=-49920
X42219 5 4 5082 5052 BU_5VX1 $T=265000 -125440 0 0 $X=264570 $Y=-126080
X42220 5 4 5052 7971 BU_5VX1 $T=268920 -116480 0 0 $X=268490 $Y=-117120
X42221 5 4 7411 5120 BU_5VX1 $T=275640 -80640 0 0 $X=275210 $Y=-81280
X42222 5 4 5121 5133 BU_5VX1 $T=277320 -8960 0 0 $X=276890 $Y=-9600
X42223 5 4 5120 5123 BU_5VX1 $T=284600 -98560 0 0 $X=284170 $Y=-99200
X42224 5 4 5074 5211 BU_5VX1 $T=291320 -71680 1 0 $X=290890 $Y=-76800
X42225 5 4 5178 1237 BU_5VX1 $T=295240 8960 0 0 $X=294810 $Y=8320
X42226 5 4 5211 5221 BU_5VX1 $T=308680 -71680 1 0 $X=308250 $Y=-76800
X42227 5 4 7507 7513 BU_5VX1 $T=323800 -206080 0 0 $X=323370 $Y=-206720
X42228 5 4 7524 7930 BU_5VX1 $T=333880 -188160 0 0 $X=333450 $Y=-188800
X42229 5 4 5545 5550 BU_5VX1 $T=369160 -224000 0 0 $X=368730 $Y=-224640
X42230 5 4 5591 5578 BU_5VX1 $T=380360 -206080 0 0 $X=379930 $Y=-206720
X42231 5 4 5596 7635 BU_5VX1 $T=384840 -188160 0 0 $X=384410 $Y=-188800
X42232 5 4 7648 7989 BU_5VX1 $T=396600 -250880 1 180 $X=393370 $Y=-251520
X42233 5 4 5632 7990 BU_5VX1 $T=396600 -215040 0 180 $X=393370 $Y=-220160
X42234 5 4 7644 7652 BU_5VX1 $T=396600 -35840 1 180 $X=393370 $Y=-36480
X42235 5 4 7668 5679 BU_5VX1 $T=408920 -62720 0 0 $X=408490 $Y=-63360
X42236 5 4 1375 5870 BU_5VX1 $T=451480 0 0 0 $X=451050 $Y=-640
X42237 5 4 5871 5773 BU_5VX1 $T=459320 -170240 1 0 $X=458890 $Y=-175360
X42238 5 4 5894 5903 BU_5VX1 $T=459320 -71680 1 0 $X=458890 $Y=-76800
X42239 5 4 5870 5845 BU_5VX1 $T=461560 0 0 0 $X=461130 $Y=-640
X42240 5 4 5903 5964 BU_5VX1 $T=472760 -62720 0 0 $X=472330 $Y=-63360
X42241 5 4 5959 5967 BU_5VX1 $T=472760 -8960 1 0 $X=472330 $Y=-14080
X42242 5 4 5967 5815 BU_5VX1 $T=475560 -8960 0 0 $X=475130 $Y=-9600
X42243 5 4 7791 5749 BU_5VX1 $T=476120 -125440 0 0 $X=475690 $Y=-126080
X42244 5 4 4490 7984 BU_5VX1 $T=476120 8960 0 0 $X=475690 $Y=8320
X42245 5 4 7816 6016 BU_5VX1 $T=485080 -232960 1 0 $X=484650 $Y=-238080
X42246 5 4 6040 6026 BU_5VX1 $T=504120 -206080 0 0 $X=503690 $Y=-206720
X42247 5 4 5513 6127 BU_5VX1 $T=510840 -35840 1 0 $X=510410 $Y=-40960
X42248 5 4 6137 6123 BU_5VX1 $T=515880 -197120 1 0 $X=515450 $Y=-202240
X42249 5 4 7882 6154 BU_5VX1 $T=517000 -116480 0 0 $X=516570 $Y=-117120
X42250 5 4 7892 6160 BU_5VX1 $T=519240 -125440 1 0 $X=518810 $Y=-130560
X42251 5 4 6144 6146 BU_5VX1 $T=519240 -89600 1 0 $X=518810 $Y=-94720
X42252 5 4 5538 7882 BU_5VX1 $T=519800 -116480 0 0 $X=519370 $Y=-117120
X42253 5 4 6155 6158 BU_5VX1 $T=522040 -89600 1 0 $X=521610 $Y=-94720
X42254 5 4 5573 6182 BU_5VX1 $T=525400 -179200 1 0 $X=524970 $Y=-184320
X42255 5 4 5502 7911 BU_5VX1 $T=528200 -8960 1 0 $X=527770 $Y=-14080
X42256 5 4 5511 6203 BU_5VX1 $T=529880 -26880 0 0 $X=529450 $Y=-27520
X42257 5 4 7911 6183 BU_5VX1 $T=531000 -8960 1 0 $X=530570 $Y=-14080
X42258 5 4 6127 6161 BU_5VX1 $T=531560 -35840 0 0 $X=531130 $Y=-36480
X42259 5 4 6203 6174 BU_5VX1 $T=532680 -26880 0 0 $X=532250 $Y=-27520
X42260 5 4 6182 6198 BU_5VX1 $T=539400 -188160 0 0 $X=538970 $Y=-188800
X42261 5 4 5576 6227 BU_5VX1 $T=540520 -125440 0 0 $X=540090 $Y=-126080
X42262 5 4 7991 6202 BU_5VX1 $T=544440 -143360 1 0 $X=544010 $Y=-148480
X42263 5 4 6188 6226 BU_5VX1 $T=551720 -125440 0 0 $X=551290 $Y=-126080
X42264 5 4 6227 6211 BU_5VX1 $T=554520 -125440 0 0 $X=554090 $Y=-126080
X42265 5 4 2202 6252 BU_5VX2 $T=-474760 -44800 0 0 $X=-475190 $Y=-45440
X42266 5 4 2032 2061 BU_5VX2 $T=-400280 -80640 1 0 $X=-400710 $Y=-85760
X42267 5 4 2195 2166 BU_5VX2 $T=-366680 -107520 0 0 $X=-367110 $Y=-108160
X42268 5 4 2216 2191 BU_5VX2 $T=-347640 -8960 1 0 $X=-348070 $Y=-14080
X42269 5 4 2268 2671 BU_5VX2 $T=-255800 -170240 1 0 $X=-256230 $Y=-175360
X42270 5 4 6669 2895 BU_5VX2 $T=-209320 -107520 0 0 $X=-209750 $Y=-108160
X42271 5 4 259 394 BU_5VX2 $T=-183000 -17920 1 0 $X=-183430 $Y=-23040
X42272 5 4 396 402 BU_5VX2 $T=-178520 -26880 0 0 $X=-178950 $Y=-27520
X42273 5 4 2719 441 BU_5VX2 $T=-152760 -206080 1 180 $X=-157110 $Y=-206720
X42274 5 4 596 3436 BU_5VX2 $T=-74360 -62720 1 0 $X=-74790 $Y=-67840
X42275 5 4 4060 4161 BU_5VX2 $T=77960 -26880 0 0 $X=77530 $Y=-27520
X42276 5 4 7221 994 BU_5VX2 $T=151880 -8960 1 0 $X=151450 $Y=-14080
X42277 5 4 4728 4868 BU_5VX2 $T=228600 -224000 1 0 $X=228170 $Y=-229120
X42278 5 4 1088 5581 BU_5VX2 $T=383720 -206080 0 0 $X=383290 $Y=-206720
X42279 5 4 5570 7775 BU_5VX2 $T=461000 -89600 1 0 $X=460570 $Y=-94720
X42280 5 4 5523 5918 BU_5VX2 $T=463800 -35840 0 0 $X=463370 $Y=-36480
X42281 5 4 5566 7803 BU_5VX2 $T=475560 -98560 1 0 $X=475130 $Y=-103680
X42282 5 4 6123 6128 BU_5VX2 $T=511960 -197120 1 0 $X=511530 $Y=-202240
X42283 5 4 6229 1562 BU_5VX0 $T=-508360 -44800 0 0 $X=-508790 $Y=-45440
X42284 5 4 1592 1597 BU_5VX0 $T=-490440 -170240 1 0 $X=-490870 $Y=-175360
X42285 5 4 1787 1795 BU_5VX0 $T=-450680 -268800 0 0 $X=-451110 $Y=-269440
X42286 5 4 1957 6335 BU_5VX0 $T=-417080 -44800 0 0 $X=-417510 $Y=-45440
X42287 5 4 2045 6394 BU_5VX0 $T=-395800 -143360 0 0 $X=-396230 $Y=-144000
X42288 5 4 6452 2766 BU_5VX0 $T=-342600 8960 0 0 $X=-343030 $Y=8320
X42289 5 4 2200 2223 BU_5VX0 $T=-338120 -215040 0 0 $X=-338550 $Y=-215680
X42290 5 4 2204 2266 BU_5VX0 $T=-338120 -8960 1 0 $X=-338550 $Y=-14080
X42291 5 4 2280 2286 BU_5VX0 $T=-332520 -197120 0 0 $X=-332950 $Y=-197760
X42292 5 4 6482 2738 BU_5VX0 $T=-327480 -26880 1 0 $X=-327910 $Y=-32000
X42293 5 4 2385 2449 BU_5VX0 $T=-299480 -232960 0 0 $X=-299910 $Y=-233600
X42294 5 4 2354 2517 BU_5VX0 $T=-285480 -241920 0 0 $X=-285910 $Y=-242560
X42295 5 4 3111 3040 BU_5VX0 $T=-172920 -53760 1 0 $X=-173350 $Y=-58880
X42296 5 4 3101 3072 BU_5VX0 $T=-166760 8960 1 0 $X=-167190 $Y=3840
X42297 5 4 3044 433 BU_5VX0 $T=-163960 8960 1 0 $X=-164390 $Y=3840
X42298 5 4 3119 3101 BU_5VX0 $T=-161160 8960 1 0 $X=-161590 $Y=3840
X42299 5 4 480 2657 BU_5VX0 $T=-135960 -35840 1 0 $X=-136390 $Y=-40960
X42300 5 4 3324 6814 BU_5VX0 $T=-106280 -71680 1 0 $X=-106710 $Y=-76800
X42301 5 4 6814 3262 BU_5VX0 $T=-106280 -71680 0 0 $X=-106710 $Y=-72320
X42302 5 4 540 3331 BU_5VX0 $T=-106280 -62720 1 0 $X=-106710 $Y=-67840
X42303 5 4 3327 3336 BU_5VX0 $T=-106280 -62720 0 0 $X=-106710 $Y=-63360
X42304 5 4 3331 6815 BU_5VX0 $T=-106280 -53760 1 0 $X=-106710 $Y=-58880
X42305 5 4 6815 538 BU_5VX0 $T=-106280 -53760 0 0 $X=-106710 $Y=-54400
X42306 5 4 541 3328 BU_5VX0 $T=-106280 -35840 1 0 $X=-106710 $Y=-40960
X42307 5 4 3339 553 BU_5VX0 $T=-96760 -53760 0 0 $X=-97190 $Y=-54400
X42308 5 4 3336 3339 BU_5VX0 $T=-88920 -53760 1 0 $X=-89350 $Y=-58880
X42309 5 4 3397 3407 BU_5VX0 $T=-85000 -44800 1 0 $X=-85430 $Y=-49920
X42310 5 4 3436 591 BU_5VX0 $T=-78280 -62720 0 0 $X=-78710 $Y=-63360
X42311 5 4 3540 3550 BU_5VX0 $T=-60360 -116480 0 0 $X=-60790 $Y=-117120
X42312 5 4 3550 3604 BU_5VX0 $T=-55320 -107520 0 0 $X=-55750 $Y=-108160
X42313 5 4 3604 3608 BU_5VX0 $T=-45240 -98560 1 0 $X=-45670 $Y=-103680
X42314 5 4 6940 3631 BU_5VX0 $T=-40200 -80640 0 0 $X=-40630 $Y=-81280
X42315 5 4 3627 6940 BU_5VX0 $T=-39640 -89600 0 0 $X=-40070 $Y=-90240
X42316 5 4 3608 3627 BU_5VX0 $T=-39080 -98560 1 0 $X=-39510 $Y=-103680
X42317 5 4 3633 660 BU_5VX0 $T=-38520 -71680 1 0 $X=-38950 $Y=-76800
X42318 5 4 3647 672 BU_5VX0 $T=-36280 -152320 0 0 $X=-36710 $Y=-152960
X42319 5 4 664 673 BU_5VX0 $T=-36280 -8960 0 0 $X=-36710 $Y=-9600
X42320 5 4 3631 3633 BU_5VX0 $T=-35720 -71680 0 0 $X=-36150 $Y=-72320
X42321 5 4 3771 3540 BU_5VX0 $T=-34040 -116480 0 0 $X=-34470 $Y=-117120
X42322 5 4 3677 3647 BU_5VX0 $T=-30120 -143360 1 0 $X=-30550 $Y=-148480
X42323 5 4 3709 3677 BU_5VX0 $T=-22280 -152320 1 0 $X=-22710 $Y=-157440
X42324 5 4 6989 6991 BU_5VX0 $T=-13320 -232960 0 0 $X=-13750 $Y=-233600
X42325 5 4 6990 6989 BU_5VX0 $T=-12760 -224000 1 0 $X=-13190 $Y=-229120
X42326 5 4 705 3771 BU_5VX0 $T=-11080 -116480 0 0 $X=-11510 $Y=-117120
X42327 5 4 7009 3802 BU_5VX0 $T=-3240 -206080 1 0 $X=-3670 $Y=-211200
X42328 5 4 3819 729 BU_5VX0 $T=680 -268800 1 0 $X=250 $Y=-273920
X42329 5 4 726 3709 BU_5VX0 $T=680 -152320 0 0 $X=250 $Y=-152960
X42330 5 4 4168 7098 BU_5VX0 $T=45480 -26880 0 0 $X=45050 $Y=-27520
X42331 5 4 4067 7100 BU_5VX0 $T=48840 -35840 0 0 $X=48410 $Y=-36480
X42332 5 4 4106 4071 BU_5VX0 $T=55560 -35840 1 0 $X=55130 $Y=-40960
X42333 5 4 828 4127 BU_5VX0 $T=57800 -26880 1 0 $X=57370 $Y=-32000
X42334 5 4 870 4136 BU_5VX0 $T=71240 -26880 0 0 $X=70810 $Y=-27520
X42335 5 4 906 881 BU_5VX0 $T=88600 -134400 1 0 $X=88170 $Y=-139520
X42336 5 4 4299 926 BU_5VX0 $T=98680 -26880 0 0 $X=98250 $Y=-27520
X42337 5 4 934 4339 BU_5VX0 $T=104280 0 0 0 $X=103850 $Y=-640
X42338 5 4 4353 4363 BU_5VX0 $T=108760 -44800 0 0 $X=108330 $Y=-45440
X42339 5 4 4363 4299 BU_5VX0 $T=114920 -35840 0 0 $X=114490 $Y=-36480
X42340 5 4 4393 7203 BU_5VX0 $T=117720 -53760 0 0 $X=117290 $Y=-54400
X42341 5 4 7203 4353 BU_5VX0 $T=121080 -44800 1 0 $X=120650 $Y=-49920
X42342 5 4 4339 7221 BU_5VX0 $T=122200 -8960 1 0 $X=121770 $Y=-14080
X42343 5 4 4462 4393 BU_5VX0 $T=127800 -44800 0 0 $X=127370 $Y=-45440
X42344 5 4 973 4462 BU_5VX0 $T=135640 -17920 1 0 $X=135210 $Y=-23040
X42345 5 4 981 4567 BU_5VX0 $T=151880 0 1 0 $X=151450 $Y=-5120
X42346 5 4 4567 1033 BU_5VX0 $T=166440 8960 0 0 $X=166010 $Y=8320
X42347 5 4 4615 1081 BU_5VX0 $T=178760 8960 0 0 $X=178330 $Y=8320
X42348 5 4 7988 5041 BU_5VX0 $T=258840 -134400 0 0 $X=258410 $Y=-135040
X42349 5 4 5043 7382 BU_5VX0 $T=263320 -44800 1 0 $X=262890 $Y=-49920
X42350 5 4 5184 5121 BU_5VX0 $T=287960 -8960 0 0 $X=287530 $Y=-9600
X42351 5 4 7513 5087 BU_5VX0 $T=326600 -206080 0 0 $X=326170 $Y=-206720
X42352 5 4 7641 7648 BU_5VX0 $T=385400 -241920 1 0 $X=384970 $Y=-247040
X42353 5 4 7619 7644 BU_5VX0 $T=396600 -26880 0 180 $X=393370 $Y=-32000
X42354 5 4 5998 7816 BU_5VX0 $T=482280 -232960 1 0 $X=481850 $Y=-238080
X42355 5 4 5256 5894 BU_5VX0 $T=482280 -80640 0 0 $X=481850 $Y=-81280
X42356 5 4 5540 6040 BU_5VX0 $T=490120 -206080 1 0 $X=489690 $Y=-211200
X42357 5 4 5541 7892 BU_5VX0 $T=522040 -125440 1 0 $X=521610 $Y=-130560
X42358 5 4 7902 7907 BU_5VX0 $T=524840 -125440 1 0 $X=524410 $Y=-130560
X42359 5 4 5560 7991 BU_5VX0 $T=541640 -143360 1 0 $X=541210 $Y=-148480
X42360 5 4 6220 6213 BU_5VX0 $T=544440 -89600 1 0 $X=544010 $Y=-94720
X42361 5 4 7992 5532 BU_5VX0 $T=553960 -89600 0 0 $X=553530 $Y=-90240
X42362 5 4 1530 1537 DLY2_5VX1 $T=-515640 -17920 0 0 $X=-516070 $Y=-18560
X42363 5 4 34 37 DLY2_5VX1 $T=-474200 8960 1 0 $X=-474630 $Y=3840
X42364 5 4 41 46 DLY2_5VX1 $T=-459640 -8960 0 0 $X=-460070 $Y=-9600
X42365 5 4 44 53 DLY2_5VX1 $T=-456840 -44800 0 0 $X=-457270 $Y=-45440
X42366 5 4 56 62 DLY2_5VX1 $T=-445080 -26880 0 0 $X=-445510 $Y=-27520
X42367 5 4 64 70 DLY2_5VX1 $T=-437240 -44800 0 0 $X=-437670 $Y=-45440
X42368 5 4 1962 94 DLY2_5VX1 $T=-415400 -125440 1 0 $X=-415830 $Y=-130560
X42369 5 4 1994 6383 DLY2_5VX1 $T=-407560 -116480 0 0 $X=-407990 $Y=-117120
X42370 5 4 6383 2054 DLY2_5VX1 $T=-400280 -107520 1 0 $X=-400710 $Y=-112640
X42371 5 4 6394 2076 DLY2_5VX1 $T=-396360 -134400 0 0 $X=-396790 $Y=-135040
X42372 5 4 1771 130 DLY2_5VX1 $T=-393560 -107520 0 0 $X=-393990 $Y=-108160
X42373 5 4 2077 2045 DLY2_5VX1 $T=-391320 -143360 1 0 $X=-391750 $Y=-148480
X42374 5 4 2091 2120 DLY2_5VX1 $T=-387400 -197120 0 0 $X=-387830 $Y=-197760
X42375 5 4 1454 2124 DLY2_5VX1 $T=-371720 -44800 1 0 $X=-372150 $Y=-49920
X42376 5 4 152 2700 DLY2_5VX1 $T=-369480 -268800 0 0 $X=-369910 $Y=-269440
X42377 5 4 1795 161 DLY2_5VX1 $T=-369480 -250880 1 0 $X=-369910 $Y=-256000
X42378 5 4 2173 2634 DLY2_5VX1 $T=-369480 -161280 0 0 $X=-369910 $Y=-161920
X42379 5 4 1607 2241 DLY2_5VX1 $T=-348200 -107520 1 0 $X=-348630 $Y=-112640
X42380 5 4 1636 2386 DLY2_5VX1 $T=-317960 -152320 0 0 $X=-318390 $Y=-152960
X42381 5 4 1459 196 DLY2_5VX1 $T=-317960 -125440 1 0 $X=-318390 $Y=-130560
X42382 5 4 2382 2414 DLY2_5VX1 $T=-311800 -206080 0 0 $X=-312230 $Y=-206720
X42383 5 4 1688 2419 DLY2_5VX1 $T=-311240 -224000 0 0 $X=-311670 $Y=-224640
X42384 5 4 1852 2424 DLY2_5VX1 $T=-310120 -268800 0 0 $X=-310550 $Y=-269440
X42385 5 4 2395 3248 DLY2_5VX1 $T=-310120 -232960 1 0 $X=-310550 $Y=-238080
X42386 5 4 2444 2326 DLY2_5VX1 $T=-298360 -44800 0 0 $X=-298790 $Y=-45440
X42387 5 4 2460 2303 DLY2_5VX1 $T=-296120 -53760 1 0 $X=-296550 $Y=-58880
X42388 5 4 1776 2537 DLY2_5VX1 $T=-288840 -161280 0 0 $X=-289270 $Y=-161920
X42389 5 4 248 256 DLY2_5VX1 $T=-270360 -152320 0 0 $X=-270790 $Y=-152960
X42390 5 4 2621 2644 DLY2_5VX1 $T=-264760 -143360 0 0 $X=-265190 $Y=-144000
X42391 5 4 258 7917 DLY2_5VX1 $T=-260840 -250880 0 0 $X=-261270 $Y=-251520
X42392 5 4 280 2711 DLY2_5VX1 $T=-251320 -35840 1 0 $X=-251750 $Y=-40960
X42393 5 4 2054 299 DLY2_5VX1 $T=-250200 -71680 0 0 $X=-250630 $Y=-72320
X42394 5 4 2715 307 DLY2_5VX1 $T=-244040 -134400 1 0 $X=-244470 $Y=-139520
X42395 5 4 2745 2759 DLY2_5VX1 $T=-235080 -224000 1 0 $X=-235510 $Y=-229120
X42396 5 4 337 2854 DLY2_5VX1 $T=-222200 -259840 0 0 $X=-222630 $Y=-260480
X42397 5 4 2859 3076 DLY2_5VX1 $T=-216040 -53760 1 0 $X=-216470 $Y=-58880
X42398 5 4 2894 2925 DLY2_5VX1 $T=-207640 -134400 1 0 $X=-208070 $Y=-139520
X42399 5 4 366 2949 DLY2_5VX1 $T=-199800 -89600 0 0 $X=-200230 $Y=-90240
X42400 5 4 2525 3074 DLY2_5VX1 $T=-179080 -116480 1 0 $X=-179510 $Y=-121600
X42401 5 4 397 3078 DLY2_5VX1 $T=-177960 -259840 0 0 $X=-178390 $Y=-260480
X42402 5 4 2748 3162 DLY2_5VX1 $T=-138200 -107520 1 0 $X=-138630 $Y=-112640
X42403 5 4 2815 530 DLY2_5VX1 $T=-121400 -188160 1 0 $X=-121830 $Y=-193280
X42404 5 4 6820 3347 DLY2_5VX1 $T=-96760 -179200 0 0 $X=-97190 $Y=-179840
X42405 5 4 3319 3313 DLY2_5VX1 $T=-68760 -62720 1 0 $X=-69190 $Y=-67840
X42406 5 4 3310 3289 DLY2_5VX1 $T=-57560 8960 0 0 $X=-57990 $Y=8320
X42407 5 4 639 3309 DLY2_5VX1 $T=-50280 -232960 1 0 $X=-50710 $Y=-238080
X42408 5 4 3577 653 DLY2_5VX1 $T=-49720 -71680 1 0 $X=-50150 $Y=-76800
X42409 5 4 699 3307 DLY2_5VX1 $T=-17240 -107520 1 0 $X=-17670 $Y=-112640
X42410 5 4 3734 3790 DLY2_5VX1 $T=-11080 -107520 0 0 $X=-11510 $Y=-108160
X42411 5 4 3786 3817 DLY2_5VX1 $T=-6600 -62720 0 0 $X=-7030 $Y=-63360
X42412 5 4 791 3992 DLY2_5VX1 $T=27000 -259840 1 0 $X=26570 $Y=-264960
X42413 5 4 797 3828 DLY2_5VX1 $T=33160 -152320 1 0 $X=32730 $Y=-157440
X42414 5 4 814 4125 DLY2_5VX1 $T=47160 -250880 0 0 $X=46730 $Y=-251520
X42415 5 4 4141 4163 DLY2_5VX1 $T=63960 -179200 0 0 $X=63530 $Y=-179840
X42416 5 4 935 4112 DLY2_5VX1 $T=104840 -215040 0 0 $X=104410 $Y=-215680
X42417 5 4 948 4122 DLY2_5VX1 $T=111000 -241920 1 0 $X=110570 $Y=-247040
X42418 5 4 4343 4371 DLY2_5VX1 $T=120520 -26880 0 0 $X=120090 $Y=-27520
X42419 5 4 4423 4547 DLY2_5VX1 $T=122200 -62720 1 0 $X=121770 $Y=-67840
X42420 5 4 4350 4466 DLY2_5VX1 $T=122760 -116480 1 0 $X=122330 $Y=-121600
X42421 5 4 4471 4494 DLY2_5VX1 $T=130600 -71680 0 0 $X=130170 $Y=-72320
X42422 5 4 979 4219 DLY2_5VX1 $T=151880 -241920 0 0 $X=151450 $Y=-242560
X42423 5 4 980 4175 DLY2_5VX1 $T=151880 -206080 1 0 $X=151450 $Y=-211200
X42424 5 4 978 4177 DLY2_5VX1 $T=151880 -197120 0 0 $X=151450 $Y=-197760
X42425 5 4 4505 4538 DLY2_5VX1 $T=153000 -71680 1 0 $X=152570 $Y=-76800
X42426 5 4 1012 3885 DLY2_5VX1 $T=160840 -232960 1 0 $X=160410 $Y=-238080
X42427 5 4 7246 4542 DLY2_5VX1 $T=164760 -268800 0 0 $X=164330 $Y=-269440
X42428 5 4 7249 4550 DLY2_5VX1 $T=166440 -224000 0 0 $X=166010 $Y=-224640
X42429 5 4 4565 4653 DLY2_5VX1 $T=181000 -26880 0 0 $X=180570 $Y=-27520
X42430 5 4 1080 4667 DLY2_5VX1 $T=183800 -250880 1 0 $X=183370 $Y=-256000
X42431 5 4 4747 4775 DLY2_5VX1 $T=211800 -215040 1 0 $X=211370 $Y=-220160
X42432 5 4 4784 4572 DLY2_5VX1 $T=212920 -107520 0 0 $X=212490 $Y=-108160
X42433 5 4 4787 4799 DLY2_5VX1 $T=214040 -161280 1 0 $X=213610 $Y=-166400
X42434 5 4 1145 4560 DLY2_5VX1 $T=220200 -250880 0 0 $X=219770 $Y=-251520
X42435 5 4 4868 4756 DLY2_5VX1 $T=227480 -215040 1 0 $X=227050 $Y=-220160
X42436 5 4 4913 1166 DLY2_5VX1 $T=235320 8960 0 0 $X=234890 $Y=8320
X42437 5 4 4957 4765 DLY2_5VX1 $T=244280 -98560 0 0 $X=243850 $Y=-99200
X42438 5 4 5669 4779 DLY2_5VX1 $T=246520 -89600 1 0 $X=246090 $Y=-94720
X42439 5 4 5044 4780 DLY2_5VX1 $T=263880 -71680 1 0 $X=263450 $Y=-76800
X42440 5 4 5047 4793 DLY2_5VX1 $T=265000 -53760 0 0 $X=264570 $Y=-54400
X42441 5 4 5089 4732 DLY2_5VX1 $T=272280 -44800 1 0 $X=271850 $Y=-49920
X42442 5 4 1218 1220 DLY2_5VX1 $T=275080 -26880 0 0 $X=274650 $Y=-27520
X42443 5 4 1219 1222 DLY2_5VX1 $T=275080 8960 0 0 $X=274650 $Y=8320
X42444 5 4 7251 5171 DLY2_5VX1 $T=278440 -53760 1 0 $X=278010 $Y=-58880
X42445 5 4 4596 1233 DLY2_5VX1 $T=282360 -44800 1 0 $X=281930 $Y=-49920
X42446 5 4 5181 4553 DLY2_5VX1 $T=284600 -26880 0 0 $X=284170 $Y=-27520
X42447 5 4 1232 4584 DLY2_5VX1 $T=288520 -215040 0 0 $X=288090 $Y=-215680
X42448 5 4 5226 4557 DLY2_5VX1 $T=296360 -44800 1 0 $X=295930 $Y=-49920
X42449 5 4 7479 1258 DLY2_5VX1 $T=309800 -17920 1 0 $X=309370 $Y=-23040
X42450 5 4 1265 7247 DLY2_5VX1 $T=321560 -215040 1 0 $X=321130 $Y=-220160
X42451 5 4 1270 4497 DLY2_5VX1 $T=326040 -224000 1 0 $X=325610 $Y=-229120
X42452 5 4 5356 5388 DLY2_5VX1 $T=330520 -44800 1 0 $X=330090 $Y=-49920
X42453 5 4 1278 4701 DLY2_5VX1 $T=336120 -80640 0 0 $X=335690 $Y=-81280
X42454 5 4 1290 4600 DLY2_5VX1 $T=345640 -44800 1 0 $X=345210 $Y=-49920
X42455 5 4 5085 5344 DLY2_5VX1 $T=349560 -98560 1 0 $X=349130 $Y=-103680
X42456 5 4 5494 4820 DLY2_5VX1 $T=358520 -125440 1 0 $X=358090 $Y=-130560
X42457 5 4 5510 5586 DLY2_5VX1 $T=362440 8960 0 0 $X=362010 $Y=8320
X42458 5 4 4563 4784 DLY2_5VX1 $T=378680 -197120 0 0 $X=378250 $Y=-197760
X42459 5 4 5630 4817 DLY2_5VX1 $T=380360 -125440 0 0 $X=379930 $Y=-126080
X42460 5 4 5605 4757 DLY2_5VX1 $T=380360 -89600 1 0 $X=379930 $Y=-94720
X42461 5 4 4714 5669 DLY2_5VX1 $T=401640 -116480 0 0 $X=401210 $Y=-117120
X42462 5 4 4788 5089 DLY2_5VX1 $T=401640 -98560 1 0 $X=401210 $Y=-103680
X42463 5 4 4764 4957 DLY2_5VX1 $T=418440 -53760 1 0 $X=418010 $Y=-58880
X42464 5 4 4792 5047 DLY2_5VX1 $T=421800 -17920 1 0 $X=421370 $Y=-23040
X42465 5 4 5171 4530 DLY2_5VX1 $T=429080 -107520 0 0 $X=428650 $Y=-108160
X42466 5 4 5773 4549 DLY2_5VX1 $T=433000 -188160 0 0 $X=432570 $Y=-188800
X42467 5 4 4791 5044 DLY2_5VX1 $T=439720 -98560 1 0 $X=439290 $Y=-103680
X42468 5 4 5034 5871 DLY2_5VX1 $T=447560 -170240 0 0 $X=447130 $Y=-170880
X42469 5 4 4576 5181 DLY2_5VX1 $T=454840 -26880 1 0 $X=454410 $Y=-32000
X42470 5 4 4555 5959 DLY2_5VX1 $T=461000 -17920 0 0 $X=460570 $Y=-18560
X42471 5 4 4786 7791 DLY2_5VX1 $T=463240 -125440 0 0 $X=462810 $Y=-126080
X42472 5 4 5964 5954 DLY2_5VX1 $T=472200 -80640 1 0 $X=471770 $Y=-85760
X42473 5 4 5954 1405 DLY2_5VX1 $T=472200 -71680 0 0 $X=471770 $Y=-72320
X42474 5 4 5913 5406 DLY2_5VX1 $T=473320 -143360 1 0 $X=472890 $Y=-148480
X42475 5 4 7984 5310 DLY2_5VX1 $T=478920 8960 1 0 $X=478490 $Y=3840
X42476 5 4 1536 1970 DLY4_5VX1 $T=-510040 -107520 1 0 $X=-510470 $Y=-112640
X42477 5 4 1538 1536 DLY4_5VX1 $T=-509480 -116480 1 0 $X=-509910 $Y=-121600
X42478 5 4 25 1575 DLY4_5VX1 $T=-507800 -8960 1 0 $X=-508230 $Y=-14080
X42479 5 4 1584 1962 DLY4_5VX1 $T=-493800 -116480 1 0 $X=-494230 $Y=-121600
X42480 5 4 40 1771 DLY4_5VX1 $T=-463000 -80640 1 0 $X=-463430 $Y=-85760
X42481 5 4 1713 1801 DLY4_5VX1 $T=-461880 -259840 0 0 $X=-462310 $Y=-260480
X42482 5 4 1738 1797 DLY4_5VX1 $T=-457960 -107520 1 0 $X=-458390 $Y=-112640
X42483 5 4 1842 1903 DLY4_5VX1 $T=-438360 -89600 0 0 $X=-438790 $Y=-90240
X42484 5 4 1446 85 DLY4_5VX1 $T=-429960 -35840 0 0 $X=-430390 $Y=-36480
X42485 5 4 3018 2046 DLY4_5VX1 $T=-404200 -241920 1 0 $X=-404630 $Y=-247040
X42486 5 4 117 129 DLY4_5VX1 $T=-398040 -26880 1 0 $X=-398470 $Y=-32000
X42487 5 4 136 147 DLY4_5VX1 $T=-384600 0 0 0 $X=-385030 $Y=-640
X42488 5 4 1575 151 DLY4_5VX1 $T=-381800 -8960 1 0 $X=-382230 $Y=-14080
X42489 5 4 2124 2758 DLY4_5VX1 $T=-380120 -44800 0 0 $X=-380550 $Y=-45440
X42490 5 4 1903 2180 DLY4_5VX1 $T=-376760 -134400 1 0 $X=-377190 $Y=-139520
X42491 5 4 2161 2197 DLY4_5VX1 $T=-372280 -224000 0 0 $X=-372710 $Y=-224640
X42492 5 4 2165 2199 DLY4_5VX1 $T=-372280 -152320 0 0 $X=-372710 $Y=-152960
X42493 5 4 2166 2201 DLY4_5VX1 $T=-372280 -80640 1 0 $X=-372710 $Y=-85760
X42494 5 4 1797 2260 DLY4_5VX1 $T=-348200 -125440 0 0 $X=-348630 $Y=-126080
X42495 5 4 1545 168 DLY4_5VX1 $T=-348200 0 0 0 $X=-348630 $Y=-640
X42496 5 4 2046 2265 DLY4_5VX1 $T=-346520 -188160 0 0 $X=-346950 $Y=-188800
X42497 5 4 2282 2334 DLY4_5VX1 $T=-331400 -152320 1 0 $X=-331830 $Y=-157440
X42498 5 4 2303 2356 DLY4_5VX1 $T=-326920 -62720 0 0 $X=-327350 $Y=-63360
X42499 5 4 2326 2379 DLY4_5VX1 $T=-322440 -26880 0 0 $X=-322870 $Y=-27520
X42500 5 4 185 2381 DLY4_5VX1 $T=-321880 -259840 1 0 $X=-322310 $Y=-264960
X42501 5 4 260 6600 DLY4_5VX1 $T=-263080 -215040 1 0 $X=-263510 $Y=-220160
X42502 5 4 272 287 DLY4_5VX1 $T=-254120 -80640 0 0 $X=-254550 $Y=-81280
X42503 5 4 2197 3122 DLY4_5VX1 $T=-253560 -215040 0 0 $X=-253990 $Y=-215680
X42504 5 4 2759 2761 DLY4_5VX1 $T=-232840 -179200 1 0 $X=-233270 $Y=-184320
X42505 5 4 2792 341 DLY4_5VX1 $T=-228920 -26880 1 0 $X=-229350 $Y=-32000
X42506 5 4 2711 370 DLY4_5VX1 $T=-202040 0 0 0 $X=-202470 $Y=-640
X42507 5 4 2949 380 DLY4_5VX1 $T=-196440 -8960 1 0 $X=-196870 $Y=-14080
X42508 5 4 2760 2747 DLY4_5VX1 $T=-187480 -134400 1 0 $X=-187910 $Y=-139520
X42509 5 4 382 3048 DLY4_5VX1 $T=-185800 -232960 0 0 $X=-186230 $Y=-233600
X42510 5 4 3058 434 DLY4_5VX1 $T=-171240 -35840 0 0 $X=-171670 $Y=-36480
X42511 5 4 3076 4209 DLY4_5VX1 $T=-171240 -17920 0 0 $X=-171670 $Y=-18560
X42512 5 4 3162 2762 DLY4_5VX1 $T=-152200 -80640 1 0 $X=-152630 $Y=-85760
X42513 5 4 467 3125 DLY4_5VX1 $T=-146040 -250880 0 0 $X=-146470 $Y=-251520
X42514 5 4 3186 3194 DLY4_5VX1 $T=-143800 -215040 0 0 $X=-144230 $Y=-215680
X42515 5 4 465 3127 DLY4_5VX1 $T=-143240 -170240 1 0 $X=-143670 $Y=-175360
X42516 5 4 475 3113 DLY4_5VX1 $T=-141560 -206080 0 0 $X=-141990 $Y=-206720
X42517 5 4 3288 6812 DLY4_5VX1 $T=-122520 -143360 0 0 $X=-122950 $Y=-144000
X42518 5 4 6807 3306 DLY4_5VX1 $T=-97880 -232960 1 0 $X=-98310 $Y=-238080
X42519 5 4 3316 3379 DLY4_5VX1 $T=-97880 -206080 1 0 $X=-98310 $Y=-211200
X42520 5 4 3399 3461 DLY4_5VX1 $T=-83880 -232960 0 0 $X=-84310 $Y=-233600
X42521 5 4 3526 3853 DLY4_5VX1 $T=-62040 -241920 0 0 $X=-62470 $Y=-242560
X42522 5 4 3597 2853 DLY4_5VX1 $T=-46920 -8960 0 0 $X=-47350 $Y=-9600
X42523 5 4 649 667 DLY4_5VX1 $T=-46920 0 0 0 $X=-47350 $Y=-640
X42524 5 4 3323 3402 DLY4_5VX1 $T=-45800 -44800 0 0 $X=-46230 $Y=-45440
X42525 5 4 3807 3678 DLY4_5VX1 $T=-37960 -232960 0 0 $X=-38390 $Y=-233600
X42526 5 4 3700 3739 DLY4_5VX1 $T=-24520 -143360 0 0 $X=-24950 $Y=-144000
X42527 5 4 3769 3806 DLY4_5VX1 $T=-10520 -232960 0 0 $X=-10950 $Y=-233600
X42528 5 4 3773 3836 DLY4_5VX1 $T=-8840 -152320 1 0 $X=-9270 $Y=-157440
X42529 5 4 3851 3841 DLY4_5VX1 $T=-3800 -98560 0 0 $X=-4230 $Y=-99200
X42530 5 4 3332 3322 DLY4_5VX1 $T=-2680 -53760 0 0 $X=-3110 $Y=-54400
X42531 5 4 3813 3857 DLY4_5VX1 $T=-440 -71680 0 0 $X=-870 $Y=-72320
X42532 5 4 3809 3830 DLY4_5VX1 $T=1800 -188160 1 0 $X=1370 $Y=-193280
X42533 5 4 3854 3904 DLY4_5VX1 $T=8520 -89600 1 0 $X=8090 $Y=-94720
X42534 5 4 3874 3826 DLY4_5VX1 $T=12440 -224000 1 0 $X=12010 $Y=-229120
X42535 5 4 3909 3976 DLY4_5VX1 $T=21400 -44800 1 0 $X=20970 $Y=-49920
X42536 5 4 3941 3963 DLY4_5VX1 $T=25880 -80640 0 0 $X=25450 $Y=-81280
X42537 5 4 801 3863 DLY4_5VX1 $T=37640 -268800 1 0 $X=37210 $Y=-273920
X42538 5 4 816 7228 DLY4_5VX1 $T=49400 -224000 1 0 $X=48970 $Y=-229120
X42539 5 4 4026 3962 DLY4_5VX1 $T=61160 -116480 1 0 $X=60730 $Y=-121600
X42540 5 4 846 4178 DLY4_5VX1 $T=64520 -26880 1 0 $X=64090 $Y=-32000
X42541 5 4 4234 4204 DLY4_5VX1 $T=84680 -53760 0 0 $X=84250 $Y=-54400
X42542 5 4 4164 4167 DLY4_5VX1 $T=85240 -152320 1 0 $X=84810 $Y=-157440
X42543 5 4 4254 4330 DLY4_5VX1 $T=89720 -206080 0 0 $X=89290 $Y=-206720
X42544 5 4 4251 4214 DLY4_5VX1 $T=91400 -107520 1 0 $X=90970 $Y=-112640
X42545 5 4 4663 3827 DLY4_5VX1 $T=97000 -188160 1 0 $X=96570 $Y=-193280
X42546 5 4 4119 4343 DLY4_5VX1 $T=97000 -8960 1 0 $X=96570 $Y=-14080
X42547 5 4 938 4238 DLY4_5VX1 $T=107080 0 0 0 $X=106650 $Y=-640
X42548 5 4 946 4397 DLY4_5VX1 $T=109320 -152320 1 0 $X=108890 $Y=-157440
X42549 5 4 4229 4203 DLY4_5VX1 $T=109880 -71680 0 0 $X=109450 $Y=-72320
X42550 5 4 4509 4190 DLY4_5VX1 $T=151880 -17920 0 0 $X=151450 $Y=-18560
X42551 5 4 4691 3871 DLY4_5VX1 $T=153000 -134400 1 0 $X=152570 $Y=-139520
X42552 5 4 4585 3856 DLY4_5VX1 $T=171480 -161280 1 0 $X=171050 $Y=-166400
X42553 5 4 4646 4685 DLY4_5VX1 $T=184920 -188160 0 0 $X=184490 $Y=-188800
X42554 5 4 4638 7291 DLY4_5VX1 $T=184920 -152320 1 0 $X=184490 $Y=-157440
X42555 5 4 1113 3835 DLY4_5VX1 $T=200600 -259840 1 0 $X=200170 $Y=-264960
X42556 5 4 4718 4737 DLY4_5VX1 $T=200600 -179200 1 0 $X=200170 $Y=-184320
X42557 5 4 4707 4767 DLY4_5VX1 $T=201720 -89600 1 0 $X=201290 $Y=-94720
X42558 5 4 4733 4194 DLY4_5VX1 $T=203960 -53760 0 0 $X=203530 $Y=-54400
X42559 5 4 4678 4272 DLY4_5VX1 $T=223000 -8960 0 0 $X=222570 $Y=-9600
X42560 5 4 4722 3905 DLY4_5VX1 $T=233640 -89600 1 0 $X=233210 $Y=-94720
X42561 5 4 4949 4165 DLY4_5VX1 $T=243160 -35840 1 0 $X=242730 $Y=-40960
X42562 5 4 1175 4675 DLY4_5VX1 $T=245960 -268800 1 0 $X=245530 $Y=-273920
X42563 5 4 4958 5040 DLY4_5VX1 $T=255480 -161280 1 0 $X=255050 $Y=-166400
X42564 5 4 1207 4586 DLY4_5VX1 $T=267800 -259840 0 0 $X=267370 $Y=-260480
X42565 5 4 5182 4702 DLY4_5VX1 $T=286840 -161280 1 0 $X=286410 $Y=-166400
X42566 5 4 5221 5096 DLY4_5VX1 $T=295800 -71680 1 0 $X=295370 $Y=-76800
X42567 5 4 5091 5083 DLY4_5VX1 $T=318200 -35840 1 0 $X=317770 $Y=-40960
X42568 5 4 4590 4601 DLY4_5VX1 $T=319880 -188160 1 0 $X=319450 $Y=-193280
X42569 5 4 4622 4623 DLY4_5VX1 $T=322680 -143360 0 0 $X=322250 $Y=-144000
X42570 5 4 5344 4970 DLY4_5VX1 $T=326600 -116480 0 0 $X=326170 $Y=-117120
X42571 5 4 5433 5051 DLY4_5VX1 $T=346760 -26880 0 0 $X=346330 $Y=-27520
X42572 5 4 5437 5105 DLY4_5VX1 $T=347880 -71680 0 0 $X=347450 $Y=-72320
X42573 5 4 1297 4828 DLY4_5VX1 $T=354040 -268800 1 0 $X=353610 $Y=-273920
X42574 5 4 5563 4693 DLY4_5VX1 $T=355160 -125440 0 0 $X=354730 $Y=-126080
X42575 5 4 5485 4778 DLY4_5VX1 $T=358520 -215040 0 0 $X=358090 $Y=-215680
X42576 5 4 1309 4746 DLY4_5VX1 $T=361880 -232960 1 0 $X=361450 $Y=-238080
X42577 5 4 4711 5713 DLY4_5VX1 $T=365240 -197120 1 0 $X=364810 $Y=-202240
X42578 5 4 5499 4703 DLY4_5VX1 $T=373080 -98560 1 0 $X=372650 $Y=-103680
X42579 5 4 5586 4839 DLY4_5VX1 $T=377000 8960 0 0 $X=376570 $Y=8320
X42580 5 4 4819 5485 DLY4_5VX1 $T=408360 -250880 0 0 $X=407930 $Y=-251520
X42581 5 4 5564 5747 DLY4_5VX1 $T=418440 -107520 0 0 $X=418010 $Y=-108160
X42582 5 4 4652 4949 DLY4_5VX1 $T=418440 8960 0 0 $X=418010 $Y=8320
X42583 5 4 5713 4686 DLY4_5VX1 $T=421240 -170240 1 0 $X=420810 $Y=-175360
X42584 5 4 5749 5356 DLY4_5VX1 $T=427960 -125440 1 0 $X=427530 $Y=-130560
X42585 5 4 5815 5226 DLY4_5VX1 $T=442520 -35840 0 0 $X=442090 $Y=-36480
X42586 5 4 5845 7479 DLY4_5VX1 $T=448120 8960 1 0 $X=447690 $Y=3840
X42587 5 4 4537 5084 DLY4_5VX1 $T=449800 -197120 0 0 $X=449370 $Y=-197760
X42588 5 4 4768 5630 DLY4_5VX1 $T=478920 -152320 0 0 $X=478490 $Y=-152960
X42589 5 4 7807 5352 DLY4_5VX1 $T=480040 -170240 0 0 $X=479610 $Y=-170880
X42590 5 4 2015 19 DLY8_5VX1 $T=-527960 -8960 0 0 $X=-528390 $Y=-9600
X42591 5 4 11 1541 DLY8_5VX1 $T=-522360 -8960 1 0 $X=-522790 $Y=-14080
X42592 5 4 15 2206 DLY8_5VX1 $T=-518440 -62720 0 0 $X=-518870 $Y=-63360
X42593 5 4 1528 1554 DLY8_5VX1 $T=-517880 -89600 1 0 $X=-518310 $Y=-94720
X42594 5 4 17 1616 DLY8_5VX1 $T=-517880 8960 1 0 $X=-518310 $Y=3840
X42595 5 4 16 1553 DLY8_5VX1 $T=-517320 -98560 1 0 $X=-517750 $Y=-103680
X42596 5 4 1529 1557 DLY8_5VX1 $T=-516200 -53760 0 0 $X=-516630 $Y=-54400
X42597 5 4 18 1558 DLY8_5VX1 $T=-516200 -17920 1 0 $X=-516630 $Y=-23040
X42598 5 4 23 1442 DLY8_5VX1 $T=-513960 -44800 1 0 $X=-514390 $Y=-49920
X42599 5 4 21 2193 DLY8_5VX1 $T=-511720 -35840 0 0 $X=-512150 $Y=-36480
X42600 5 4 7932 1572 DLY8_5VX1 $T=-511160 -35840 1 0 $X=-511590 $Y=-40960
X42601 5 4 1540 2235 DLY8_5VX1 $T=-508920 -80640 1 0 $X=-509350 $Y=-85760
X42602 5 4 1544 1596 DLY8_5VX1 $T=-507800 -17920 0 0 $X=-508230 $Y=-18560
X42603 5 4 1543 1583 DLY8_5VX1 $T=-507800 8960 0 0 $X=-508230 $Y=8320
X42604 5 4 1542 1455 DLY8_5VX1 $T=-507240 -89600 0 0 $X=-507670 $Y=-90240
X42605 5 4 7993 1581 DLY8_5VX1 $T=-507240 -8960 0 0 $X=-507670 $Y=-9600
X42606 5 4 1546 1605 DLY8_5VX1 $T=-506120 -71680 0 0 $X=-506550 $Y=-72320
X42607 5 4 6230 1585 DLY8_5VX1 $T=-506120 -26880 1 0 $X=-506550 $Y=-32000
X42608 5 4 6231 1587 DLY8_5VX1 $T=-505560 -53760 1 0 $X=-505990 $Y=-58880
X42609 5 4 1547 2186 DLY8_5VX1 $T=-505560 -44800 0 0 $X=-505990 $Y=-45440
X42610 5 4 1551 6236 DLY8_5VX1 $T=-504440 -80640 0 0 $X=-504870 $Y=-81280
X42611 5 4 1555 1453 DLY8_5VX1 $T=-503880 -62720 0 0 $X=-504310 $Y=-63360
X42612 5 4 1556 1590 DLY8_5VX1 $T=-503320 -98560 0 0 $X=-503750 $Y=-99200
X42613 5 4 7933 1595 DLY8_5VX1 $T=-503320 -89600 1 0 $X=-503750 $Y=-94720
X42614 5 4 1564 1591 DLY8_5VX1 $T=-503320 0 0 0 $X=-503750 $Y=-640
X42615 5 4 1533 1602 DLY8_5VX1 $T=-503320 8960 1 0 $X=-503750 $Y=3840
X42616 5 4 1562 29 DLY8_5VX1 $T=-501640 -53760 0 0 $X=-502070 $Y=-54400
X42617 5 4 1563 1600 DLY8_5VX1 $T=-501640 -17920 1 0 $X=-502070 $Y=-23040
X42618 5 4 2969 1607 DLY8_5VX1 $T=-500520 -116480 0 0 $X=-500950 $Y=-117120
X42619 5 4 1567 6238 DLY8_5VX1 $T=-499400 -125440 1 0 $X=-499830 $Y=-130560
X42620 5 4 1568 1631 DLY8_5VX1 $T=-499400 -107520 1 0 $X=-499830 $Y=-112640
X42621 5 4 1569 1614 DLY8_5VX1 $T=-499400 -44800 1 0 $X=-499830 $Y=-49920
X42622 5 4 1570 1615 DLY8_5VX1 $T=-499400 -26880 0 0 $X=-499830 $Y=-27520
X42623 5 4 2042 7919 DLY8_5VX1 $T=-499400 0 1 0 $X=-499830 $Y=-5120
X42624 5 4 6232 1617 DLY8_5VX1 $T=-497720 -107520 0 0 $X=-498150 $Y=-108160
X42625 5 4 1573 1618 DLY8_5VX1 $T=-497160 -179200 0 0 $X=-497590 $Y=-179840
X42626 5 4 1639 1637 DLY8_5VX1 $T=-497160 -35840 0 0 $X=-497590 $Y=-36480
X42627 5 4 1574 1619 DLY8_5VX1 $T=-497160 -8960 1 0 $X=-497590 $Y=-14080
X42628 5 4 6233 1623 DLY8_5VX1 $T=-496600 -143360 1 0 $X=-497030 $Y=-148480
X42629 5 4 1576 1620 DLY8_5VX1 $T=-496600 -62720 1 0 $X=-497030 $Y=-67840
X42630 5 4 1577 1622 DLY8_5VX1 $T=-496600 -35840 1 0 $X=-497030 $Y=-40960
X42631 5 4 1578 1660 DLY8_5VX1 $T=-496040 -98560 1 0 $X=-496470 $Y=-103680
X42632 5 4 1580 6239 DLY8_5VX1 $T=-494920 -71680 1 0 $X=-495350 $Y=-76800
X42633 5 4 27 1459 DLY8_5VX1 $T=-494360 -152320 1 0 $X=-494790 $Y=-157440
X42634 5 4 1582 1633 DLY8_5VX1 $T=-494360 -80640 1 0 $X=-494790 $Y=-85760
X42635 5 4 6234 2317 DLY8_5VX1 $T=-493240 -170240 0 0 $X=-493670 $Y=-170880
X42636 5 4 28 1634 DLY8_5VX1 $T=-493240 8960 0 0 $X=-493670 $Y=8320
X42637 5 4 1586 1636 DLY8_5VX1 $T=-492680 -152320 0 0 $X=-493110 $Y=-152960
X42638 5 4 6235 1647 DLY8_5VX1 $T=-491560 -134400 0 0 $X=-491990 $Y=-135040
X42639 5 4 1589 1646 DLY8_5VX1 $T=-491000 -161280 1 0 $X=-491430 $Y=-166400
X42640 5 4 1726 1751 DLY8_5VX1 $T=-490440 -197120 0 0 $X=-490870 $Y=-197760
X42641 5 4 1594 2382 DLY8_5VX1 $T=-489880 -206080 0 0 $X=-490310 $Y=-206720
X42642 5 4 1599 1652 DLY8_5VX1 $T=-489320 -62720 0 0 $X=-489750 $Y=-63360
X42643 5 4 1603 1661 DLY8_5VX1 $T=-488760 -89600 1 0 $X=-489190 $Y=-94720
X42644 5 4 7994 7915 DLY8_5VX1 $T=-488200 -179200 1 0 $X=-488630 $Y=-184320
X42645 5 4 1588 1658 DLY8_5VX1 $T=-487640 -170240 1 0 $X=-488070 $Y=-175360
X42646 5 4 1608 1667 DLY8_5VX1 $T=-487080 -17920 1 0 $X=-487510 $Y=-23040
X42647 5 4 1609 1659 DLY8_5VX1 $T=-486520 -143360 0 0 $X=-486950 $Y=-144000
X42648 5 4 1611 1664 DLY8_5VX1 $T=-485960 -188160 0 0 $X=-486390 $Y=-188800
X42649 5 4 1613 2171 DLY8_5VX1 $T=-485960 -116480 0 0 $X=-486390 $Y=-117120
X42650 5 4 1626 1681 DLY8_5VX1 $T=-482600 -179200 0 0 $X=-483030 $Y=-179840
X42651 5 4 1627 1693 DLY8_5VX1 $T=-482600 -161280 0 0 $X=-483030 $Y=-161920
X42652 5 4 1628 1682 DLY8_5VX1 $T=-482040 -143360 1 0 $X=-482470 $Y=-148480
X42653 5 4 2295 2323 DLY8_5VX1 $T=-480920 -188160 1 0 $X=-481350 $Y=-193280
X42654 5 4 1632 1688 DLY8_5VX1 $T=-480360 -224000 1 0 $X=-480790 $Y=-229120
X42655 5 4 1443 1689 DLY8_5VX1 $T=-479800 -197120 1 0 $X=-480230 $Y=-202240
X42656 5 4 1635 1692 DLY8_5VX1 $T=-479240 -232960 1 0 $X=-479670 $Y=-238080
X42657 5 4 1642 6267 DLY8_5VX1 $T=-478680 -170240 0 0 $X=-479110 $Y=-170880
X42658 5 4 1645 7920 DLY8_5VX1 $T=-478120 -224000 0 0 $X=-478550 $Y=-224640
X42659 5 4 6245 1711 DLY8_5VX1 $T=-475880 -215040 0 0 $X=-476310 $Y=-215680
X42660 5 4 1742 6273 DLY8_5VX1 $T=-475880 -197120 0 0 $X=-476310 $Y=-197760
X42661 5 4 1655 1715 DLY8_5VX1 $T=-475320 -206080 0 0 $X=-475750 $Y=-206720
X42662 5 4 1668 2395 DLY8_5VX1 $T=-471960 -241920 0 0 $X=-472390 $Y=-242560
X42663 5 4 6252 1730 DLY8_5VX1 $T=-471960 -53760 0 0 $X=-472390 $Y=-54400
X42664 5 4 2125 1736 DLY8_5VX1 $T=-471400 -188160 0 0 $X=-471830 $Y=-188800
X42665 5 4 7935 1737 DLY8_5VX1 $T=-470840 -134400 1 0 $X=-471270 $Y=-139520
X42666 5 4 1674 1754 DLY8_5VX1 $T=-469160 -250880 0 0 $X=-469590 $Y=-251520
X42667 5 4 1679 1755 DLY8_5VX1 $T=-469160 -215040 1 0 $X=-469590 $Y=-220160
X42668 5 4 1680 6287 DLY8_5VX1 $T=-468600 -206080 1 0 $X=-469030 $Y=-211200
X42669 5 4 1831 1774 DLY8_5VX1 $T=-465800 -224000 1 0 $X=-466230 $Y=-229120
X42670 5 4 1696 1776 DLY8_5VX1 $T=-465240 -250880 1 0 $X=-465670 $Y=-256000
X42671 5 4 1706 6290 DLY8_5VX1 $T=-463560 -224000 0 0 $X=-463990 $Y=-224640
X42672 5 4 1725 6297 DLY8_5VX1 $T=-459640 -241920 1 0 $X=-460070 $Y=-247040
X42673 5 4 7937 7921 DLY8_5VX1 $T=-458520 -232960 1 0 $X=-458950 $Y=-238080
X42674 5 4 1735 1812 DLY8_5VX1 $T=-457400 -259840 1 0 $X=-457830 $Y=-264960
X42675 5 4 1761 1854 DLY8_5VX1 $T=-454600 -250880 0 0 $X=-455030 $Y=-251520
X42676 5 4 2105 2176 DLY8_5VX1 $T=-454600 -179200 1 0 $X=-455030 $Y=-184320
X42677 5 4 2036 1833 DLY8_5VX1 $T=-454040 -89600 1 0 $X=-454470 $Y=-94720
X42678 5 4 50 1852 DLY8_5VX1 $T=-451240 -268800 1 0 $X=-451670 $Y=-273920
X42679 5 4 1781 6308 DLY8_5VX1 $T=-451240 -259840 0 0 $X=-451670 $Y=-260480
X42680 5 4 1788 1846 DLY8_5VX1 $T=-450680 -215040 1 0 $X=-451110 $Y=-220160
X42681 5 4 2192 1859 DLY8_5VX1 $T=-450120 -134400 0 0 $X=-450550 $Y=-135040
X42682 5 4 1849 6429 DLY8_5VX1 $T=-437240 -152320 0 0 $X=-437670 $Y=-152960
X42683 5 4 1861 2073 DLY8_5VX1 $T=-435560 -134400 0 0 $X=-435990 $Y=-135040
X42684 5 4 1883 1925 DLY8_5VX1 $T=-435000 -206080 0 0 $X=-435430 $Y=-206720
X42685 5 4 1873 1949 DLY8_5VX1 $T=-432760 -8960 1 0 $X=-433190 $Y=-14080
X42686 5 4 1904 1963 DLY8_5VX1 $T=-428840 -62720 0 0 $X=-429270 $Y=-63360
X42687 5 4 6340 2004 DLY8_5VX1 $T=-419320 -35840 0 0 $X=-419750 $Y=-36480
X42688 5 4 1952 2001 DLY8_5VX1 $T=-418200 -161280 1 0 $X=-418630 $Y=-166400
X42689 5 4 1948 2007 DLY8_5VX1 $T=-417640 -89600 1 0 $X=-418070 $Y=-94720
X42690 5 4 1959 2272 DLY8_5VX1 $T=-416520 0 0 0 $X=-416950 $Y=-640
X42691 5 4 2373 131 DLY8_5VX1 $T=-400280 -8960 0 0 $X=-400710 $Y=-9600
X42692 5 4 114 2094 DLY8_5VX1 $T=-399720 -268800 1 0 $X=-400150 $Y=-273920
X42693 5 4 2020 6423 DLY8_5VX1 $T=-385160 -268800 1 0 $X=-385590 $Y=-273920
X42694 5 4 2142 6442 DLY8_5VX1 $T=-376200 -206080 0 0 $X=-376630 $Y=-206720
X42695 5 4 2207 2273 DLY8_5VX1 $T=-348200 -259840 1 0 $X=-348630 $Y=-264960
X42696 5 4 2213 2775 DLY8_5VX1 $T=-347080 -143360 1 0 $X=-347510 $Y=-148480
X42697 5 4 2223 2220 DLY8_5VX1 $T=-345400 -206080 1 0 $X=-345830 $Y=-211200
X42698 5 4 2243 2658 DLY8_5VX1 $T=-342040 -53760 1 0 $X=-342470 $Y=-58880
X42699 5 4 2290 2375 DLY8_5VX1 $T=-326920 -197120 1 0 $X=-327350 $Y=-202240
X42700 5 4 2292 2418 DLY8_5VX1 $T=-317960 -71680 0 0 $X=-318390 $Y=-72320
X42701 5 4 2360 2428 DLY8_5VX1 $T=-316280 -107520 1 0 $X=-316710 $Y=-112640
X42702 5 4 6509 2488 DLY8_5VX1 $T=-304520 -206080 1 0 $X=-304950 $Y=-211200
X42703 5 4 2453 2522 DLY8_5VX1 $T=-296680 -224000 1 0 $X=-297110 $Y=-229120
X42704 5 4 2527 2316 DLY8_5VX1 $T=-281560 -232960 1 0 $X=-281990 $Y=-238080
X42705 5 4 2671 2281 DLY8_5VX1 $T=-249080 -161280 0 0 $X=-249510 $Y=-161920
X42706 5 4 6611 2763 DLY8_5VX1 $T=-245720 -98560 1 0 $X=-246150 $Y=-103680
X42707 5 4 2305 2712 DLY8_5VX1 $T=-244600 -26880 0 0 $X=-245030 $Y=-27520
X42708 5 4 321 347 DLY8_5VX1 $T=-229480 -62720 0 0 $X=-229910 $Y=-63360
X42709 5 4 2771 2858 DLY8_5VX1 $T=-228360 -98560 1 0 $X=-228790 $Y=-103680
X42710 5 4 2823 2891 DLY8_5VX1 $T=-221640 -206080 1 0 $X=-222070 $Y=-211200
X42711 5 4 2831 2906 DLY8_5VX1 $T=-219960 -179200 1 0 $X=-220390 $Y=-184320
X42712 5 4 2863 2927 DLY8_5VX1 $T=-214360 -259840 0 0 $X=-214790 $Y=-260480
X42713 5 4 2875 4205 DLY8_5VX1 $T=-208200 -170240 1 0 $X=-208630 $Y=-175360
X42714 5 4 2833 2846 DLY8_5VX1 $T=-206520 -143360 1 0 $X=-206950 $Y=-148480
X42715 5 4 356 375 DLY8_5VX1 $T=-206520 -53760 0 0 $X=-206950 $Y=-54400
X42716 5 4 2910 2909 DLY8_5VX1 $T=-205400 -107520 0 0 $X=-205830 $Y=-108160
X42717 5 4 358 3116 DLY8_5VX1 $T=-201480 -268800 1 0 $X=-201910 $Y=-273920
X42718 5 4 7950 3165 DLY8_5VX1 $T=-193640 -250880 1 0 $X=-194070 $Y=-256000
X42719 5 4 2979 3037 DLY8_5VX1 $T=-190280 -179200 0 0 $X=-190710 $Y=-179840
X42720 5 4 3033 6735 DLY8_5VX1 $T=-177400 -232960 1 0 $X=-177830 $Y=-238080
X42721 5 4 3084 3882 DLY8_5VX1 $T=-171240 -116480 1 0 $X=-171670 $Y=-121600
X42722 5 4 428 3158 DLY8_5VX1 $T=-167320 -62720 0 0 $X=-167750 $Y=-63360
X42723 5 4 424 446 DLY8_5VX1 $T=-166200 -8960 0 0 $X=-166630 $Y=-9600
X42724 5 4 3134 6760 DLY8_5VX1 $T=-157800 -241920 1 0 $X=-158230 $Y=-247040
X42725 5 4 440 469 DLY8_5VX1 $T=-156680 -116480 1 0 $X=-157110 $Y=-121600
X42726 5 4 445 474 DLY8_5VX1 $T=-152760 -62720 0 0 $X=-153190 $Y=-63360
X42727 5 4 498 6821 DLY8_5VX1 $T=-126440 -125440 1 0 $X=-126870 $Y=-130560
X42728 5 4 3193 6871 DLY8_5VX1 $T=-90600 -8960 0 0 $X=-91030 $Y=-9600
X42729 5 4 3118 3377 DLY8_5VX1 $T=-90040 -80640 1 0 $X=-90470 $Y=-85760
X42730 5 4 580 606 DLY8_5VX1 $T=-81080 -98560 1 0 $X=-81510 $Y=-103680
X42731 5 4 3451 4207 DLY8_5VX1 $T=-76040 -134400 0 0 $X=-76470 $Y=-135040
X42732 5 4 3500 3562 DLY8_5VX1 $T=-67080 -188160 1 0 $X=-67510 $Y=-193280
X42733 5 4 3120 3607 DLY8_5VX1 $T=-58120 -152320 1 0 $X=-58550 $Y=-157440
X42734 5 4 631 651 DLY8_5VX1 $T=-57000 -143360 0 0 $X=-57430 $Y=-144000
X42735 5 4 3611 3676 DLY8_5VX1 $T=-43000 -161280 0 0 $X=-43430 $Y=-161920
X42736 5 4 4225 3703 DLY8_5VX1 $T=-36840 -44800 1 0 $X=-37270 $Y=-49920
X42737 5 4 3672 3728 DLY8_5VX1 $T=-31240 8960 1 0 $X=-31670 $Y=3840
X42738 5 4 680 697 DLY8_5VX1 $T=-29560 -116480 0 0 $X=-29990 $Y=-117120
X42739 5 4 1488 3745 DLY8_5VX1 $T=-27880 -161280 1 0 $X=-28310 $Y=-166400
X42740 5 4 3815 3878 DLY8_5VX1 $T=120 -232960 0 0 $X=-310 $Y=-233600
X42741 5 4 3845 7154 DLY8_5VX1 $T=5720 -152320 0 0 $X=5290 $Y=-152960
X42742 5 4 3873 4631 DLY8_5VX1 $T=11880 -44800 0 0 $X=11450 $Y=-45440
X42743 5 4 3902 3877 DLY8_5VX1 $T=18040 -197120 0 0 $X=17610 $Y=-197760
X42744 5 4 3915 3993 DLY8_5VX1 $T=20280 -152320 0 0 $X=19850 $Y=-152960
X42745 5 4 1474 3808 DLY8_5VX1 $T=23640 -250880 0 0 $X=23210 $Y=-251520
X42746 5 4 4092 7125 DLY8_5VX1 $T=52760 -206080 0 0 $X=52330 $Y=-206720
X42747 5 4 4105 4160 DLY8_5VX1 $T=55560 -80640 0 0 $X=55130 $Y=-81280
X42748 5 4 824 862 DLY8_5VX1 $T=55560 -53760 1 0 $X=55130 $Y=-58880
X42749 5 4 831 1495 DLY8_5VX1 $T=60600 -268800 1 0 $X=60170 $Y=-273920
X42750 5 4 4660 4142 DLY8_5VX1 $T=72360 -241920 1 0 $X=71930 $Y=-247040
X42751 5 4 886 909 DLY8_5VX1 $T=75160 -26880 1 0 $X=74730 $Y=-32000
X42752 5 4 897 919 DLY8_5VX1 $T=82440 8960 0 0 $X=82010 $Y=8320
X42753 5 4 4262 4317 DLY8_5VX1 $T=89720 -80640 0 0 $X=89290 $Y=-81280
X42754 5 4 927 952 DLY8_5VX1 $T=100360 8960 1 0 $X=99930 $Y=3840
X42755 5 4 4329 4395 DLY8_5VX1 $T=104280 -250880 1 0 $X=103850 $Y=-256000
X42756 5 4 4337 4406 DLY8_5VX1 $T=105960 -116480 0 0 $X=105530 $Y=-117120
X42757 5 4 4688 4425 DLY8_5VX1 $T=109320 -179200 0 0 $X=108890 $Y=-179840
X42758 5 4 4374 4695 DLY8_5VX1 $T=114920 -215040 0 0 $X=114490 $Y=-215680
X42759 5 4 4428 4492 DLY8_5VX1 $T=123880 -179200 0 0 $X=123450 $Y=-179840
X42760 5 4 4430 4609 DLY8_5VX1 $T=123880 -107520 1 0 $X=123450 $Y=-112640
X42761 5 4 977 1030 DLY8_5VX1 $T=151880 -35840 1 0 $X=151450 $Y=-40960
X42762 5 4 4606 4618 DLY8_5VX1 $T=178200 -197120 1 0 $X=177770 $Y=-202240
X42763 5 4 1087 4628 DLY8_5VX1 $T=186600 -125440 1 0 $X=186170 $Y=-130560
X42764 5 4 4648 4640 DLY8_5VX1 $T=187160 -89600 1 0 $X=186730 $Y=-94720
X42765 5 4 4602 4617 DLY8_5VX1 $T=191640 -206080 0 0 $X=191210 $Y=-206720
X42766 5 4 4588 4597 DLY8_5VX1 $T=193320 -241920 1 0 $X=192890 $Y=-247040
X42767 5 4 4629 4639 DLY8_5VX1 $T=201160 -125440 1 0 $X=200730 $Y=-130560
X42768 5 4 4673 4671 DLY8_5VX1 $T=209000 -232960 1 0 $X=208570 $Y=-238080
X42769 5 4 4635 4625 DLY8_5VX1 $T=220200 -161280 0 0 $X=219770 $Y=-161920
X42770 5 4 4559 4687 DLY8_5VX1 $T=234200 -241920 1 0 $X=233770 $Y=-247040
X42771 5 4 4644 4689 DLY8_5VX1 $T=244280 -188160 0 0 $X=243850 $Y=-188800
X42772 5 4 4659 4656 DLY8_5VX1 $T=250440 -224000 1 0 $X=250010 $Y=-229120
X42773 5 4 4607 4699 DLY8_5VX1 $T=261080 -179200 1 0 $X=260650 $Y=-184320
X42774 5 4 4619 4633 DLY8_5VX1 $T=262760 -143360 0 0 $X=262330 $Y=-144000
X42775 5 4 7390 4717 DLY8_5VX1 $T=265000 -224000 1 0 $X=264570 $Y=-229120
X42776 5 4 1234 1242 DLY8_5VX1 $T=289640 0 0 0 $X=289210 $Y=-640
X42777 5 4 4637 5266 DLY8_5VX1 $T=292440 -98560 1 0 $X=292010 $Y=-103680
X42778 5 4 4626 4632 DLY8_5VX1 $T=295240 -17920 1 0 $X=294810 $Y=-23040
X42779 5 4 5245 4681 DLY8_5VX1 $T=302520 -161280 0 0 $X=302090 $Y=-161920
X42780 5 4 5248 3820 DLY8_5VX1 $T=303080 -259840 0 0 $X=302650 $Y=-260480
X42781 5 4 1154 5299 DLY8_5VX1 $T=311480 -98560 0 0 $X=311050 $Y=-99200
X42782 5 4 4649 4745 DLY8_5VX1 $T=331640 -215040 0 0 $X=331210 $Y=-215680
X42783 5 4 1283 1304 DLY8_5VX1 $T=340600 0 0 0 $X=340170 $Y=-640
X42784 5 4 5465 5355 DLY8_5VX1 $T=353480 -241920 1 0 $X=353050 $Y=-247040
X42785 5 4 4710 3876 DLY8_5VX1 $T=354600 -170240 1 0 $X=354170 $Y=-175360
X42786 5 4 4692 5547 DLY8_5VX1 $T=356840 -62720 0 0 $X=356410 $Y=-63360
X42787 5 4 4614 5556 DLY8_5VX1 $T=359080 -98560 0 0 $X=358650 $Y=-99200
X42788 5 4 4715 4705 DLY8_5VX1 $T=369720 0 1 0 $X=369290 $Y=-5120
X42789 5 4 1301 5061 DLY8_5VX1 $T=401640 -268800 1 0 $X=401210 $Y=-273920
X42790 5 4 5447 5309 DLY8_5VX1 $T=401640 -143360 0 0 $X=401210 $Y=-144000
X42791 5 4 7652 5548 DLY8_5VX1 $T=401640 -26880 1 0 $X=401210 $Y=-32000
X42792 5 4 1337 5587 DLY8_5VX1 $T=416200 -268800 1 0 $X=415770 $Y=-273920
X42793 5 4 5691 5572 DLY8_5VX1 $T=418440 -188160 0 0 $X=418010 $Y=-188800
X42794 5 4 7688 5574 DLY8_5VX1 $T=426280 -152320 0 0 $X=425850 $Y=-152960
X42795 5 4 5425 5939 DLY8_5VX1 $T=456520 -62720 1 0 $X=456090 $Y=-67840
X42796 5 4 7757 5588 DLY8_5VX1 $T=457080 -259840 0 0 $X=456650 $Y=-260480
X42797 5 4 5439 5479 DLY8_5VX1 $T=458760 -143360 1 0 $X=458330 $Y=-148480
X42798 5 4 5918 5516 DLY8_5VX1 $T=463240 -44800 0 0 $X=462810 $Y=-45440
X42799 5 4 7775 5559 DLY8_5VX1 $T=464920 -98560 0 0 $X=464490 $Y=-99200
X42800 5 4 6016 5582 DLY8_5VX1 $T=467720 -232960 1 0 $X=467290 $Y=-238080
X42801 5 4 7803 5549 DLY8_5VX1 $T=479480 -98560 0 0 $X=479050 $Y=-99200
X42802 5 4 5987 4842 DLY8_5VX1 $T=480600 -26880 1 0 $X=480170 $Y=-32000
X42803 5 4 5857 5852 DLY8_5VX1 $T=488440 -161280 1 0 $X=488010 $Y=-166400
X42804 5 4 6026 5483 DLY8_5VX1 $T=489560 -206080 0 0 $X=489130 $Y=-206720
X42805 5 4 6047 4708 DLY8_5VX1 $T=495160 -26880 1 0 $X=494730 $Y=-32000
X42806 5 4 6058 5078 DLY8_5VX1 $T=496840 -8960 1 0 $X=496410 $Y=-14080
X42807 5 4 7845 5880 DLY8_5VX1 $T=505240 -170240 0 0 $X=504810 $Y=-170880
X42808 5 4 5423 4579 DLY8_5VX1 $T=505800 -44800 0 0 $X=505370 $Y=-45440
X42809 5 4 5829 5846 DLY8_5VX1 $T=509720 -26880 1 0 $X=509290 $Y=-32000
X42810 5 4 6108 5873 DLY8_5VX1 $T=512520 -143360 1 0 $X=512090 $Y=-148480
X42811 5 4 5604 7588 DLY8_5VX1 $T=513080 -8960 0 0 $X=512650 $Y=-9600
X42812 5 4 5799 7590 DLY8_5VX1 $T=513080 0 0 0 $X=512650 $Y=-640
X42813 5 4 5826 5816 DLY8_5VX1 $T=514760 -17920 0 0 $X=514330 $Y=-18560
X42814 5 4 6128 5468 DLY8_5VX1 $T=515320 -197120 0 0 $X=514890 $Y=-197760
X42815 5 4 1162 7762 DLY8_5VX1 $T=515320 8960 0 0 $X=514890 $Y=8320
X42816 5 4 6156 6200 DLY8_5VX1 $T=518680 -17920 1 0 $X=518250 $Y=-23040
X42817 5 4 7885 7615 DLY8_5VX1 $T=519800 -62720 1 0 $X=519370 $Y=-67840
X42818 5 4 6163 6133 DLY8_5VX1 $T=519800 0 1 0 $X=519370 $Y=-5120
X42819 5 4 6161 1527 DLY8_5VX1 $T=520360 -44800 0 0 $X=519930 $Y=-45440
X42820 5 4 7895 5824 DLY8_5VX1 $T=520920 -107520 1 0 $X=520490 $Y=-112640
X42821 5 4 5440 4825 DLY8_5VX1 $T=523720 -80640 1 0 $X=523290 $Y=-85760
X42822 5 4 6174 5470 DLY8_5VX1 $T=524280 -26880 1 0 $X=523850 $Y=-32000
X42823 5 4 5517 5495 DLY8_5VX1 $T=524840 8960 1 0 $X=524410 $Y=3840
X42824 5 4 5819 5843 DLY8_5VX1 $T=525400 -53760 1 0 $X=524970 $Y=-58880
X42825 5 4 6095 5862 DLY8_5VX1 $T=526520 -152320 1 0 $X=526090 $Y=-157440
X42826 5 4 7909 5553 DLY8_5VX1 $T=526520 -44800 1 0 $X=526090 $Y=-49920
X42827 5 4 6084 5872 DLY8_5VX1 $T=527080 -143360 1 0 $X=526650 $Y=-148480
X42828 5 4 5835 7750 DLY8_5VX1 $T=527640 -71680 1 0 $X=527210 $Y=-76800
X42829 5 4 6183 5521 DLY8_5VX1 $T=527640 -8960 0 0 $X=527210 $Y=-9600
X42830 5 4 6185 5839 DLY8_5VX1 $T=529880 -89600 1 0 $X=529450 $Y=-94720
X42831 5 4 1425 6219 DLY8_5VX1 $T=529880 8960 0 0 $X=529450 $Y=8320
X42832 5 4 6154 5463 DLY8_5VX1 $T=530440 -116480 1 0 $X=530010 $Y=-121600
X42833 5 4 6160 5558 DLY8_5VX1 $T=531560 -125440 1 0 $X=531130 $Y=-130560
X42834 5 4 6197 6180 DLY8_5VX1 $T=531560 -62720 0 0 $X=531130 $Y=-63360
X42835 5 4 6198 5507 DLY8_5VX1 $T=532120 -179200 1 0 $X=531690 $Y=-184320
X42836 5 4 6201 7897 DLY8_5VX1 $T=532680 -188160 1 0 $X=532250 $Y=-193280
X42837 5 4 6202 5621 DLY8_5VX1 $T=532680 -143360 0 0 $X=532250 $Y=-144000
X42838 5 4 6204 5616 DLY8_5VX1 $T=533240 -134400 1 0 $X=532810 $Y=-139520
X42839 5 4 6205 6168 DLY8_5VX1 $T=533240 -53760 0 0 $X=532810 $Y=-54400
X42840 5 4 6209 6191 DLY8_5VX1 $T=534360 -80640 0 0 $X=533930 $Y=-81280
X42841 5 4 4972 5494 DLY8_5VX1 $T=534920 -71680 0 0 $X=534490 $Y=-72320
X42842 5 4 7913 5617 DLY8_5VX1 $T=535480 -107520 1 0 $X=535050 $Y=-112640
X42843 5 4 6211 5546 DLY8_5VX1 $T=537160 -116480 0 0 $X=536730 $Y=-117120
X42844 5 4 6213 7992 DLY8_5VX1 $T=539400 -89600 0 0 $X=538970 $Y=-90240
X42845 5 4 6214 6207 DLY8_5VX1 $T=539960 -161280 0 0 $X=539530 $Y=-161920
X42846 5 4 6215 6208 DLY8_5VX1 $T=539960 -98560 0 0 $X=539530 $Y=-99200
X42847 5 4 6216 7912 DLY8_5VX1 $T=540520 -170240 1 0 $X=540090 $Y=-175360
X42848 5 4 6218 6210 DLY8_5VX1 $T=541640 -134400 0 0 $X=541210 $Y=-135040
X42849 5 4 6222 6199 DLY8_5VX1 $T=545000 -116480 1 0 $X=544570 $Y=-121600
X42850 5 4 6223 5605 DLY8_5VX1 $T=547240 -89600 1 0 $X=546810 $Y=-94720
X42851 5 4 6224 7914 DLY8_5VX1 $T=547800 -134400 1 0 $X=547370 $Y=-139520
X42852 5 4 7 13 BU_5VX3 $T=-523480 -62720 1 0 $X=-523910 $Y=-67840
X42853 5 4 103 2015 BU_5VX3 $T=-405880 -8960 0 0 $X=-406310 $Y=-9600
X42854 5 4 13 157 BU_5VX3 $T=-368920 -71680 0 0 $X=-369350 $Y=-72320
X42855 5 4 244 1584 BU_5VX3 $T=-270920 -17920 1 0 $X=-271350 $Y=-23040
X42856 5 4 3001 3324 BU_5VX3 $T=-186920 -152320 0 0 $X=-187350 $Y=-152960
X42857 5 4 3010 388 BU_5VX3 $T=-185800 -125440 1 0 $X=-186230 $Y=-130560
X42858 5 4 395 1674 BU_5VX3 $T=-179640 -89600 0 0 $X=-180070 $Y=-90240
X42859 5 4 438 442 BU_5VX3 $T=-157800 -80640 0 0 $X=-158230 $Y=-81280
X42860 5 4 454 461 BU_5VX3 $T=-147720 -134400 0 0 $X=-148150 $Y=-135040
X42861 5 4 3262 492 BU_5VX3 $T=-129800 -224000 0 0 $X=-130230 $Y=-224640
X42862 5 4 493 3001 BU_5VX3 $T=-127560 -53760 0 0 $X=-127990 $Y=-54400
X42863 5 4 3335 554 BU_5VX3 $T=-97880 -161280 1 0 $X=-98310 $Y=-166400
X42864 5 4 539 3327 BU_5VX3 $T=-97880 -44800 1 0 $X=-98310 $Y=-49920
X42865 5 4 3450 4213 BU_5VX3 $T=-76040 -143360 1 0 $X=-76470 $Y=-148480
X42866 5 4 636 3010 BU_5VX3 $T=-53640 8960 1 0 $X=-54070 $Y=3840
X42867 5 4 3413 1496 BU_5VX3 $T=-45240 -44800 0 180 $X=-51270 $Y=-49920
X42868 5 4 3414 624 BU_5VX3 $T=-41320 -116480 1 180 $X=-47350 $Y=-117120
X42869 5 4 3407 1489 BU_5VX3 $T=-37400 -62720 0 0 $X=-37830 $Y=-63360
X42870 5 4 678 685 BU_5VX3 $T=-29000 -71680 1 0 $X=-29430 $Y=-76800
X42871 5 4 3385 3504 BU_5VX3 $T=-20600 -53760 1 0 $X=-21030 $Y=-58880
X42872 5 4 703 708 BU_5VX3 $T=-11080 -17920 0 0 $X=-11510 $Y=-18560
X42873 5 4 4139 3895 BU_5VX3 $T=12440 -197120 0 0 $X=12010 $Y=-197760
X42874 5 4 4007 4064 BU_5VX3 $T=36520 -197120 0 0 $X=36090 $Y=-197760
X42875 5 4 4084 848 BU_5VX3 $T=62840 -152320 1 0 $X=62410 $Y=-157440
X42876 5 4 4213 904 BU_5VX3 $T=83560 -232960 1 0 $X=83130 $Y=-238080
X42877 5 4 913 4276 BU_5VX3 $T=91400 -26880 1 0 $X=90970 $Y=-32000
X42878 5 4 4169 4233 BU_5VX3 $T=98680 -152320 1 0 $X=98250 $Y=-157440
X42879 5 4 4113 4359 BU_5VX3 $T=107080 -80640 0 0 $X=106650 $Y=-81280
X42880 5 4 4132 4532 BU_5VX3 $T=156360 -89600 0 0 $X=155930 $Y=-90240
X42881 5 4 4048 4582 BU_5VX3 $T=166440 -35840 0 0 $X=166010 $Y=-36480
X42882 5 4 1146 4858 BU_5VX3 $T=220200 -98560 1 0 $X=219770 $Y=-103680
X42883 5 4 1150 1153 BU_5VX3 $T=229720 -53760 0 0 $X=229290 $Y=-54400
X42884 5 4 4276 5256 BU_5VX3 $T=301400 -89600 1 0 $X=300970 $Y=-94720
X42885 5 4 1532 7993 DLY1_5VX1 $T=-513400 -8960 0 0 $X=-513830 $Y=-9600
X42886 5 4 1534 6230 DLY1_5VX1 $T=-512280 -26880 1 0 $X=-512710 $Y=-32000
X42887 5 4 1535 6231 DLY1_5VX1 $T=-511720 -53760 1 0 $X=-512150 $Y=-58880
X42888 5 4 26 1538 DLY1_5VX1 $T=-509480 -116480 0 0 $X=-509910 $Y=-117120
X42889 5 4 1539 7933 DLY1_5VX1 $T=-509480 -98560 0 0 $X=-509910 $Y=-99200
X42890 5 4 1552 6232 DLY1_5VX1 $T=-503880 -107520 0 0 $X=-504310 $Y=-108160
X42891 5 4 1559 6233 DLY1_5VX1 $T=-502760 -143360 1 0 $X=-503190 $Y=-148480
X42892 5 4 1560 1556 DLY1_5VX1 $T=-502760 -98560 1 0 $X=-503190 $Y=-103680
X42893 5 4 1561 1641 DLY1_5VX1 $T=-502760 -62720 1 0 $X=-503190 $Y=-67840
X42894 5 4 1566 6234 DLY1_5VX1 $T=-499400 -170240 0 0 $X=-499830 $Y=-170880
X42895 5 4 1571 1567 DLY1_5VX1 $T=-498840 -134400 0 0 $X=-499270 $Y=-135040
X42896 5 4 1579 6235 DLY1_5VX1 $T=-495480 -134400 1 0 $X=-495910 $Y=-139520
X42897 5 4 2350 7994 DLY1_5VX1 $T=-494360 -179200 1 0 $X=-494790 $Y=-184320
X42898 5 4 1610 1443 DLY1_5VX1 $T=-485960 -197120 1 0 $X=-486390 $Y=-202240
X42899 5 4 1624 1648 DLY1_5VX1 $T=-483160 -116480 1 0 $X=-483590 $Y=-121600
X42900 5 4 1630 6245 DLY1_5VX1 $T=-482040 -215040 0 0 $X=-482470 $Y=-215680
X42901 5 4 6241 1629 DLY1_5VX1 $T=-480920 0 1 0 $X=-481350 $Y=-5120
X42902 5 4 1638 1642 DLY1_5VX1 $T=-479800 -152320 1 0 $X=-480230 $Y=-157440
X42903 5 4 6242 1640 DLY1_5VX1 $T=-478680 -8960 1 0 $X=-479110 $Y=-14080
X42904 5 4 6243 1651 DLY1_5VX1 $T=-477000 -89600 0 0 $X=-477430 $Y=-90240
X42905 5 4 1593 1671 DLY1_5VX1 $T=-476440 -53760 1 0 $X=-476870 $Y=-58880
X42906 5 4 1657 1655 DLY1_5VX1 $T=-474760 -206080 1 0 $X=-475190 $Y=-211200
X42907 5 4 1813 7937 DLY1_5VX1 $T=-464680 -232960 1 0 $X=-465110 $Y=-238080
X42908 5 4 1702 1699 DLY1_5VX1 $T=-464120 -161280 0 0 $X=-464550 $Y=-161920
X42909 5 4 1750 1735 DLY1_5VX1 $T=-456840 -268800 0 0 $X=-457270 $Y=-269440
X42910 5 4 6292 1717 DLY1_5VX1 $T=-450120 -206080 1 0 $X=-450550 $Y=-211200
X42911 5 4 6296 1782 DLY1_5VX1 $T=-442280 -232960 0 0 $X=-442710 $Y=-233600
X42912 5 4 6312 1853 DLY1_5VX1 $T=-435560 -241920 1 0 $X=-435990 $Y=-247040
X42913 5 4 1553 78 DLY1_5VX1 $T=-426040 -98560 0 0 $X=-426470 $Y=-99200
X42914 5 4 1942 1948 DLY1_5VX1 $T=-420440 -89600 0 0 $X=-420870 $Y=-90240
X42915 5 4 1970 98 DLY1_5VX1 $T=-413160 -107520 1 0 $X=-413590 $Y=-112640
X42916 5 4 1997 108 DLY1_5VX1 $T=-407000 -62720 0 0 $X=-407430 $Y=-63360
X42917 5 4 109 1994 DLY1_5VX1 $T=-404760 -125440 1 0 $X=-405190 $Y=-130560
X42918 5 4 1442 125 DLY1_5VX1 $T=-396360 -44800 0 0 $X=-396790 $Y=-45440
X42919 5 4 2147 2169 DLY1_5VX1 $T=-375640 -89600 0 0 $X=-376070 $Y=-90240
X42920 5 4 2170 2142 DLY1_5VX1 $T=-370600 -188160 1 0 $X=-371030 $Y=-193280
X42921 5 4 1541 160 DLY1_5VX1 $T=-367800 -8960 0 0 $X=-368230 $Y=-9600
X42922 5 4 2206 164 DLY1_5VX1 $T=-348200 -53760 1 0 $X=-348630 $Y=-58880
X42923 5 4 2214 2207 DLY1_5VX1 $T=-347640 -250880 0 0 $X=-348070 $Y=-251520
X42924 5 4 1558 162 DLY1_5VX1 $T=-347640 -17920 1 0 $X=-348070 $Y=-23040
X42925 5 4 2193 167 DLY1_5VX1 $T=-347080 -35840 0 0 $X=-347510 $Y=-36480
X42926 5 4 2224 1540 DLY1_5VX1 $T=-342040 -107520 0 0 $X=-342470 $Y=-108160
X42927 5 4 6472 6611 DLY1_5VX1 $T=-331960 -53760 0 0 $X=-332390 $Y=-54400
X42928 5 4 183 1635 DLY1_5VX1 $T=-326360 -179200 1 0 $X=-326790 $Y=-184320
X42929 5 4 1754 200 DLY1_5VX1 $T=-312920 -241920 0 0 $X=-313350 $Y=-242560
X42930 5 4 205 2077 DLY1_5VX1 $T=-303400 -152320 0 0 $X=-303830 $Y=-152960
X42931 5 4 2497 2525 DLY1_5VX1 $T=-288280 -134400 1 0 $X=-288710 $Y=-139520
X42932 5 4 226 229 DLY1_5VX1 $T=-287720 -116480 1 0 $X=-288150 $Y=-121600
X42933 5 4 231 237 DLY1_5VX1 $T=-282680 -107520 1 0 $X=-283110 $Y=-112640
X42934 5 4 1692 239 DLY1_5VX1 $T=-279880 -80640 0 0 $X=-280310 $Y=-81280
X42935 5 4 2558 2534 DLY1_5VX1 $T=-275960 -197120 1 0 $X=-276390 $Y=-202240
X42936 5 4 243 246 DLY1_5VX1 $T=-275400 -188160 0 0 $X=-275830 $Y=-188800
X42937 5 4 253 262 DLY1_5VX1 $T=-264200 -26880 1 0 $X=-264630 $Y=-32000
X42938 5 4 2076 263 DLY1_5VX1 $T=-262520 -71680 0 0 $X=-262950 $Y=-72320
X42939 5 4 2657 1713 DLY1_5VX1 $T=-256920 -116480 1 0 $X=-257350 $Y=-121600
X42940 5 4 273 282 DLY1_5VX1 $T=-254120 -250880 1 0 $X=-254550 $Y=-256000
X42941 5 4 2700 2723 DLY1_5VX1 $T=-246280 -241920 1 0 $X=-246710 $Y=-247040
X42942 5 4 2704 6620 DLY1_5VX1 $T=-245720 -179200 1 0 $X=-246150 $Y=-184320
X42943 5 4 289 302 DLY1_5VX1 $T=-244600 -215040 1 0 $X=-245030 $Y=-220160
X42944 5 4 300 2734 DLY1_5VX1 $T=-242920 8960 1 0 $X=-243350 $Y=3840
X42945 5 4 2752 2771 DLY1_5VX1 $T=-236200 -62720 1 0 $X=-236630 $Y=-67840
X42946 5 4 2757 2778 DLY1_5VX1 $T=-228360 -125440 0 0 $X=-228790 $Y=-126080
X42947 5 4 330 2792 DLY1_5VX1 $T=-226120 0 1 0 $X=-226550 $Y=-5120
X42948 5 4 2811 2167 DLY1_5VX1 $T=-225000 -224000 0 0 $X=-225430 $Y=-224640
X42949 5 4 348 351 DLY1_5VX1 $T=-215480 -107520 0 0 $X=-215910 $Y=-108160
X42950 5 4 2948 7950 DLY1_5VX1 $T=-197560 -241920 1 0 $X=-197990 $Y=-247040
X42951 5 4 376 2859 DLY1_5VX1 $T=-191400 -53760 1 0 $X=-191830 $Y=-58880
X42952 5 4 2871 3030 DLY1_5VX1 $T=-179640 -161280 0 0 $X=-180070 $Y=-161920
X42953 5 4 409 3075 DLY1_5VX1 $T=-176840 -71680 0 0 $X=-177270 $Y=-72320
X42954 5 4 420 3081 DLY1_5VX1 $T=-171240 -188160 0 0 $X=-171670 $Y=-188800
X42955 5 4 421 430 DLY1_5VX1 $T=-170680 -80640 1 0 $X=-171110 $Y=-85760
X42956 5 4 437 444 DLY1_5VX1 $T=-159480 -268800 1 0 $X=-159910 $Y=-273920
X42957 5 4 2723 2497 DLY1_5VX1 $T=-158360 -188160 1 0 $X=-158790 $Y=-193280
X42958 5 4 451 3172 DLY1_5VX1 $T=-152760 -161280 1 0 $X=-153190 $Y=-166400
X42959 5 4 3281 3286 DLY1_5VX1 $T=-125880 -179200 1 0 $X=-126310 $Y=-184320
X42960 5 4 3264 3134 DLY1_5VX1 $T=-123640 -268800 0 0 $X=-124070 $Y=-269440
X42961 5 4 3219 3323 DLY1_5VX1 $T=-120280 -35840 1 0 $X=-120710 $Y=-40960
X42962 5 4 526 2894 DLY1_5VX1 $T=-118600 -215040 0 0 $X=-119030 $Y=-215680
X42963 5 4 549 3281 DLY1_5VX1 $T=-97880 -259840 1 0 $X=-98310 $Y=-264960
X42964 5 4 550 3356 DLY1_5VX1 $T=-97880 -250880 1 0 $X=-98310 $Y=-256000
X42965 5 4 551 2621 DLY1_5VX1 $T=-97880 -241920 1 0 $X=-98310 $Y=-247040
X42966 5 4 6620 3329 DLY1_5VX1 $T=-97880 -17920 1 0 $X=-98310 $Y=-23040
X42967 5 4 2623 3291 DLY1_5VX1 $T=-97880 -8960 0 0 $X=-98310 $Y=-9600
X42968 5 4 552 4187 DLY1_5VX1 $T=-96760 -268800 0 0 $X=-97190 $Y=-269440
X42969 5 4 3341 3363 DLY1_5VX1 $T=-96200 -80640 1 0 $X=-96630 $Y=-85760
X42970 5 4 560 2715 DLY1_5VX1 $T=-93400 -224000 0 0 $X=-93830 $Y=-224640
X42971 5 4 567 3389 DLY1_5VX1 $T=-90040 -259840 1 0 $X=-90470 $Y=-264960
X42972 5 4 3453 3485 DLY1_5VX1 $T=-75480 -71680 0 0 $X=-75910 $Y=-72320
X42973 5 4 597 601 DLY1_5VX1 $T=-74360 0 1 0 $X=-74790 $Y=-5120
X42974 5 4 3502 3439 DLY1_5VX1 $T=-67080 -107520 1 0 $X=-67510 $Y=-112640
X42975 5 4 3531 3417 DLY1_5VX1 $T=-63160 -143360 0 0 $X=-63590 $Y=-144000
X42976 5 4 630 3335 DLY1_5VX1 $T=-58680 -17920 1 0 $X=-59110 $Y=-23040
X42977 5 4 3557 3333 DLY1_5VX1 $T=-56440 -26880 0 0 $X=-56870 $Y=-27520
X42978 5 4 3389 640 DLY1_5VX1 $T=-54200 -188160 0 0 $X=-54630 $Y=-188800
X42979 5 4 3578 3716 DLY1_5VX1 $T=-49720 -188160 1 0 $X=-50150 $Y=-193280
X42980 5 4 643 648 DLY1_5VX1 $T=-49160 -206080 0 0 $X=-49590 $Y=-206720
X42981 5 4 3605 3380 DLY1_5VX1 $T=-45240 -89600 1 0 $X=-45670 $Y=-94720
X42982 5 4 665 3652 DLY1_5VX1 $T=-39640 -259840 1 0 $X=-40070 $Y=-264960
X42983 5 4 3844 3611 DLY1_5VX1 $T=-36840 -170240 0 0 $X=-37270 $Y=-170880
X42984 5 4 6986 3687 DLY1_5VX1 $T=-32360 -206080 0 0 $X=-32790 $Y=-206720
X42985 5 4 3670 688 DLY1_5VX1 $T=-31240 -250880 1 0 $X=-31670 $Y=-256000
X42986 5 4 687 3577 DLY1_5VX1 $T=-27880 -250880 0 0 $X=-28310 $Y=-251520
X42987 5 4 692 3734 DLY1_5VX1 $T=-21160 -224000 1 0 $X=-21590 $Y=-229120
X42988 5 4 3721 3799 DLY1_5VX1 $T=-19480 -250880 1 0 $X=-19910 $Y=-256000
X42989 5 4 701 3450 DLY1_5VX1 $T=-16120 8960 0 0 $X=-16550 $Y=8320
X42990 5 4 3778 3449 DLY1_5VX1 $T=-3240 -134400 0 0 $X=-3670 $Y=-135040
X42991 5 4 766 775 DLY1_5VX1 $T=13000 -259840 0 0 $X=12570 $Y=-260480
X42992 5 4 3890 3909 DLY1_5VX1 $T=14680 -62720 0 0 $X=14250 $Y=-63360
X42993 5 4 3903 3670 DLY1_5VX1 $T=18600 -134400 0 0 $X=18170 $Y=-135040
X42994 5 4 7046 3921 DLY1_5VX1 $T=18600 -89600 0 0 $X=18170 $Y=-90240
X42995 5 4 3884 3855 DLY1_5VX1 $T=30360 -197120 1 0 $X=29930 $Y=-202240
X42996 5 4 4014 4152 DLY1_5VX1 $T=38200 -89600 0 0 $X=37770 $Y=-90240
X42997 5 4 4157 4062 DLY1_5VX1 $T=43240 -80640 0 0 $X=42810 $Y=-81280
X42998 5 4 4070 4094 DLY1_5VX1 $T=49400 -71680 1 0 $X=48970 $Y=-76800
X42999 5 4 4081 4104 DLY1_5VX1 $T=51080 -107520 1 0 $X=50650 $Y=-112640
X43000 5 4 4100 4121 DLY1_5VX1 $T=54440 -116480 0 0 $X=54010 $Y=-117120
X43001 5 4 829 4138 DLY1_5VX1 $T=57800 -161280 0 0 $X=57370 $Y=-161920
X43002 5 4 4156 4171 DLY1_5VX1 $T=67320 -107520 0 0 $X=66890 $Y=-108160
X43003 5 4 4174 4141 DLY1_5VX1 $T=81880 -215040 0 0 $X=81450 $Y=-215680
X43004 5 4 899 7136 DLY1_5VX1 $T=83000 -134400 0 0 $X=82570 $Y=-135040
X43005 5 4 4263 4176 DLY1_5VX1 $T=91400 -62720 0 0 $X=90970 $Y=-63360
X43006 5 4 4182 925 DLY1_5VX1 $T=94200 -259840 0 0 $X=93770 $Y=-260480
X43007 5 4 4328 4350 DLY1_5VX1 $T=103160 -179200 1 0 $X=102730 $Y=-184320
X43008 5 4 4371 4148 DLY1_5VX1 $T=112120 -44800 1 0 $X=111690 $Y=-49920
X43009 5 4 4138 3396 DLY1_5VX1 $T=118840 -232960 1 0 $X=118410 $Y=-238080
X43010 5 4 4475 4485 DLY1_5VX1 $T=132280 8960 0 0 $X=131850 $Y=8320
X43011 5 4 4504 4527 DLY1_5VX1 $T=151880 -98560 1 0 $X=151450 $Y=-103680
X43012 5 4 4500 4471 DLY1_5VX1 $T=151880 -80640 1 0 $X=151450 $Y=-85760
X43013 5 4 5281 4565 DLY1_5VX1 $T=160840 -98560 0 0 $X=160410 $Y=-99200
X43014 5 4 4549 4566 DLY1_5VX1 $T=161960 -62720 0 0 $X=161530 $Y=-63360
X43015 5 4 4501 4234 DLY1_5VX1 $T=167000 -44800 1 0 $X=166570 $Y=-49920
X43016 5 4 1042 4263 DLY1_5VX1 $T=169240 -241920 0 0 $X=168810 $Y=-242560
X43017 5 4 4724 4747 DLY1_5VX1 $T=201720 -250880 0 0 $X=201290 $Y=-251520
X43018 5 4 4763 4787 DLY1_5VX1 $T=214040 -143360 0 0 $X=213610 $Y=-144000
X43019 5 4 4599 4500 DLY1_5VX1 $T=215720 -125440 1 0 $X=215290 $Y=-130560
X43020 5 4 4735 4838 DLY1_5VX1 $T=217400 -53760 1 0 $X=216970 $Y=-58880
X43021 5 4 4146 4145 DLY1_5VX1 $T=227480 -206080 0 0 $X=227050 $Y=-206720
X43022 5 4 4930 4505 DLY1_5VX1 $T=238680 -134400 0 0 $X=238250 $Y=-135040
X43023 5 4 4934 4958 DLY1_5VX1 $T=239800 -143360 0 0 $X=239370 $Y=-144000
X43024 5 4 5003 5023 DLY1_5VX1 $T=251000 -134400 1 0 $X=250570 $Y=-139520
X43025 5 4 5019 4913 DLY1_5VX1 $T=255480 0 1 0 $X=255050 $Y=-5120
X43026 5 4 4556 5034 DLY1_5VX1 $T=256040 -71680 1 0 $X=255610 $Y=-76800
X43027 5 4 4794 4832 DLY1_5VX1 $T=258840 -71680 0 0 $X=258410 $Y=-72320
X43028 5 4 7969 4591 DLY1_5VX1 $T=259960 -44800 0 0 $X=259530 $Y=-45440
X43029 5 4 5084 5111 DLY1_5VX1 $T=271720 -116480 1 0 $X=271290 $Y=-121600
X43030 5 4 5069 5057 DLY1_5VX1 $T=276760 -179200 0 0 $X=276330 $Y=-179840
X43031 5 4 5070 5129 DLY1_5VX1 $T=277320 -152320 1 0 $X=276890 $Y=-157440
X43032 5 4 4359 1227 DLY1_5VX1 $T=279560 -224000 1 0 $X=279130 $Y=-229120
X43033 5 4 5113 5178 DLY1_5VX1 $T=281800 0 0 0 $X=281370 $Y=-640
X43034 5 4 5059 5058 DLY1_5VX1 $T=290760 -143360 0 0 $X=290330 $Y=-144000
X43035 5 4 7931 4423 DLY1_5VX1 $T=290760 -53760 0 0 $X=290330 $Y=-54400
X43036 5 4 5212 5056 DLY1_5VX1 $T=294120 -188160 0 0 $X=293690 $Y=-188800
X43037 5 4 5235 5093 DLY1_5VX1 $T=299160 -161280 1 0 $X=298730 $Y=-166400
X43038 5 4 5133 7316 DLY1_5VX1 $T=304200 0 0 0 $X=303770 $Y=-640
X43039 5 4 4738 5281 DLY1_5VX1 $T=304760 -62720 1 0 $X=304330 $Y=-67840
X43040 5 4 5665 4854 DLY1_5VX1 $T=305880 8960 0 0 $X=305450 $Y=8320
X43041 5 4 5310 4522 DLY1_5VX1 $T=317640 -26880 0 0 $X=317210 $Y=-27520
X43042 5 4 4558 4504 DLY1_5VX1 $T=327720 -62720 1 0 $X=327290 $Y=-67840
X43043 5 4 5352 1276 DLY1_5VX1 $T=328280 -179200 0 0 $X=327850 $Y=-179840
X43044 5 4 5406 4615 DLY1_5VX1 $T=337800 -161280 0 0 $X=337370 $Y=-161920
X43045 5 4 4524 4930 DLY1_5VX1 $T=348440 -125440 0 0 $X=348010 $Y=-126080
X43046 5 4 5679 1302 DLY1_5VX1 $T=350120 -89600 1 0 $X=349690 $Y=-94720
X43047 5 4 4546 7931 DLY1_5VX1 $T=356840 -53760 0 0 $X=356410 $Y=-54400
X43048 5 4 5480 5433 DLY1_5VX1 $T=357400 -17920 1 0 $X=356970 $Y=-23040
X43049 5 4 1324 7668 DLY1_5VX1 $T=401640 -62720 1 0 $X=401210 $Y=-67840
X43050 5 4 4759 5665 DLY1_5VX1 $T=401640 8960 1 0 $X=401210 $Y=3840
X43051 5 4 5677 5691 DLY1_5VX1 $T=410040 -188160 1 0 $X=409610 $Y=-193280
X43052 5 4 5583 7688 DLY1_5VX1 $T=416760 -143360 0 0 $X=416330 $Y=-144000
X43053 5 4 5577 1337 DLY1_5VX1 $T=430760 -268800 1 0 $X=430330 $Y=-273920
X43054 5 4 5565 7757 DLY1_5VX1 $T=450360 -250880 1 0 $X=449930 $Y=-256000
X43055 5 4 1384 5913 DLY1_5VX1 $T=457640 -134400 0 0 $X=457210 $Y=-135040
X43056 5 4 4858 7807 DLY1_5VX1 $T=475560 -161280 1 0 $X=475130 $Y=-166400
X43057 5 4 5533 7885 DLY1_5VX1 $T=512520 -71680 1 0 $X=512090 $Y=-76800
X43058 5 4 7886 6151 DLY1_5VX1 $T=519240 -206080 0 0 $X=518810 $Y=-206720
X43059 5 4 6142 6156 DLY1_5VX1 $T=523720 -26880 0 0 $X=523290 $Y=-27520
X43060 5 4 6181 6163 DLY1_5VX1 $T=527640 0 0 0 $X=527210 $Y=-640
X43061 5 4 6173 6184 DLY1_5VX1 $T=529880 -197120 0 0 $X=529450 $Y=-197760
X43062 5 4 6175 6197 DLY1_5VX1 $T=534360 -62720 1 0 $X=533930 $Y=-67840
X43063 5 4 6162 6205 DLY1_5VX1 $T=534920 -44800 0 0 $X=534490 $Y=-45440
X43064 5 4 6177 6212 DLY1_5VX1 $T=535480 -161280 1 0 $X=535050 $Y=-166400
X43065 5 4 6172 6201 DLY1_5VX1 $T=536040 -197120 0 0 $X=535610 $Y=-197760
X43066 5 4 6179 6209 DLY1_5VX1 $T=538280 -80640 1 0 $X=537850 $Y=-85760
X43067 5 4 5597 6204 DLY1_5VX1 $T=539400 -152320 0 0 $X=538970 $Y=-152960
X43068 5 4 6186 6215 DLY1_5VX1 $T=540520 -98560 1 0 $X=540090 $Y=-103680
X43069 5 4 6192 6216 DLY1_5VX1 $T=541080 -170240 0 0 $X=540650 $Y=-170880
X43070 5 4 6166 6221 DLY1_5VX1 $T=541080 -152320 1 0 $X=540650 $Y=-157440
X43071 5 4 5599 7909 DLY1_5VX1 $T=541080 -44800 1 0 $X=540650 $Y=-49920
X43072 5 4 6217 6214 DLY1_5VX1 $T=541640 -161280 1 0 $X=541210 $Y=-166400
X43073 5 4 6189 6222 DLY1_5VX1 $T=545560 -125440 0 0 $X=545130 $Y=-126080
X43074 5 4 6190 6218 DLY1_5VX1 $T=546120 -125440 1 0 $X=545690 $Y=-130560
X43075 5 4 6187 6224 DLY1_5VX1 $T=548360 -143360 0 0 $X=547930 $Y=-144000
X43076 5 4 6225 7913 DLY1_5VX1 $T=550040 -107520 1 0 $X=549610 $Y=-112640
X43077 5 4 2218 1690 BU_5VX12 $T=-348200 -80640 0 0 $X=-348630 $Y=-81280
X43078 5 4 2218 6270 BU_5VX12 $T=-340360 -98560 0 0 $X=-340790 $Y=-99200
X43079 5 4 2218 1815 BU_5VX12 $T=-339800 -116480 1 0 $X=-340230 $Y=-121600
X43080 5 4 2218 63 BU_5VX12 $T=-329720 -134400 1 0 $X=-330150 $Y=-139520
X43081 5 4 188 1643 BU_5VX12 $T=-320760 0 0 0 $X=-321190 $Y=-640
X43082 5 4 188 1621 BU_5VX12 $T=-314040 8960 0 0 $X=-314470 $Y=8320
X43083 5 4 188 2172 BU_5VX12 $T=-312360 0 1 0 $X=-312790 $Y=-5120
X43084 5 4 188 2261 BU_5VX12 $T=-296680 8960 0 0 $X=-297110 $Y=8320
X43085 5 4 188 2175 BU_5VX12 $T=-295560 8960 1 0 $X=-295990 $Y=3840
X43086 5 4 188 2174 BU_5VX12 $T=-295000 0 1 0 $X=-295430 $Y=-5120
X43087 5 4 2218 2240 BU_5VX12 $T=-284360 -71680 1 0 $X=-284790 $Y=-76800
X43088 5 4 2218 2309 BU_5VX12 $T=-276520 -107520 1 0 $X=-276950 $Y=-112640
X43089 5 4 2218 2298 BU_5VX12 $T=-274840 -80640 1 0 $X=-275270 $Y=-85760
X43090 5 4 2218 308 BU_5VX12 $T=-236200 -134400 1 0 $X=-236630 $Y=-139520
X43091 5 4 2218 6627 BU_5VX12 $T=-233400 -71680 1 0 $X=-233830 $Y=-76800
X43092 5 4 340 2744 BU_5VX12 $T=-221080 -44800 0 0 $X=-221510 $Y=-45440
X43093 5 4 340 315 BU_5VX12 $T=-218280 8960 1 0 $X=-218710 $Y=3840
X43094 5 4 2866 2751 BU_5VX12 $T=-217160 -89600 0 0 $X=-217590 $Y=-90240
X43095 5 4 2866 2974 BU_5VX12 $T=-181320 -197120 1 0 $X=-181750 $Y=-202240
X43096 5 4 403 381 BU_5VX12 $T=-177400 -268800 1 0 $X=-177830 $Y=-273920
X43097 5 4 2866 3097 BU_5VX12 $T=-166200 -143360 1 0 $X=-166630 $Y=-148480
X43098 5 4 403 3094 BU_5VX12 $T=-163960 -224000 0 0 $X=-164390 $Y=-224640
X43099 5 4 340 6707 BU_5VX12 $T=-159480 -26880 1 0 $X=-159910 $Y=-32000
X43100 5 4 2866 6709 BU_5VX12 $T=-158920 -179200 1 0 $X=-159350 $Y=-184320
X43101 5 4 340 3179 BU_5VX12 $T=-153880 -17920 0 0 $X=-154310 $Y=-18560
X43102 5 4 2866 3099 BU_5VX12 $T=-147160 -89600 1 0 $X=-147590 $Y=-94720
X43103 5 4 2866 3211 BU_5VX12 $T=-142120 -143360 0 0 $X=-142550 $Y=-144000
X43104 5 4 403 3180 BU_5VX12 $T=-141560 -259840 0 0 $X=-141990 $Y=-260480
X43105 5 4 340 407 BU_5VX12 $T=-141560 0 0 0 $X=-141990 $Y=-640
X43106 5 4 340 3184 BU_5VX12 $T=-138200 -62720 0 0 $X=-138630 $Y=-63360
X43107 5 4 2866 3226 BU_5VX12 $T=-135960 -170240 0 0 $X=-136390 $Y=-170880
X43108 5 4 2866 3178 BU_5VX12 $T=-129800 -98560 0 0 $X=-130230 $Y=-99200
X43109 5 4 403 3197 BU_5VX12 $T=-129240 -232960 0 0 $X=-129670 $Y=-233600
X43110 5 4 2866 3296 BU_5VX12 $T=-97880 -125440 0 0 $X=-98310 $Y=-126080
X43111 5 4 2866 3263 BU_5VX12 $T=-93960 -188160 1 0 $X=-94390 $Y=-193280
X43112 5 4 737 3814 BU_5VX12 $T=2920 -215040 1 0 $X=2490 $Y=-220160
X43113 5 4 737 714 BU_5VX12 $T=3480 -268800 1 0 $X=3050 $Y=-273920
X43114 5 4 3912 7035 BU_5VX12 $T=18040 -98560 1 0 $X=17610 $Y=-103680
X43115 5 4 3912 3966 BU_5VX12 $T=23080 -170240 0 0 $X=22650 $Y=-170880
X43116 5 4 3912 7063 BU_5VX12 $T=46040 -179200 0 0 $X=45610 $Y=-179840
X43117 5 4 737 7116 BU_5VX12 $T=64520 -215040 0 0 $X=64090 $Y=-215680
X43118 5 4 3912 7119 BU_5VX12 $T=70120 -80640 1 0 $X=69690 $Y=-85760
X43119 5 4 873 4191 BU_5VX12 $T=71240 -44800 0 0 $X=70810 $Y=-45440
X43120 5 4 3912 4133 BU_5VX12 $T=71800 -116480 1 0 $X=71370 $Y=-121600
X43121 5 4 873 4076 BU_5VX12 $T=77400 0 1 0 $X=76970 $Y=-5120
X43122 5 4 3912 4580 BU_5VX12 $T=159720 -152320 0 0 $X=159290 $Y=-152960
X43123 5 4 737 4575 BU_5VX12 $T=160840 -197120 0 0 $X=160410 $Y=-197760
X43124 5 4 873 4535 BU_5VX12 $T=163080 -26880 0 0 $X=162650 $Y=-27520
X43125 5 4 3912 4545 BU_5VX12 $T=169240 -125440 1 0 $X=168810 $Y=-130560
X43126 5 4 737 7236 BU_5VX12 $T=169800 -224000 1 0 $X=169370 $Y=-229120
X43127 5 4 3912 4533 BU_5VX12 $T=169800 -89600 1 0 $X=169370 $Y=-94720
X43128 5 4 3912 4534 BU_5VX12 $T=170360 -44800 0 0 $X=169930 $Y=-45440
X43129 5 4 737 999 BU_5VX12 $T=174280 -259840 1 0 $X=173850 $Y=-264960
X43130 5 4 3912 4544 BU_5VX12 $T=174280 -179200 0 0 $X=173850 $Y=-179840
X43131 5 4 1075 4642 BU_5VX12 $T=181560 -232960 0 0 $X=181130 $Y=-233600
X43132 5 4 4636 4608 BU_5VX12 $T=181560 -62720 1 0 $X=181130 $Y=-67840
X43133 5 4 1075 4721 BU_5VX12 $T=195560 -152320 1 0 $X=195130 $Y=-157440
X43134 5 4 1079 4645 BU_5VX12 $T=197240 -8960 1 0 $X=196810 $Y=-14080
X43135 5 4 1075 4806 BU_5VX12 $T=210120 -188160 0 0 $X=209690 $Y=-188800
X43136 5 4 4636 4658 BU_5VX12 $T=212920 -107520 1 0 $X=212490 $Y=-112640
X43137 5 4 1079 7294 BU_5VX12 $T=213480 -35840 1 0 $X=213050 $Y=-40960
X43138 5 4 4636 4761 BU_5VX12 $T=215160 -80640 0 0 $X=214730 $Y=-81280
X43139 5 4 4636 4760 BU_5VX12 $T=220760 -143360 1 0 $X=220330 $Y=-148480
X43140 5 4 1079 1110 BU_5VX12 $T=226920 8960 1 0 $X=226490 $Y=3840
X43141 5 4 1075 5055 BU_5VX12 $T=253800 -197120 1 0 $X=253370 $Y=-202240
X43142 5 4 4636 5081 BU_5VX12 $T=289080 -125440 1 0 $X=288650 $Y=-130560
X43143 5 4 1079 5520 BU_5VX12 $T=355160 -8960 1 0 $X=354730 $Y=-14080
X43144 5 4 4636 5539 BU_5VX12 $T=358520 -35840 1 0 $X=358090 $Y=-40960
X43145 5 4 4636 7599 BU_5VX12 $T=361880 -143360 0 0 $X=361450 $Y=-144000
X43146 5 4 4636 5531 BU_5VX12 $T=365800 -116480 1 0 $X=365370 $Y=-121600
X43147 5 4 1075 1316 BU_5VX12 $T=366920 -259840 0 0 $X=366490 $Y=-260480
X43148 5 4 1075 5569 BU_5VX12 $T=370280 -232960 0 0 $X=369850 $Y=-233600
X43149 5 4 1075 5504 BU_5VX12 $T=370840 -170240 1 0 $X=370410 $Y=-175360
X43150 5 4 4636 5600 BU_5VX12 $T=370840 -62720 1 0 $X=370410 $Y=-67840
X43151 5 4 1079 6171 BU_5VX12 $T=522040 -35840 1 0 $X=521610 $Y=-40960
X43152 5 4 1075 6195 BU_5VX12 $T=525960 -179200 0 0 $X=525530 $Y=-179840
X43153 5 4 4636 6176 BU_5VX12 $T=529320 -107520 0 0 $X=528890 $Y=-108160
X43154 5 4 12 24 BU_5VX16 $T=-521240 0 1 0 $X=-521670 $Y=-5120
X43155 5 4 324 2218 BU_5VX16 $T=-229480 0 0 0 $X=-229910 $Y=-640
X43156 5 4 447 463 BU_5VX16 $T=-151640 -8960 0 0 $X=-152070 $Y=-9600
X43157 5 4 545 403 BU_5VX16 $T=-97880 -35840 1 0 $X=-98310 $Y=-40960
X43158 5 4 546 340 BU_5VX16 $T=-97880 8960 0 0 $X=-98310 $Y=8320
X43159 5 4 581 2866 BU_5VX16 $T=-81640 -26880 1 0 $X=-82070 $Y=-32000
X43160 5 4 736 3912 BU_5VX16 $T=3480 8960 0 0 $X=3050 $Y=8320
X43161 5 4 736 737 BU_5VX16 $T=13560 8960 1 0 $X=13130 $Y=3840
X43162 5 4 788 798 BU_5VX16 $T=25320 8960 0 0 $X=24890 $Y=8320
X43163 5 4 788 4114 BU_5VX16 $T=35400 8960 1 0 $X=34970 $Y=3840
X43164 5 4 788 7128 BU_5VX16 $T=44920 0 0 0 $X=44490 $Y=-640
X43165 5 4 788 4201 BU_5VX16 $T=57240 8960 1 0 $X=56810 $Y=3840
X43166 5 4 982 4636 BU_5VX16 $T=151880 8960 1 0 $X=151450 $Y=3840
X43167 5 4 4201 1079 BU_5VX16 $T=173720 8960 1 0 $X=173290 $Y=3840
X43168 5 4 7128 1075 BU_5VX16 $T=182680 -17920 1 0 $X=182250 $Y=-23040
X43169 5 4 4114 1115 BU_5VX16 $T=196120 8960 0 0 $X=195690 $Y=8320
X43170 5 4 190 198 IN_5VX16 $T=-319080 -170240 1 0 $X=-319510 $Y=-175360
X43171 5 4 3387 586 IN_5VX3 $T=-78840 -116480 1 0 $X=-79270 $Y=-121600
X43172 5 4 6886 632 IN_5VX3 $T=-56440 -170240 1 0 $X=-56870 $Y=-175360
X43173 5 4 477 715 IN_5VX3 $T=11880 -268800 0 0 $X=11450 $Y=-269440
X43174 5 4 171 821 IN_5VX3 $T=74600 -71680 1 180 $X=70250 $Y=-72320
X43175 5 4 171 856 IN_5VX3 $T=73480 -134400 0 0 $X=73050 $Y=-135040
X43176 5 4 477 1088 IN_5VX3 $T=186600 -268800 1 0 $X=186170 $Y=-273920
X43177 5 4 477 2719 IN_5VX4 $T=-135960 -224000 0 180 $X=-140870 $Y=-229120
X43178 5 4 3429 592 IN_5VX4 $T=-79960 -152320 1 0 $X=-80390 $Y=-157440
X43179 5 4 7 14 IN_5VX1 $T=-521800 -62720 0 0 $X=-522230 $Y=-63360
X43180 5 4 47 1786 IN_5VX1 $T=-454600 -35840 0 180 $X=-456710 $Y=-40960
X43181 5 4 54 1870 IN_5VX1 $T=-437240 -26880 0 0 $X=-437670 $Y=-27520
X43182 5 4 7995 7940 IN_5VX1 $T=-433880 -26880 0 180 $X=-435990 $Y=-32000
X43183 5 4 1880 1891 IN_5VX1 $T=-431640 -116480 0 0 $X=-432070 $Y=-117120
X43184 5 4 59 1914 IN_5VX1 $T=-426040 -107520 0 0 $X=-426470 $Y=-108160
X43185 5 4 51 69 IN_5VX1 $T=-424360 8960 1 180 $X=-426470 $Y=8320
X43186 5 4 1900 1905 IN_5VX1 $T=-422120 -125440 0 180 $X=-424230 $Y=-130560
X43187 5 4 1902 6330 IN_5VX1 $T=-422120 -116480 0 180 $X=-424230 $Y=-121600
X43188 5 4 1841 1951 IN_5VX1 $T=-414840 -107520 1 180 $X=-416950 $Y=-108160
X43189 5 4 6348 6357 IN_5VX1 $T=-414280 -89600 0 0 $X=-414710 $Y=-90240
X43190 5 4 1943 1967 IN_5VX1 $T=-411480 -125440 1 180 $X=-413590 $Y=-126080
X43191 5 4 1920 6345 IN_5VX1 $T=-410360 -143360 1 180 $X=-412470 $Y=-144000
X43192 5 4 1964 6351 IN_5VX1 $T=-408120 -152320 1 180 $X=-410230 $Y=-152960
X43193 5 4 6362 6366 IN_5VX1 $T=-409240 -143360 0 0 $X=-409670 $Y=-144000
X43194 5 4 1900 1983 IN_5VX1 $T=-407560 -89600 1 180 $X=-409670 $Y=-90240
X43195 5 4 1974 7996 IN_5VX1 $T=-407560 8960 0 180 $X=-409670 $Y=3840
X43196 5 4 6369 6371 IN_5VX1 $T=-407000 -107520 0 0 $X=-407430 $Y=-108160
X43197 5 4 1993 6372 IN_5VX1 $T=-403080 -197120 1 180 $X=-405190 $Y=-197760
X43198 5 4 49 6376 IN_5VX1 $T=-403080 -35840 1 180 $X=-405190 $Y=-36480
X43199 5 4 45 2037 IN_5VX1 $T=-400840 -17920 1 0 $X=-401270 $Y=-23040
X43200 5 4 1462 2009 IN_5VX1 $T=-398600 -116480 0 180 $X=-400710 $Y=-121600
X43201 5 4 47 2029 IN_5VX1 $T=-398040 -26880 0 180 $X=-400150 $Y=-32000
X43202 5 4 1447 6379 IN_5VX1 $T=-395800 -143360 1 180 $X=-397910 $Y=-144000
X43203 5 4 80 1451 IN_5VX1 $T=-394680 -161280 1 0 $X=-395110 $Y=-166400
X43204 5 4 6398 6396 IN_5VX1 $T=-391880 -152320 0 180 $X=-393990 $Y=-157440
X43205 5 4 92 6393 IN_5VX1 $T=-388520 -179200 0 180 $X=-390630 $Y=-184320
X43206 5 4 59 2074 IN_5VX1 $T=-390200 -17920 1 0 $X=-390630 $Y=-23040
X43207 5 4 84 2047 IN_5VX1 $T=-387960 -170240 0 180 $X=-390070 $Y=-175360
X43208 5 4 54 123 IN_5VX1 $T=-387400 -26880 1 0 $X=-387830 $Y=-32000
X43209 5 4 79 2115 IN_5VX1 $T=-384040 -224000 0 0 $X=-384470 $Y=-224640
X43210 5 4 100 6411 IN_5VX1 $T=-381240 -170240 0 180 $X=-383350 $Y=-175360
X43211 5 4 48 2102 IN_5VX1 $T=-381240 -62720 1 180 $X=-383350 $Y=-63360
X43212 5 4 49 119 IN_5VX1 $T=-381240 -17920 1 180 $X=-383350 $Y=-18560
X43213 5 4 137 7942 IN_5VX1 $T=-376200 -188160 0 180 $X=-378310 $Y=-193280
X43214 5 4 1452 2139 IN_5VX1 $T=-372280 -188160 1 0 $X=-372710 $Y=-193280
X43215 5 4 1841 2152 IN_5VX1 $T=-371160 -143360 0 0 $X=-371590 $Y=-144000
X43216 5 4 58 2141 IN_5VX1 $T=-366680 -107520 1 180 $X=-368790 $Y=-108160
X43217 5 4 1447 2128 IN_5VX1 $T=-347640 -197120 1 0 $X=-348070 $Y=-202240
X43218 5 4 80 2183 IN_5VX1 $T=-347080 -232960 1 0 $X=-347510 $Y=-238080
X43219 5 4 84 2217 IN_5VX1 $T=-347080 -215040 1 0 $X=-347510 $Y=-220160
X43220 5 4 1900 2231 IN_5VX1 $T=-340920 -125440 0 180 $X=-343030 $Y=-130560
X43221 5 4 100 2208 IN_5VX1 $T=-338680 -250880 1 180 $X=-340790 $Y=-251520
X43222 5 4 1462 2146 IN_5VX1 $T=-338680 -170240 1 180 $X=-340790 $Y=-170880
X43223 5 4 89 6458 IN_5VX1 $T=-333640 -232960 0 180 $X=-335750 $Y=-238080
X43224 5 4 92 2209 IN_5VX1 $T=-324120 -250880 1 180 $X=-326230 $Y=-251520
X43225 5 4 141 165 IN_5VX1 $T=-322440 -268800 0 180 $X=-324550 $Y=-273920
X43226 5 4 137 2291 IN_5VX1 $T=-321880 -259840 0 180 $X=-323990 $Y=-264960
X43227 5 4 139 6492 IN_5VX1 $T=-316840 -250880 1 180 $X=-318950 $Y=-251520
X43228 5 4 137 2384 IN_5VX1 $T=-312920 -232960 1 0 $X=-313350 $Y=-238080
X43229 5 4 2368 2396 IN_5VX1 $T=-311240 -259840 1 0 $X=-311670 $Y=-264960
X43230 5 4 2357 6505 IN_5VX1 $T=-306200 -143360 1 180 $X=-308310 $Y=-144000
X43231 5 4 7997 2362 IN_5VX1 $T=-305080 -241920 1 180 $X=-307190 $Y=-242560
X43232 5 4 209 2443 IN_5VX1 $T=-296120 -259840 0 180 $X=-298230 $Y=-264960
X43233 5 4 2451 2405 IN_5VX1 $T=-295560 -152320 1 180 $X=-297670 $Y=-152960
X43234 5 4 54 2434 IN_5VX1 $T=-293320 -26880 0 180 $X=-295430 $Y=-32000
X43235 5 4 59 2483 IN_5VX1 $T=-293320 -35840 0 0 $X=-293750 $Y=-36480
X43236 5 4 80 6531 IN_5VX1 $T=-289400 -179200 0 180 $X=-291510 $Y=-184320
X43237 5 4 58 6532 IN_5VX1 $T=-289400 -62720 0 180 $X=-291510 $Y=-67840
X43238 5 4 6534 6528 IN_5VX1 $T=-288280 -197120 1 180 $X=-290390 $Y=-197760
X43239 5 4 1447 2427 IN_5VX1 $T=-287720 -134400 1 180 $X=-289830 $Y=-135040
X43240 5 4 48 2503 IN_5VX1 $T=-288840 -17920 1 0 $X=-289270 $Y=-23040
X43241 5 4 79 6541 IN_5VX1 $T=-287720 -179200 1 0 $X=-288150 $Y=-184320
X43242 5 4 47 221 IN_5VX1 $T=-287160 -8960 1 0 $X=-287590 $Y=-14080
X43243 5 4 1452 2510 IN_5VX1 $T=-286600 -134400 0 0 $X=-287030 $Y=-135040
X43244 5 4 1841 2447 IN_5VX1 $T=-284920 -62720 1 180 $X=-287030 $Y=-63360
X43245 5 4 1900 2475 IN_5VX1 $T=-284360 -71680 0 180 $X=-286470 $Y=-76800
X43246 5 4 1462 2477 IN_5VX1 $T=-284360 -98560 0 0 $X=-284790 $Y=-99200
X43247 5 4 1841 6554 IN_5VX1 $T=-282680 -44800 0 0 $X=-283110 $Y=-45440
X43248 5 4 1452 2456 IN_5VX1 $T=-279880 -116480 0 180 $X=-281990 $Y=-121600
X43249 5 4 1900 2535 IN_5VX1 $T=-281560 -80640 0 0 $X=-281990 $Y=-81280
X43250 5 4 1462 7922 IN_5VX1 $T=-280440 -89600 0 0 $X=-280870 $Y=-90240
X43251 5 4 6545 7947 IN_5VX1 $T=-280440 -26880 1 0 $X=-280870 $Y=-32000
X43252 5 4 6556 6550 IN_5VX1 $T=-276520 -71680 1 180 $X=-278630 $Y=-72320
X43253 5 4 80 6561 IN_5VX1 $T=-275400 -125440 0 0 $X=-275830 $Y=-126080
X43254 5 4 1447 6565 IN_5VX1 $T=-273160 -107520 0 0 $X=-273590 $Y=-108160
X43255 5 4 6566 6573 IN_5VX1 $T=-270920 -62720 0 0 $X=-271350 $Y=-63360
X43256 5 4 58 2549 IN_5VX1 $T=-270920 -8960 1 0 $X=-271350 $Y=-14080
X43257 5 4 89 6570 IN_5VX1 $T=-264760 -134400 0 180 $X=-266870 $Y=-139520
X43258 5 4 6576 1463 IN_5VX1 $T=-264200 -44800 1 180 $X=-266310 $Y=-45440
X43259 5 4 251 6572 IN_5VX1 $T=-264200 -17920 1 180 $X=-266310 $Y=-18560
X43260 5 4 59 2627 IN_5VX1 $T=-265880 -8960 1 0 $X=-266310 $Y=-14080
X43261 5 4 2585 2584 IN_5VX1 $T=-263640 -8960 1 180 $X=-265750 $Y=-9600
X43262 5 4 2624 252 IN_5VX1 $T=-263080 8960 0 180 $X=-265190 $Y=3840
X43263 5 4 84 6578 IN_5VX1 $T=-263640 -134400 1 0 $X=-264070 $Y=-139520
X43264 5 4 2587 6598 IN_5VX1 $T=-254120 -152320 0 0 $X=-254550 $Y=-152960
X43265 5 4 2641 2684 IN_5VX1 $T=-251880 -197120 1 0 $X=-252310 $Y=-202240
X43266 5 4 79 2678 IN_5VX1 $T=-247400 -206080 1 180 $X=-249510 $Y=-206720
X43267 5 4 92 2691 IN_5VX1 $T=-245160 -206080 0 0 $X=-245590 $Y=-206720
X43268 5 4 2709 2699 IN_5VX1 $T=-240120 -170240 1 180 $X=-242230 $Y=-170880
X43269 5 4 89 6618 IN_5VX1 $T=-238440 -241920 0 180 $X=-240550 $Y=-247040
X43270 5 4 2735 6626 IN_5VX1 $T=-237320 -224000 1 0 $X=-237750 $Y=-229120
X43271 5 4 326 6645 IN_5VX1 $T=-227800 -250880 1 0 $X=-228230 $Y=-256000
X43272 5 4 84 6638 IN_5VX1 $T=-227800 -224000 0 0 $X=-228230 $Y=-224640
X43273 5 4 2790 6642 IN_5VX1 $T=-227800 -116480 0 0 $X=-228230 $Y=-117120
X43274 5 4 6641 1467 IN_5VX1 $T=-225560 -53760 0 0 $X=-225990 $Y=-54400
X43275 5 4 2806 2810 IN_5VX1 $T=-225560 -8960 1 0 $X=-225990 $Y=-14080
X43276 5 4 100 2818 IN_5VX1 $T=-225000 -232960 0 0 $X=-225430 $Y=-233600
X43277 5 4 138 325 IN_5VX1 $T=-222760 -259840 0 180 $X=-224870 $Y=-264960
X43278 5 4 89 1468 IN_5VX1 $T=-221080 -152320 0 0 $X=-221510 $Y=-152960
X43279 5 4 2804 2830 IN_5VX1 $T=-220520 -197120 0 0 $X=-220950 $Y=-197760
X43280 5 4 80 2849 IN_5VX1 $T=-218840 -89600 0 0 $X=-219270 $Y=-90240
X43281 5 4 2841 6646 IN_5VX1 $T=-216600 -232960 1 180 $X=-218710 $Y=-233600
X43282 5 4 137 7998 IN_5VX1 $T=-214360 -197120 0 180 $X=-216470 $Y=-202240
X43283 5 4 1452 2883 IN_5VX1 $T=-213800 -44800 0 180 $X=-215910 $Y=-49920
X43284 5 4 92 2838 IN_5VX1 $T=-212120 -170240 1 180 $X=-214230 $Y=-170880
X43285 5 4 2845 6666 IN_5VX1 $T=-213240 -232960 1 0 $X=-213670 $Y=-238080
X43286 5 4 1447 6664 IN_5VX1 $T=-210440 -71680 1 180 $X=-212550 $Y=-72320
X43287 5 4 59 353 IN_5VX1 $T=-210440 8960 0 0 $X=-210870 $Y=8320
X43288 5 4 84 1471 IN_5VX1 $T=-208200 -152320 0 180 $X=-210310 $Y=-157440
X43289 5 4 79 2865 IN_5VX1 $T=-207080 -98560 0 180 $X=-209190 $Y=-103680
X43290 5 4 1841 354 IN_5VX1 $T=-205960 0 1 180 $X=-208070 $Y=-640
X43291 5 4 2864 2928 IN_5VX1 $T=-206520 -224000 0 0 $X=-206950 $Y=-224640
X43292 5 4 2903 6675 IN_5VX1 $T=-206520 -17920 1 0 $X=-206950 $Y=-23040
X43293 5 4 2913 2905 IN_5VX1 $T=-205960 -259840 1 0 $X=-206390 $Y=-264960
X43294 5 4 2870 6673 IN_5VX1 $T=-202600 -170240 1 180 $X=-204710 $Y=-170880
X43295 5 4 2888 2943 IN_5VX1 $T=-203720 -241920 0 0 $X=-204150 $Y=-242560
X43296 5 4 2879 2922 IN_5VX1 $T=-203720 -215040 0 0 $X=-204150 $Y=-215680
X43297 5 4 3014 2995 IN_5VX1 $T=-183000 -8960 0 180 $X=-185110 $Y=-14080
X43298 5 4 2987 7916 IN_5VX1 $T=-182440 -152320 0 180 $X=-184550 $Y=-157440
X43299 5 4 6685 6689 IN_5VX1 $T=-177960 -26880 0 180 $X=-180070 $Y=-32000
X43300 5 4 3152 6750 IN_5VX1 $T=-151640 -259840 0 0 $X=-152070 $Y=-260480
X43301 5 4 6774 6778 IN_5VX1 $T=-134840 -89600 0 0 $X=-135270 $Y=-90240
X43302 5 4 3247 3242 IN_5VX1 $T=-130920 -134400 0 180 $X=-133030 $Y=-139520
X43303 5 4 3261 1476 IN_5VX1 $T=-129240 -232960 1 180 $X=-131350 $Y=-233600
X43304 5 4 1477 6782 IN_5VX1 $T=-129240 -98560 0 180 $X=-131350 $Y=-103680
X43305 5 4 3266 3210 IN_5VX1 $T=-127560 -170240 0 180 $X=-129670 $Y=-175360
X43306 5 4 3269 3251 IN_5VX1 $T=-127560 -98560 0 180 $X=-129670 $Y=-103680
X43307 5 4 3238 3275 IN_5VX1 $T=-125880 -26880 1 180 $X=-127990 $Y=-27520
X43308 5 4 3304 3284 IN_5VX1 $T=-120840 -206080 0 180 $X=-122950 $Y=-211200
X43309 5 4 6804 3282 IN_5VX1 $T=-118600 -188160 1 180 $X=-120710 $Y=-188800
X43310 5 4 542 6827 IN_5VX1 $T=-97880 -26880 0 0 $X=-98310 $Y=-27520
X43311 5 4 3361 3366 IN_5VX1 $T=-91720 -259840 1 0 $X=-92150 $Y=-264960
X43312 5 4 1479 3367 IN_5VX1 $T=-91720 -250880 1 0 $X=-92150 $Y=-256000
X43313 5 4 6843 3409 IN_5VX1 $T=-87240 -232960 0 0 $X=-87670 $Y=-233600
X43314 5 4 7952 3394 IN_5VX1 $T=-86680 -62720 1 0 $X=-87110 $Y=-67840
X43315 5 4 3408 6852 IN_5VX1 $T=-81640 -241920 0 180 $X=-83750 $Y=-247040
X43316 5 4 3410 3411 IN_5VX1 $T=-82760 -188160 0 0 $X=-83190 $Y=-188800
X43317 5 4 3420 3479 IN_5VX1 $T=-82200 -44800 1 0 $X=-82630 $Y=-49920
X43318 5 4 6857 3424 IN_5VX1 $T=-79960 -197120 1 0 $X=-80390 $Y=-202240
X43319 5 4 3423 3427 IN_5VX1 $T=-79960 8960 1 0 $X=-80390 $Y=3840
X43320 5 4 3428 6850 IN_5VX1 $T=-77720 -206080 0 180 $X=-79830 $Y=-211200
X43321 5 4 3438 3415 IN_5VX1 $T=-77160 -17920 1 180 $X=-79270 $Y=-18560
X43322 5 4 6867 6862 IN_5VX1 $T=-76040 -224000 1 180 $X=-78150 $Y=-224640
X43323 5 4 3444 3412 IN_5VX1 $T=-75480 -62720 0 180 $X=-77590 $Y=-67840
X43324 5 4 3445 3440 IN_5VX1 $T=-75480 -17920 1 180 $X=-77590 $Y=-18560
X43325 5 4 587 588 IN_5VX1 $T=-76040 8960 0 0 $X=-76470 $Y=8320
X43326 5 4 6872 3457 IN_5VX1 $T=-75480 -161280 1 0 $X=-75910 $Y=-166400
X43327 5 4 3454 3482 IN_5VX1 $T=-74920 -35840 1 0 $X=-75350 $Y=-40960
X43328 5 4 3468 3480 IN_5VX1 $T=-72680 -125440 1 0 $X=-73110 $Y=-130560
X43329 5 4 3470 7926 IN_5VX1 $T=-71000 -44800 0 180 $X=-73110 $Y=-49920
X43330 5 4 3478 3458 IN_5VX1 $T=-70440 -80640 1 180 $X=-72550 $Y=-81280
X43331 5 4 6880 3460 IN_5VX1 $T=-70440 -26880 1 180 $X=-72550 $Y=-27520
X43332 5 4 7999 3447 IN_5VX1 $T=-70440 0 1 180 $X=-72550 $Y=-640
X43333 5 4 8000 3488 IN_5VX1 $T=-71000 -125440 1 0 $X=-71430 $Y=-130560
X43334 5 4 6882 6887 IN_5VX1 $T=-71000 -116480 0 0 $X=-71430 $Y=-117120
X43335 5 4 6884 6890 IN_5VX1 $T=-70440 -143360 1 0 $X=-70870 $Y=-148480
X43336 5 4 6883 3481 IN_5VX1 $T=-68760 -62720 0 180 $X=-70870 $Y=-67840
X43337 5 4 8001 3491 IN_5VX1 $T=-69880 -98560 0 0 $X=-70310 $Y=-99200
X43338 5 4 3422 6881 IN_5VX1 $T=-67080 -8960 0 180 $X=-69190 $Y=-14080
X43339 5 4 3484 7927 IN_5VX1 $T=-65960 -80640 0 180 $X=-68070 $Y=-85760
X43340 5 4 604 3516 IN_5VX1 $T=-67080 -8960 1 0 $X=-67510 $Y=-14080
X43341 5 4 3490 6891 IN_5VX1 $T=-63720 -143360 0 180 $X=-65830 $Y=-148480
X43342 5 4 6895 6896 IN_5VX1 $T=-65400 -107520 0 0 $X=-65830 $Y=-108160
X43343 5 4 3510 7918 IN_5VX1 $T=-62040 -26880 1 180 $X=-64150 $Y=-27520
X43344 5 4 623 3514 IN_5VX1 $T=-57000 -71680 1 180 $X=-59110 $Y=-72320
X43345 5 4 609 3532 IN_5VX1 $T=-56440 -26880 1 180 $X=-58550 $Y=-27520
X43346 5 4 3542 3498 IN_5VX1 $T=-54760 -170240 1 180 $X=-56870 $Y=-170880
X43347 5 4 3572 6909 IN_5VX1 $T=-55880 -188160 0 0 $X=-56310 $Y=-188800
X43348 5 4 611 6904 IN_5VX1 $T=-54200 -80640 0 180 $X=-56310 $Y=-85760
X43349 5 4 584 6932 IN_5VX1 $T=-39640 -71680 0 180 $X=-41750 $Y=-76800
X43350 5 4 595 1484 IN_5VX1 $T=-40760 -215040 1 0 $X=-41190 $Y=-220160
X43351 5 4 3636 6934 IN_5VX1 $T=-36280 -179200 0 180 $X=-38390 $Y=-184320
X43352 5 4 3414 3595 IN_5VX1 $T=-35720 -80640 1 180 $X=-37830 $Y=-81280
X43353 5 4 586 638 IN_5VX1 $T=-35160 -197120 1 180 $X=-37270 $Y=-197760
X43354 5 4 3413 3585 IN_5VX1 $T=-36840 -26880 1 0 $X=-37270 $Y=-32000
X43355 5 4 3407 3628 IN_5VX1 $T=-35720 -53760 0 0 $X=-36150 $Y=-54400
X43356 5 4 1485 6947 IN_5VX1 $T=-34040 -241920 0 0 $X=-34470 $Y=-242560
X43357 5 4 632 3646 IN_5VX1 $T=-31800 -224000 0 180 $X=-33910 $Y=-229120
X43358 5 4 3682 3662 IN_5VX1 $T=-32920 -152320 0 0 $X=-33350 $Y=-152960
X43359 5 4 677 671 IN_5VX1 $T=-30680 -241920 0 0 $X=-31110 $Y=-242560
X43360 5 4 6953 676 IN_5VX1 $T=-27880 -268800 0 180 $X=-29990 $Y=-273920
X43361 5 4 632 6962 IN_5VX1 $T=-27320 -232960 0 0 $X=-27750 $Y=-233600
X43362 5 4 677 3645 IN_5VX1 $T=-23400 -250880 0 180 $X=-25510 $Y=-256000
X43363 5 4 592 6966 IN_5VX1 $T=-25080 -197120 0 0 $X=-25510 $Y=-197760
X43364 5 4 6964 3671 IN_5VX1 $T=-20600 -188160 0 180 $X=-22710 $Y=-193280
X43365 5 4 595 3723 IN_5VX1 $T=-20040 -179200 1 0 $X=-20470 $Y=-184320
X43366 5 4 679 3757 IN_5VX1 $T=-19480 -259840 0 0 $X=-19910 $Y=-260480
X43367 5 4 698 694 IN_5VX1 $T=-16120 -268800 0 180 $X=-18230 $Y=-273920
X43368 5 4 637 3748 IN_5VX1 $T=-15560 -259840 0 0 $X=-15990 $Y=-260480
X43369 5 4 3727 3752 IN_5VX1 $T=-15000 -241920 0 0 $X=-15430 $Y=-242560
X43370 5 4 3740 3719 IN_5VX1 $T=-13320 -224000 0 180 $X=-15430 $Y=-229120
X43371 5 4 683 3729 IN_5VX1 $T=-13320 -268800 0 0 $X=-13750 $Y=-269440
X43372 5 4 670 3733 IN_5VX1 $T=-11080 -250880 1 180 $X=-13190 $Y=-251520
X43373 5 4 584 3725 IN_5VX1 $T=-11080 -134400 0 180 $X=-13190 $Y=-139520
X43374 5 4 7012 6985 IN_5VX1 $T=-11080 -107520 1 180 $X=-13190 $Y=-108160
X43375 5 4 3763 6997 IN_5VX1 $T=-10520 -161280 0 0 $X=-10950 $Y=-161920
X43376 5 4 624 3764 IN_5VX1 $T=-8840 -152320 0 180 $X=-10950 $Y=-157440
X43377 5 4 1496 3812 IN_5VX1 $T=-8280 -107520 1 0 $X=-8710 $Y=-112640
X43378 5 4 3788 6996 IN_5VX1 $T=-4360 -98560 1 180 $X=-6470 $Y=-99200
X43379 5 4 3784 3774 IN_5VX1 $T=-3800 -89600 0 180 $X=-5910 $Y=-94720
X43380 5 4 586 6976 IN_5VX1 $T=-2120 -170240 0 180 $X=-4230 $Y=-175360
X43381 5 4 1489 3797 IN_5VX1 $T=680 -143360 1 180 $X=-1430 $Y=-144000
X43382 5 4 720 1491 IN_5VX1 $T=680 -44800 1 180 $X=-1430 $Y=-45440
X43383 5 4 7014 3776 IN_5VX1 $T=2920 -134400 0 180 $X=810 $Y=-139520
X43384 5 4 7015 7004 IN_5VX1 $T=2920 -125440 1 180 $X=810 $Y=-126080
X43385 5 4 3893 3794 IN_5VX1 $T=4600 -26880 1 180 $X=2490 $Y=-27520
X43386 5 4 620 3829 IN_5VX1 $T=5160 0 0 180 $X=3050 $Y=-5120
X43387 5 4 607 3833 IN_5VX1 $T=7960 -35840 0 180 $X=5850 $Y=-40960
X43388 5 4 3504 7017 IN_5VX1 $T=9640 -80640 0 180 $X=7530 $Y=-85760
X43389 5 4 625 3832 IN_5VX1 $T=10200 -80640 1 180 $X=8090 $Y=-81280
X43390 5 4 754 3930 IN_5VX1 $T=11320 -17920 1 0 $X=10890 $Y=-23040
X43391 5 4 607 761 IN_5VX1 $T=11880 8960 1 0 $X=11450 $Y=3840
X43392 5 4 3847 7030 IN_5VX1 $T=16920 -53760 1 180 $X=14810 $Y=-54400
X43393 5 4 7039 3956 IN_5VX1 $T=18040 -44800 1 0 $X=17610 $Y=-49920
X43394 5 4 3918 3858 IN_5VX1 $T=23640 -71680 1 180 $X=21530 $Y=-72320
X43395 5 4 7052 3929 IN_5VX1 $T=23640 -71680 0 0 $X=23210 $Y=-72320
X43396 5 4 584 3953 IN_5VX1 $T=24760 -134400 0 0 $X=24330 $Y=-135040
X43397 5 4 3965 3946 IN_5VX1 $T=29240 -26880 1 180 $X=27130 $Y=-27520
X43398 5 4 1496 7056 IN_5VX1 $T=29800 -98560 1 180 $X=27690 $Y=-99200
X43399 5 4 611 7060 IN_5VX1 $T=30360 0 0 180 $X=28250 $Y=-5120
X43400 5 4 586 3987 IN_5VX1 $T=31480 -152320 1 0 $X=31050 $Y=-157440
X43401 5 4 3983 3988 IN_5VX1 $T=32600 -116480 1 0 $X=32170 $Y=-121600
X43402 5 4 3972 7074 IN_5VX1 $T=36520 -161280 0 180 $X=34410 $Y=-166400
X43403 5 4 1489 3944 IN_5VX1 $T=37080 -98560 0 180 $X=34970 $Y=-103680
X43404 5 4 802 4012 IN_5VX1 $T=37080 -268800 0 0 $X=36650 $Y=-269440
X43405 5 4 1494 4008 IN_5VX1 $T=37080 -116480 1 0 $X=36650 $Y=-121600
X43406 5 4 625 4018 IN_5VX1 $T=39880 -53760 1 0 $X=39450 $Y=-58880
X43407 5 4 677 4072 IN_5VX1 $T=46600 -232960 0 0 $X=46170 $Y=-233600
X43408 5 4 4025 4069 IN_5VX1 $T=46600 -152320 0 0 $X=46170 $Y=-152960
X43409 5 4 809 4041 IN_5VX1 $T=51080 -259840 0 180 $X=48970 $Y=-264960
X43410 5 4 637 4036 IN_5VX1 $T=49400 -250880 1 0 $X=48970 $Y=-256000
X43411 5 4 4047 4051 IN_5VX1 $T=51080 -89600 1 180 $X=48970 $Y=-90240
X43412 5 4 595 4085 IN_5VX1 $T=49960 -206080 0 0 $X=49530 $Y=-206720
X43413 5 4 592 4049 IN_5VX1 $T=53880 -197120 0 0 $X=53450 $Y=-197760
X43414 5 4 632 4061 IN_5VX1 $T=55560 -215040 1 0 $X=55130 $Y=-220160
X43415 5 4 624 4135 IN_5VX1 $T=61160 -152320 1 0 $X=60730 $Y=-157440
X43416 5 4 677 855 IN_5VX1 $T=75160 -268800 1 0 $X=74730 $Y=-273920
X43417 5 4 595 874 IN_5VX1 $T=79080 -259840 0 180 $X=76970 $Y=-264960
X43418 5 4 592 4218 IN_5VX1 $T=81880 -232960 1 0 $X=81450 $Y=-238080
X43419 5 4 625 4236 IN_5VX1 $T=84680 -71680 0 0 $X=84250 $Y=-72320
X43420 5 4 586 4243 IN_5VX1 $T=85800 -206080 0 0 $X=85370 $Y=-206720
X43421 5 4 611 4241 IN_5VX1 $T=85800 -62720 1 0 $X=85370 $Y=-67840
X43422 5 4 1489 4232 IN_5VX1 $T=87480 -161280 1 0 $X=87050 $Y=-166400
X43423 5 4 584 4261 IN_5VX1 $T=89160 -170240 0 0 $X=88730 $Y=-170880
X43424 5 4 607 7162 IN_5VX1 $T=89160 -98560 1 0 $X=88730 $Y=-103680
X43425 5 4 609 7161 IN_5VX1 $T=91400 -26880 0 180 $X=89290 $Y=-32000
X43426 5 4 1496 4228 IN_5VX1 $T=91400 -134400 1 0 $X=90970 $Y=-139520
X43427 5 4 586 914 IN_5VX1 $T=92520 -259840 0 0 $X=92090 $Y=-260480
X43428 5 4 623 910 IN_5VX1 $T=92520 -8960 0 0 $X=92090 $Y=-9600
X43429 5 4 1489 4258 IN_5VX1 $T=96440 -188160 0 0 $X=96010 $Y=-188800
X43430 5 4 3504 4240 IN_5VX1 $T=98680 -152320 0 180 $X=96570 $Y=-157440
X43431 5 4 624 924 IN_5VX1 $T=99240 -250880 0 0 $X=98810 $Y=-251520
X43432 5 4 595 4305 IN_5VX1 $T=100360 -206080 0 0 $X=99930 $Y=-206720
X43433 5 4 624 4290 IN_5VX1 $T=100360 -197120 1 0 $X=99930 $Y=-202240
X43434 5 4 1496 4281 IN_5VX1 $T=101480 -170240 1 0 $X=101050 $Y=-175360
X43435 5 4 620 4273 IN_5VX1 $T=104840 -44800 0 0 $X=104410 $Y=-45440
X43436 5 4 3504 4237 IN_5VX1 $T=107080 -44800 0 180 $X=104970 $Y=-49920
X43437 5 4 625 4289 IN_5VX1 $T=107640 -143360 1 180 $X=105530 $Y=-144000
X43438 5 4 614 7962 IN_5VX1 $T=108200 -26880 0 0 $X=107770 $Y=-27520
X43439 5 4 584 4239 IN_5VX1 $T=110440 -197120 1 180 $X=108330 $Y=-197760
X43440 5 4 620 945 IN_5VX1 $T=111560 -44800 0 0 $X=111130 $Y=-45440
X43441 5 4 623 950 IN_5VX1 $T=114920 -62720 0 0 $X=114490 $Y=-63360
X43442 5 4 609 953 IN_5VX1 $T=117720 0 0 0 $X=117290 $Y=-640
X43443 5 4 614 955 IN_5VX1 $T=118840 -26880 0 0 $X=118410 $Y=-27520
X43444 5 4 611 4390 IN_5VX1 $T=119400 -44800 1 0 $X=118970 $Y=-49920
X43445 5 4 604 960 IN_5VX1 $T=120520 -8960 1 0 $X=120090 $Y=-14080
X43446 5 4 608 967 IN_5VX1 $T=125000 -26880 0 180 $X=122890 $Y=-32000
X43447 5 4 607 4443 IN_5VX1 $T=123880 -134400 0 0 $X=123450 $Y=-135040
X43448 5 4 4762 4953 IN_5VX1 $T=243720 -206080 1 0 $X=243290 $Y=-211200
X43449 5 4 1161 7361 IN_5VX1 $T=244840 -89600 1 0 $X=244410 $Y=-94720
X43450 5 4 1133 1171 IN_5VX1 $T=252680 -259840 0 180 $X=250570 $Y=-264960
X43451 5 4 1157 4984 IN_5VX1 $T=253800 -62720 0 180 $X=251690 $Y=-67840
X43452 5 4 1109 4960 IN_5VX1 $T=253240 -232960 0 0 $X=252810 $Y=-233600
X43453 5 4 4754 4966 IN_5VX1 $T=254920 -206080 1 180 $X=252810 $Y=-206720
X43454 5 4 1123 4948 IN_5VX1 $T=254360 -241920 1 0 $X=253930 $Y=-247040
X43455 5 4 1523 7369 IN_5VX1 $T=257160 -179200 0 180 $X=255050 $Y=-184320
X43456 5 4 4769 5008 IN_5VX1 $T=257160 -134400 1 0 $X=256730 $Y=-139520
X43457 5 4 1170 4956 IN_5VX1 $T=258840 -71680 1 180 $X=256730 $Y=-72320
X43458 5 4 1162 8002 IN_5VX1 $T=259960 -17920 0 180 $X=257850 $Y=-23040
X43459 5 4 1504 5011 IN_5VX1 $T=261080 -179200 0 180 $X=258970 $Y=-184320
X43460 5 4 1117 1189 IN_5VX1 $T=261640 -268800 0 180 $X=259530 $Y=-273920
X43461 5 4 1165 5020 IN_5VX1 $T=263880 -71680 0 180 $X=261770 $Y=-76800
X43462 5 4 1515 4987 IN_5VX1 $T=264440 -197120 1 180 $X=262330 $Y=-197760
X43463 5 4 1506 5028 IN_5VX1 $T=265560 -143360 0 180 $X=263450 $Y=-148480
X43464 5 4 1168 5039 IN_5VX1 $T=264440 -107520 1 0 $X=264010 $Y=-112640
X43465 5 4 1159 5000 IN_5VX1 $T=266120 -71680 0 0 $X=265690 $Y=-72320
X43466 5 4 1173 7391 IN_5VX1 $T=267800 -44800 1 180 $X=265690 $Y=-45440
X43467 5 4 1193 1181 IN_5VX1 $T=268360 0 1 180 $X=266250 $Y=-640
X43468 5 4 5090 7396 IN_5VX1 $T=273960 -26880 1 180 $X=271850 $Y=-27520
X43469 5 4 7407 7415 IN_5VX1 $T=274520 8960 1 0 $X=274090 $Y=3840
X43470 5 4 7412 7401 IN_5VX1 $T=276760 -8960 1 180 $X=274650 $Y=-9600
X43471 5 4 1133 5108 IN_5VX1 $T=276200 -232960 0 0 $X=275770 $Y=-233600
X43472 5 4 5073 7393 IN_5VX1 $T=277880 -35840 1 180 $X=275770 $Y=-36480
X43473 5 4 1119 1215 IN_5VX1 $T=279560 -241920 0 180 $X=277450 $Y=-247040
X43474 5 4 1210 7426 IN_5VX1 $T=278440 -259840 0 0 $X=278010 $Y=-260480
X43475 5 4 4754 5142 IN_5VX1 $T=280120 -206080 1 0 $X=279690 $Y=-211200
X43476 5 4 7421 5101 IN_5VX1 $T=281800 -8960 1 180 $X=279690 $Y=-9600
X43477 5 4 1123 5156 IN_5VX1 $T=280680 -241920 1 0 $X=280250 $Y=-247040
X43478 5 4 1117 1216 IN_5VX1 $T=282360 -232960 1 180 $X=280250 $Y=-233600
X43479 5 4 5100 5125 IN_5VX1 $T=282360 -44800 0 180 $X=280250 $Y=-49920
X43480 5 4 1154 5153 IN_5VX1 $T=284600 -26880 1 180 $X=282490 $Y=-27520
X43481 5 4 1195 7427 IN_5VX1 $T=285720 -268800 1 180 $X=283610 $Y=-269440
X43482 5 4 1156 5170 IN_5VX1 $T=287960 -35840 1 0 $X=287530 $Y=-40960
X43483 5 4 1191 5191 IN_5VX1 $T=287960 0 0 0 $X=287530 $Y=-640
X43484 5 4 1515 7431 IN_5VX1 $T=291880 -197120 0 180 $X=289770 $Y=-202240
X43485 5 4 1504 5202 IN_5VX1 $T=294120 -188160 1 180 $X=292010 $Y=-188800
X43486 5 4 1173 5213 IN_5VX1 $T=295800 -71680 0 180 $X=293690 $Y=-76800
X43487 5 4 1165 5206 IN_5VX1 $T=294680 -107520 1 0 $X=294250 $Y=-112640
X43488 5 4 1506 5122 IN_5VX1 $T=295240 -152320 0 0 $X=294810 $Y=-152960
X43489 5 4 1109 5193 IN_5VX1 $T=299160 -215040 1 180 $X=297050 $Y=-215680
X43490 5 4 1523 5225 IN_5VX1 $T=299160 -161280 0 180 $X=297050 $Y=-166400
X43491 5 4 4769 7446 IN_5VX1 $T=299160 -143360 1 180 $X=297050 $Y=-144000
X43492 5 4 1161 5204 IN_5VX1 $T=300280 -62720 1 180 $X=298170 $Y=-63360
X43493 5 4 1186 1236 IN_5VX1 $T=298600 8960 0 0 $X=298170 $Y=8320
X43494 5 4 1159 5233 IN_5VX1 $T=299720 -89600 1 0 $X=299290 $Y=-94720
X43495 5 4 1180 5231 IN_5VX1 $T=303640 -250880 1 180 $X=301530 $Y=-251520
X43496 5 4 1119 7463 IN_5VX1 $T=302520 -197120 0 0 $X=302090 $Y=-197760
X43497 5 4 1193 1235 IN_5VX1 $T=304200 8960 0 0 $X=303770 $Y=8320
X43498 5 4 1180 5263 IN_5VX1 $T=304760 -215040 0 0 $X=304330 $Y=-215680
X43499 5 4 1195 5295 IN_5VX1 $T=305880 -250880 1 0 $X=305450 $Y=-256000
X43500 5 4 1133 7470 IN_5VX1 $T=308680 -170240 0 180 $X=306570 $Y=-175360
X43501 5 4 1157 5192 IN_5VX1 $T=308680 -71680 0 180 $X=306570 $Y=-76800
X43502 5 4 1162 5246 IN_5VX1 $T=309800 -44800 1 180 $X=307690 $Y=-45440
X43503 5 4 5299 5242 IN_5VX1 $T=312600 -62720 0 180 $X=310490 $Y=-67840
X43504 5 4 1210 1251 IN_5VX1 $T=311480 -250880 1 0 $X=311050 $Y=-256000
X43505 5 4 4762 5238 IN_5VX1 $T=313160 -215040 1 180 $X=311050 $Y=-215680
X43506 5 4 4762 5298 IN_5VX1 $T=313160 -134400 0 0 $X=312730 $Y=-135040
X43507 5 4 4754 5270 IN_5VX1 $T=314280 -116480 0 0 $X=313850 $Y=-117120
X43508 5 4 1170 5229 IN_5VX1 $T=316520 -89600 0 180 $X=314410 $Y=-94720
X43509 5 4 1192 5284 IN_5VX1 $T=318200 -224000 1 180 $X=316090 $Y=-224640
X43510 5 4 1123 7482 IN_5VX1 $T=318760 -143360 0 180 $X=316650 $Y=-148480
X43511 5 4 7489 1507 IN_5VX1 $T=321560 -44800 1 0 $X=321130 $Y=-49920
X43512 5 4 1168 5228 IN_5VX1 $T=323800 -152320 1 180 $X=321690 $Y=-152960
X43513 5 4 1170 5328 IN_5VX1 $T=323240 -26880 1 0 $X=322810 $Y=-32000
X43514 5 4 7505 7514 IN_5VX1 $T=329960 -98560 0 180 $X=327850 $Y=-103680
X43515 5 4 5318 7509 IN_5VX1 $T=332760 -161280 0 180 $X=330650 $Y=-166400
X43516 5 4 5307 7516 IN_5VX1 $T=333320 -179200 0 180 $X=331210 $Y=-184320
X43517 5 4 5718 7692 IN_5VX1 $T=421240 0 1 0 $X=420810 $Y=-5120
X43518 5 4 1523 7709 IN_5VX1 $T=430760 -62720 1 0 $X=430330 $Y=-67840
X43519 5 4 7715 5758 IN_5VX1 $T=436920 -89600 0 180 $X=434810 $Y=-94720
X43520 5 4 1506 1516 IN_5VX1 $T=437480 -62720 1 180 $X=435370 $Y=-63360
X43521 5 4 5789 7707 IN_5VX1 $T=438600 -116480 0 180 $X=436490 $Y=-121600
X43522 5 4 5782 5759 IN_5VX1 $T=439160 0 1 180 $X=437050 $Y=-640
X43523 5 4 5741 5776 IN_5VX1 $T=439720 -206080 1 180 $X=437610 $Y=-206720
X43524 5 4 7719 7718 IN_5VX1 $T=440280 -107520 1 180 $X=438170 $Y=-108160
X43525 5 4 5785 7730 IN_5VX1 $T=438600 -62720 1 0 $X=438170 $Y=-67840
X43526 5 4 1359 1517 IN_5VX1 $T=440840 -250880 0 180 $X=438730 $Y=-256000
X43527 5 4 4762 7717 IN_5VX1 $T=442520 -134400 1 180 $X=440410 $Y=-135040
X43528 5 4 7727 7720 IN_5VX1 $T=442520 -35840 1 180 $X=440410 $Y=-36480
X43529 5 4 1159 5788 IN_5VX1 $T=442520 0 1 180 $X=440410 $Y=-640
X43530 5 4 1123 5783 IN_5VX1 $T=444200 -170240 0 180 $X=442090 $Y=-175360
X43531 5 4 1362 7722 IN_5VX1 $T=444760 -268800 0 180 $X=442650 $Y=-273920
X43532 5 4 1168 5787 IN_5VX1 $T=444760 -35840 0 180 $X=442650 $Y=-40960
X43533 5 4 4769 5775 IN_5VX1 $T=445320 -44800 1 180 $X=443210 $Y=-45440
X43534 5 4 7740 7726 IN_5VX1 $T=447000 -161280 1 180 $X=444890 $Y=-161920
X43535 5 4 7738 5784 IN_5VX1 $T=447000 -134400 1 180 $X=444890 $Y=-135040
X43536 5 4 5814 7728 IN_5VX1 $T=447000 -62720 0 180 $X=444890 $Y=-67840
X43537 5 4 7744 7742 IN_5VX1 $T=445880 -179200 0 0 $X=445450 $Y=-179840
X43538 5 4 1119 5836 IN_5VX1 $T=448120 -215040 1 0 $X=447690 $Y=-220160
X43539 5 4 1109 5802 IN_5VX1 $T=449800 -143360 0 180 $X=447690 $Y=-148480
X43540 5 4 4769 7748 IN_5VX1 $T=448680 -44800 1 0 $X=448250 $Y=-49920
X43541 5 4 1506 5851 IN_5VX1 $T=449800 -62720 0 0 $X=449370 $Y=-63360
X43542 5 4 7747 7743 IN_5VX1 $T=451480 -53760 0 180 $X=449370 $Y=-58880
X43543 5 4 1133 5820 IN_5VX1 $T=452040 -206080 0 180 $X=449930 $Y=-211200
X43544 5 4 1180 5831 IN_5VX1 $T=452040 -241920 1 0 $X=451610 $Y=-247040
X43545 5 4 1515 7736 IN_5VX1 $T=453720 -107520 0 180 $X=451610 $Y=-112640
X43546 5 4 1504 5828 IN_5VX1 $T=453720 -98560 1 180 $X=451610 $Y=-99200
X43547 5 4 4754 5832 IN_5VX1 $T=454280 -143360 0 180 $X=452170 $Y=-148480
X43548 5 4 1165 7741 IN_5VX1 $T=452600 -26880 0 0 $X=452170 $Y=-27520
X43549 5 4 1520 1377 IN_5VX1 $T=454280 -17920 0 180 $X=452170 $Y=-23040
X43550 5 4 7752 5886 IN_5VX1 $T=453720 -35840 1 0 $X=453290 $Y=-40960
X43551 5 4 7755 5888 IN_5VX1 $T=454840 -98560 0 0 $X=454410 $Y=-99200
X43552 5 4 1159 7770 IN_5VX1 $T=454840 -62720 0 0 $X=454410 $Y=-63360
X43553 5 4 5830 7759 IN_5VX1 $T=454840 0 0 0 $X=454410 $Y=-640
X43554 5 4 1192 7745 IN_5VX1 $T=457080 -259840 1 180 $X=454970 $Y=-260480
X43555 5 4 1378 7763 IN_5VX1 $T=457640 -268800 1 0 $X=457210 $Y=-273920
X43556 5 4 5937 8003 IN_5VX1 $T=457640 -215040 1 0 $X=457210 $Y=-220160
X43557 5 4 1523 7767 IN_5VX1 $T=459880 -125440 1 0 $X=459450 $Y=-130560
X43558 5 4 5885 5909 IN_5VX1 $T=459880 -89600 0 0 $X=459450 $Y=-90240
X43559 5 4 1515 5902 IN_5VX1 $T=461560 -125440 0 0 $X=461130 $Y=-126080
X43560 5 4 5907 5923 IN_5VX1 $T=462120 -224000 1 0 $X=461690 $Y=-229120
X43561 5 4 1504 7779 IN_5VX1 $T=462120 -98560 1 0 $X=461690 $Y=-103680
X43562 5 4 1522 5883 IN_5VX1 $T=463800 -71680 0 180 $X=461690 $Y=-76800
X43563 5 4 1385 7766 IN_5VX1 $T=464360 -268800 1 180 $X=462250 $Y=-269440
X43564 5 4 1386 7773 IN_5VX1 $T=466040 -53760 0 180 $X=463930 $Y=-58880
X43565 5 4 4754 5950 IN_5VX1 $T=468280 -152320 0 0 $X=467850 $Y=-152960
X43566 5 4 1133 5934 IN_5VX1 $T=468840 -197120 0 0 $X=468410 $Y=-197760
X43567 5 4 1210 5956 IN_5VX1 $T=469400 -250880 0 0 $X=468970 $Y=-251520
X43568 5 4 1168 1521 IN_5VX1 $T=471080 -62720 1 180 $X=468970 $Y=-63360
X43569 5 4 1210 5864 IN_5VX1 $T=471640 -259840 0 180 $X=469530 $Y=-264960
X43570 5 4 5943 5952 IN_5VX1 $T=472200 -71680 0 180 $X=470090 $Y=-76800
X43571 5 4 5963 7795 IN_5VX1 $T=471640 -107520 0 0 $X=471210 $Y=-108160
X43572 5 4 7982 5962 IN_5VX1 $T=471640 -44800 1 0 $X=471210 $Y=-49920
X43573 5 4 1109 6002 IN_5VX1 $T=472760 -170240 0 0 $X=472330 $Y=-170880
X43574 5 4 1119 7797 IN_5VX1 $T=473880 -206080 0 0 $X=473450 $Y=-206720
X43575 5 4 7796 5971 IN_5VX1 $T=473880 -197120 1 0 $X=473450 $Y=-202240
X43576 5 4 4769 7799 IN_5VX1 $T=474440 -44800 1 0 $X=474010 $Y=-49920
X43577 5 4 1387 1402 IN_5VX1 $T=481720 -268800 1 180 $X=479610 $Y=-269440
X43578 5 4 5981 8004 IN_5VX1 $T=482840 -206080 0 0 $X=482410 $Y=-206720
X43579 5 4 5985 7819 IN_5VX1 $T=483400 -179200 1 0 $X=482970 $Y=-184320
X43580 5 4 1192 5988 IN_5VX1 $T=486760 -224000 0 180 $X=484650 $Y=-229120
X43581 5 4 6024 7822 IN_5VX1 $T=492360 -179200 0 180 $X=490250 $Y=-184320
X43582 5 4 7 171 IN_5VX2 $T=-337560 -125440 0 0 $X=-337990 $Y=-126080
X43583 5 4 22 1545 BU_5VX4 $T=-512840 0 0 0 $X=-513270 $Y=-640
X43584 5 4 1549 1565 BU_5VX4 $T=-506120 -26880 0 0 $X=-506550 $Y=-27520
X43585 5 4 82 88 BU_5VX4 $T=-418760 -17920 0 0 $X=-419190 $Y=-18560
X43586 5 4 2249 3041 BU_5VX4 $T=-340920 -125440 1 0 $X=-341350 $Y=-130560
X43587 5 4 3046 2898 BU_5VX4 $T=-211560 -232960 1 0 $X=-211990 $Y=-238080
X43588 5 4 4124 3690 BU_5VX4 $T=-8280 -188160 0 0 $X=-8710 $Y=-188800
X43589 5 4 48 1786 1821 EO2_5VX1 $T=-442840 -44800 1 180 $X=-449430 $Y=-45440
X43590 5 4 47 1806 6307 EO2_5VX1 $T=-443400 -35840 1 0 $X=-443830 $Y=-40960
X43591 5 4 1887 1851 1856 EO2_5VX1 $T=-429960 -35840 1 180 $X=-436550 $Y=-36480
X43592 5 4 1931 67 1819 EO2_5VX1 $T=-427720 8960 1 180 $X=-434310 $Y=8320
X43593 5 4 1906 1886 6313 EO2_5VX1 $T=-426600 -98560 1 180 $X=-433190 $Y=-99200
X43594 5 4 1462 1905 1879 EO2_5VX1 $T=-422680 -134400 0 180 $X=-429270 $Y=-139520
X43595 5 4 1900 1895 6316 EO2_5VX1 $T=-418200 -125440 1 180 $X=-424790 $Y=-126080
X43596 5 4 1955 1902 6334 EO2_5VX1 $T=-416520 -152320 1 180 $X=-423110 $Y=-152960
X43597 5 4 1946 1944 6350 EO2_5VX1 $T=-418760 -179200 1 0 $X=-419190 $Y=-184320
X43598 5 4 1973 92 6363 EO2_5VX1 $T=-414840 -259840 1 0 $X=-415270 $Y=-264960
X43599 5 4 2148 141 2111 EO2_5VX1 $T=-367240 -206080 0 180 $X=-373830 $Y=-211200
X43600 5 4 139 6414 6431 EO2_5VX1 $T=-372280 -224000 1 0 $X=-372710 $Y=-229120
X43601 5 4 140 2188 6422 EO2_5VX1 $T=-365560 -259840 1 180 $X=-372150 $Y=-260480
X43602 5 4 138 2184 6434 EO2_5VX1 $T=-371720 -232960 1 0 $X=-372150 $Y=-238080
X43603 5 4 100 6523 2470 EO2_5VX1 $T=-298360 -170240 1 0 $X=-298790 $Y=-175360
X43604 5 4 219 2480 222 EO2_5VX1 $T=-293880 -259840 1 0 $X=-294310 $Y=-264960
X43605 5 4 6536 2480 6526 EO2_5VX1 $T=-287720 -241920 1 180 $X=-294310 $Y=-242560
X43606 5 4 2493 47 2467 EO2_5VX1 $T=-287160 -17920 1 180 $X=-293750 $Y=-18560
X43607 5 4 92 2598 2580 EO2_5VX1 $T=-274840 -206080 0 0 $X=-275270 $Y=-206720
X43608 5 4 309 2788 6636 EO2_5VX1 $T=-232280 0 1 0 $X=-232710 $Y=-5120
X43609 5 4 6647 92 2801 EO2_5VX1 $T=-220520 -161280 0 180 $X=-227110 $Y=-166400
X43610 5 4 2083 2821 6648 EO2_5VX1 $T=-225560 -107520 1 0 $X=-225990 $Y=-112640
X43611 5 4 2829 141 1466 EO2_5VX1 $T=-215480 -215040 0 180 $X=-222070 $Y=-220160
X43612 5 4 327 2873 2808 EO2_5VX1 $T=-207640 -35840 0 180 $X=-214230 $Y=-40960
X43613 5 4 3126 6740 2821 EO2_5VX1 $T=-155000 -125440 0 180 $X=-161590 $Y=-130560
X43614 5 4 614 3503 3489 EO2_5VX1 $T=-63720 -35840 0 180 $X=-70310 $Y=-40960
X43615 5 4 3535 3503 3476 EO2_5VX1 $T=-61480 -98560 1 180 $X=-68070 $Y=-99200
X43616 5 4 620 3515 3496 EO2_5VX1 $T=-61480 -53760 0 180 $X=-68070 $Y=-58880
X43617 5 4 609 3471 616 EO2_5VX1 $T=-55880 0 0 180 $X=-62470 $Y=-5120
X43618 5 4 614 609 605 EO2_5VX1 $T=-51400 -44800 0 180 $X=-57990 $Y=-49920
X43619 5 4 3781 637 7001 EO2_5VX1 $T=1240 -259840 0 180 $X=-5350 $Y=-264960
X43620 5 4 3864 760 3894 EO2_5VX1 $T=10760 -17920 0 0 $X=10330 $Y=-18560
X43621 5 4 3943 3979 4004 EO2_5VX1 $T=33160 -224000 1 0 $X=32730 $Y=-229120
X43622 5 4 4005 3983 7087 EO2_5VX1 $T=35960 -161280 0 0 $X=35530 $Y=-161920
X43623 5 4 625 4032 7078 EO2_5VX1 $T=44920 -26880 1 180 $X=38330 $Y=-27520
X43624 5 4 677 4140 7961 EO2_5VX1 $T=69000 -259840 1 0 $X=68570 $Y=-264960
X43625 5 4 7167 4246 7180 EO2_5VX1 $T=93640 -98560 1 0 $X=93210 $Y=-103680
X43626 5 4 7181 623 7168 EO2_5VX1 $T=103160 -26880 0 180 $X=96570 $Y=-32000
X43627 5 4 4887 4889 4901 EO2_5VX1 $T=231960 -89600 0 0 $X=231530 $Y=-90240
X43628 5 4 5000 7380 5010 EO2_5VX1 $T=259960 -44800 1 180 $X=253370 $Y=-45440
X43629 5 4 4963 1196 5018 EO2_5VX1 $T=262200 -26880 0 180 $X=255610 $Y=-32000
X43630 5 4 5033 1205 4955 EO2_5VX1 $T=272280 -44800 0 180 $X=265690 $Y=-49920
X43631 5 4 5048 1200 4899 EO2_5VX1 $T=273960 -8960 1 180 $X=267370 $Y=-9600
X43632 5 4 5206 7439 5183 EO2_5VX1 $T=293000 -53760 0 180 $X=286410 $Y=-58880
X43633 5 4 5192 7439 7444 EO2_5VX1 $T=290200 -44800 1 0 $X=289770 $Y=-49920
X43634 5 4 1161 5247 7468 EO2_5VX1 $T=299160 -17920 0 0 $X=298730 $Y=-18560
X43635 5 4 1159 7478 5223 EO2_5VX1 $T=312600 -44800 0 180 $X=306010 $Y=-49920
X43636 5 4 1173 7478 7476 EO2_5VX1 $T=306440 -35840 1 0 $X=306010 $Y=-40960
X43637 5 4 5337 5346 5363 EO2_5VX1 $T=326600 -71680 1 0 $X=326170 $Y=-76800
X43638 5 4 5349 5380 7528 EO2_5VX1 $T=331080 -98560 1 0 $X=330650 $Y=-103680
X43639 5 4 1519 5834 1367 EO2_5VX1 $T=450920 -268800 0 180 $X=444330 $Y=-273920
X43640 5 4 5856 1520 5882 EO2_5VX1 $T=452600 -53760 0 0 $X=452170 $Y=-54400
X43641 5 4 5869 1363 5905 EO2_5VX1 $T=455960 -17920 1 0 $X=455530 $Y=-23040
X43642 5 4 1123 5915 7774 EO2_5VX1 $T=458200 -188160 0 0 $X=457770 $Y=-188800
X43643 5 4 1504 7768 5917 EO2_5VX1 $T=458760 -98560 0 0 $X=458330 $Y=-99200
X43644 5 4 1515 7779 7771 EO2_5VX1 $T=468280 -116480 1 180 $X=461690 $Y=-117120
X43645 5 4 1123 4762 5935 EO2_5VX1 $T=463800 -134400 0 0 $X=463370 $Y=-135040
X43646 5 4 1133 7781 7786 EO2_5VX1 $T=466040 -206080 0 0 $X=465610 $Y=-206720
X43647 5 4 7789 1393 7783 EO2_5VX1 $T=472760 0 1 180 $X=466170 $Y=-640
X43648 5 4 1229 1402 7983 EO2_5VX1 $T=477800 -268800 1 180 $X=471210 $Y=-269440
X43649 5 4 5951 5924 5970 EO2_5VX1 $T=471640 -89600 0 0 $X=471210 $Y=-90240
X43650 5 4 1506 7799 7808 EO2_5VX1 $T=475560 -53760 0 0 $X=475130 $Y=-54400
X43651 5 4 5975 5947 7818 EO2_5VX1 $T=479480 -116480 1 0 $X=479050 $Y=-121600
X43652 5 4 4769 5997 6005 EO2_5VX1 $T=482280 -44800 1 0 $X=481850 $Y=-49920
X43653 5 4 6013 1397 1414 EO2_5VX1 $T=487320 -268800 1 0 $X=486890 $Y=-273920
X43654 5 4 6060 5893 6035 EO2_5VX1 $T=496840 -170240 1 180 $X=490250 $Y=-170880
X43655 5 4 1574 1654 1669 33 HA_5VX1 $T=-477560 -17920 0 0 $X=-477990 $Y=-18560
X43656 5 4 1639 6255 8005 1654 HA_5VX1 $T=-476440 -35840 0 0 $X=-476870 $Y=-36480
X43657 5 4 6244 1662 6265 1673 HA_5VX1 $T=-475880 -26880 1 0 $X=-476310 $Y=-32000
X43658 5 4 1582 1663 8006 1666 HA_5VX1 $T=-474760 -71680 0 0 $X=-475190 $Y=-72320
X43659 5 4 1569 1666 1691 6255 HA_5VX1 $T=-474760 -35840 1 0 $X=-475190 $Y=-40960
X43660 5 4 1603 1665 7936 1663 HA_5VX1 $T=-474200 -80640 1 0 $X=-474630 $Y=-85760
X43661 5 4 1644 6254 6269 36 HA_5VX1 $T=-473640 0 0 0 $X=-474070 $Y=-640
X43662 5 4 6249 1670 6266 1676 HA_5VX1 $T=-473080 -62720 1 0 $X=-473510 $Y=-67840
X43663 5 4 6251 6261 6274 6266 HA_5VX1 $T=-471400 -80640 0 0 $X=-471830 $Y=-81280
X43664 5 4 1649 6262 1673 6269 HA_5VX1 $T=-471400 -8960 1 0 $X=-471830 $Y=-14080
X43665 5 4 1653 1701 1676 6265 HA_5VX1 $T=-461320 -53760 0 180 $X=-470710 $Y=-58880
X43666 5 4 7935 1683 6276 1684 HA_5VX1 $T=-469720 -116480 1 0 $X=-470150 $Y=-121600
X43667 5 4 1578 1684 6277 1665 HA_5VX1 $T=-469720 -98560 1 0 $X=-470150 $Y=-103680
X43668 5 4 6256 1695 6281 1712 HA_5VX1 $T=-467480 -107520 1 0 $X=-467910 $Y=-112640
X43669 5 4 1672 1697 1712 6274 HA_5VX1 $T=-466920 -89600 1 0 $X=-467350 $Y=-94720
X43670 5 4 1609 1700 8007 1683 HA_5VX1 $T=-466360 -143360 0 0 $X=-466790 $Y=-144000
X43671 5 4 6258 1703 6284 6281 HA_5VX1 $T=-465800 -134400 0 0 $X=-466230 $Y=-135040
X43672 5 4 1627 1732 6286 1700 HA_5VX1 $T=-464120 -152320 1 0 $X=-464550 $Y=-157440
X43673 5 4 1686 1719 8008 6284 HA_5VX1 $T=-461880 -152320 0 0 $X=-462310 $Y=-152960
X43674 5 4 1724 6294 1784 1719 HA_5VX1 $T=-459640 -161280 1 0 $X=-460070 $Y=-166400
X43675 5 4 6293 6291 1746 1784 HA_5VX1 $T=-448440 -170240 0 180 $X=-457830 $Y=-175360
X43676 5 4 1742 6288 1799 1732 HA_5VX1 $T=-456840 -188160 0 0 $X=-457270 $Y=-188800
X43677 5 4 1680 1802 8009 1799 HA_5VX1 $T=-449000 -197120 1 0 $X=-449430 $Y=-202240
X43678 5 4 1706 1816 6311 1802 HA_5VX1 $T=-445640 -215040 0 0 $X=-446070 $Y=-215680
X43679 5 4 1831 1839 6318 1816 HA_5VX1 $T=-439480 -224000 1 0 $X=-439910 $Y=-229120
X43680 5 4 6303 1847 1954 1746 HA_5VX1 $T=-439480 -188160 1 0 $X=-439910 $Y=-193280
X43681 5 4 1851 49 45 1971 HA_5VX1 $T=-436680 -17920 1 0 $X=-437110 $Y=-23040
X43682 5 4 1761 1871 6327 1839 HA_5VX1 $T=-435560 -241920 0 0 $X=-435990 $Y=-242560
X43683 5 4 1725 1882 1915 1871 HA_5VX1 $T=-432200 -250880 1 0 $X=-432630 $Y=-256000
X43684 5 4 1877 48 54 6326 HA_5VX1 $T=-431640 -53760 0 0 $X=-432070 $Y=-54400
X43685 5 4 66 73 76 1882 HA_5VX1 $T=-429400 -268800 1 0 $X=-429830 $Y=-273920
X43686 5 4 1886 58 48 1907 HA_5VX1 $T=-429400 -80640 0 0 $X=-429830 $Y=-81280
X43687 5 4 1902 1452 1900 1920 HA_5VX1 $T=-428280 -143360 0 0 $X=-428710 $Y=-144000
X43688 5 4 6338 1945 6354 1954 HA_5VX1 $T=-420440 -206080 0 0 $X=-420870 $Y=-206720
X43689 5 4 1958 59 47 1937 HA_5VX1 $T=-410920 -44800 0 180 $X=-420310 $Y=-49920
X43690 5 4 1944 1447 1462 1964 HA_5VX1 $T=-419320 -152320 1 0 $X=-419750 $Y=-157440
X43691 5 4 1961 80 1452 6360 HA_5VX1 $T=-414840 -179200 0 0 $X=-415270 $Y=-179840
X43692 5 4 2020 1990 6358 1992 HA_5VX1 $T=-400840 -259840 1 180 $X=-410230 $Y=-260480
X43693 5 4 1982 79 1447 2002 HA_5VX1 $T=-409800 -152320 1 0 $X=-410230 $Y=-157440
X43694 5 4 1608 2013 1449 1998 HA_5VX1 $T=-400280 -26880 1 180 $X=-409670 $Y=-27520
X43695 5 4 6359 6370 2075 1995 HA_5VX1 $T=-408120 -232960 0 0 $X=-408550 $Y=-233600
X43696 5 4 1975 1995 2031 1945 HA_5VX1 $T=-408120 -224000 0 0 $X=-408550 $Y=-224640
X43697 5 4 1990 99 6386 2016 HA_5VX1 $T=-407560 -259840 1 0 $X=-407990 $Y=-264960
X43698 5 4 1599 6380 1747 6375 HA_5VX1 $T=-398600 -53760 0 180 $X=-407990 $Y=-58880
X43699 5 4 6374 89 79 2021 HA_5VX1 $T=-406440 -152320 0 0 $X=-406870 $Y=-152960
X43700 5 4 1580 2019 1752 6380 HA_5VX1 $T=-397480 -71680 1 180 $X=-406870 $Y=-72320
X43701 5 4 2036 6384 1739 2019 HA_5VX1 $T=-396360 -89600 1 180 $X=-405750 $Y=-90240
X43702 5 4 2042 1998 1722 111 HA_5VX1 $T=-395240 0 0 180 $X=-404630 $Y=-5120
X43703 5 4 1577 1731 6375 2013 HA_5VX1 $T=-394680 -44800 0 180 $X=-404070 $Y=-49920
X43704 5 4 1952 6392 1757 6384 HA_5VX1 $T=-394120 -107520 1 180 $X=-403510 $Y=-108160
X43705 5 4 2018 6393 2047 1450 HA_5VX1 $T=-402520 -179200 0 0 $X=-402950 $Y=-179840
X43706 5 4 1861 2051 1767 6392 HA_5VX1 $T=-390200 -125440 1 180 $X=-399590 $Y=-126080
X43707 5 4 6386 120 127 6399 HA_5VX1 $T=-398040 -268800 0 0 $X=-398470 $Y=-269440
X43708 5 4 6389 6399 2096 2075 HA_5VX1 $T=-394680 -250880 0 0 $X=-395110 $Y=-251520
X43709 5 4 6398 2059 6411 2026 HA_5VX1 $T=-393560 -170240 0 0 $X=-393990 $Y=-170880
X43710 5 4 1849 2085 1803 2051 HA_5VX1 $T=-382920 -143360 1 180 $X=-392310 $Y=-144000
X43711 5 4 1883 1992 8010 2080 HA_5VX1 $T=-382360 -232960 0 180 $X=-391750 $Y=-238080
X43712 5 4 2105 2100 1807 2085 HA_5VX1 $T=-381800 -161280 0 180 $X=-391190 $Y=-166400
X43713 5 4 1788 6410 2017 2097 HA_5VX1 $T=-381240 -215040 1 180 $X=-390630 $Y=-215680
X43714 5 4 114 2080 2040 6410 HA_5VX1 $T=-379000 -224000 0 180 $X=-388390 $Y=-229120
X43715 5 4 2025 2098 7942 2059 HA_5VX1 $T=-387960 -188160 0 0 $X=-388390 $Y=-188800
X43716 5 4 2125 2097 1756 6409 HA_5VX1 $T=-378440 -188160 0 180 $X=-387830 $Y=-193280
X43717 5 4 144 1716 6409 2100 HA_5VX1 $T=-375640 -179200 0 180 $X=-385030 $Y=-184320
X43718 5 4 1547 2185 2112 2135 HA_5VX1 $T=-371720 -44800 0 180 $X=-381110 $Y=-49920
X43719 5 4 1576 2145 6427 2156 HA_5VX1 $T=-377880 -71680 0 0 $X=-378310 $Y=-72320
X43720 5 4 1613 6430 2149 2157 HA_5VX1 $T=-366120 -107520 0 180 $X=-375510 $Y=-112640
X43721 5 4 1542 2157 8011 6427 HA_5VX1 $T=-363880 -98560 1 180 $X=-373270 $Y=-99200
X43722 5 4 6440 2187 2164 2177 HA_5VX1 $T=-362200 -170240 0 180 $X=-371590 $Y=-175360
X43723 5 4 1555 2156 2196 2185 HA_5VX1 $T=-371160 -62720 1 0 $X=-371590 $Y=-67840
X43724 5 4 6441 2177 6426 6432 HA_5VX1 $T=-361640 -152320 0 180 $X=-371030 $Y=-157440
X43725 5 4 2192 6432 8012 2162 HA_5VX1 $T=-361640 -143360 0 180 $X=-371030 $Y=-148480
X43726 5 4 1628 2140 2162 6430 HA_5VX1 $T=-361640 -134400 1 180 $X=-371030 $Y=-135040
X43727 5 4 1570 2135 6424 6433 HA_5VX1 $T=-361640 -35840 0 180 $X=-371030 $Y=-40960
X43728 5 4 1563 6433 6428 2181 HA_5VX1 $T=-361640 -17920 0 180 $X=-371030 $Y=-23040
X43729 5 4 1564 2181 6420 2182 HA_5VX1 $T=-361640 0 0 180 $X=-371030 $Y=-5120
X43730 5 4 159 2182 8013 153 HA_5VX1 $T=-361640 8960 0 180 $X=-371030 $Y=3840
X43731 5 4 2232 2257 6464 6467 HA_5VX1 $T=-340920 -35840 0 0 $X=-341350 $Y=-36480
X43732 5 4 6450 2284 6470 6464 HA_5VX1 $T=-339800 -44800 1 0 $X=-340230 $Y=-49920
X43733 5 4 1626 2278 6459 2187 HA_5VX1 $T=-326920 -188160 1 180 $X=-336310 $Y=-188800
X43734 5 4 6453 6469 6480 6470 HA_5VX1 $T=-335880 -62720 1 0 $X=-336310 $Y=-67840
X43735 5 4 2295 6479 6456 2278 HA_5VX1 $T=-326360 -188160 0 180 $X=-335750 $Y=-193280
X43736 5 4 6462 2283 6484 2297 HA_5VX1 $T=-333640 -116480 0 0 $X=-334070 $Y=-117120
X43737 5 4 2275 6474 6483 6480 HA_5VX1 $T=-333640 -89600 0 0 $X=-334070 $Y=-90240
X43738 5 4 2271 2285 8014 6476 HA_5VX1 $T=-333640 -8960 0 0 $X=-334070 $Y=-9600
X43739 5 4 174 6476 8015 180 HA_5VX1 $T=-333640 8960 1 0 $X=-334070 $Y=3840
X43740 5 4 1679 2262 8016 6479 HA_5VX1 $T=-324120 -215040 0 180 $X=-333510 $Y=-220160
X43741 5 4 2247 6471 2297 6483 HA_5VX1 $T=-333080 -107520 0 0 $X=-333510 $Y=-108160
X43742 5 4 1458 6486 6467 2285 HA_5VX1 $T=-323000 -26880 1 180 $X=-332390 $Y=-27520
X43743 5 4 6488 2318 6493 6484 HA_5VX1 $T=-320200 -134400 1 180 $X=-329590 $Y=-135040
X43744 5 4 6496 2351 2313 2318 HA_5VX1 $T=-315160 -161280 1 180 $X=-324550 $Y=-161920
X43745 5 4 2315 6492 194 2304 HA_5VX1 $T=-321880 -241920 0 0 $X=-322310 $Y=-242560
X43746 5 4 2329 2364 2425 2351 HA_5VX1 $T=-312360 -170240 0 0 $X=-312790 $Y=-170880
X43747 5 4 2493 58 59 6517 HA_5VX1 $T=-297800 -26880 0 180 $X=-307190 $Y=-32000
X43748 5 4 2480 92 89 2468 HA_5VX1 $T=-284360 -250880 1 180 $X=-293750 $Y=-251520
X43749 5 4 2516 79 80 6534 HA_5VX1 $T=-283800 -188160 0 180 $X=-293190 $Y=-193280
X43750 5 4 2598 84 79 6540 HA_5VX1 $T=-277640 -206080 1 180 $X=-287030 $Y=-206720
X43751 5 4 238 1841 58 6545 HA_5VX1 $T=-275400 -17920 0 180 $X=-284790 $Y=-23040
X43752 5 4 2562 1447 1452 6549 HA_5VX1 $T=-274280 -107520 1 180 $X=-283670 $Y=-108160
X43753 5 4 2565 80 1447 2540 HA_5VX1 $T=-273720 -143360 1 180 $X=-283110 $Y=-144000
X43754 5 4 2530 1452 1462 6556 HA_5VX1 $T=-280440 -62720 0 0 $X=-280870 $Y=-63360
X43755 5 4 2532 1462 1900 6566 HA_5VX1 $T=-275960 -44800 0 0 $X=-276390 $Y=-45440
X43756 5 4 250 58 59 2585 HA_5VX1 $T=-264760 8960 0 180 $X=-274150 $Y=3840
X43757 5 4 2588 6570 6578 2615 HA_5VX1 $T=-269800 -134400 0 0 $X=-270230 $Y=-135040
X43758 5 4 2646 1900 1841 6576 HA_5VX1 $T=-258040 -35840 1 180 $X=-267430 $Y=-36480
X43759 5 4 266 6588 8017 6581 HA_5VX1 $T=-253560 -259840 0 180 $X=-262950 $Y=-264960
X43760 5 4 267 6590 2625 2650 HA_5VX1 $T=-253560 -232960 1 180 $X=-262950 $Y=-233600
X43761 5 4 271 6589 2628 6590 HA_5VX1 $T=-253000 -241920 0 180 $X=-262390 $Y=-247040
X43762 5 4 274 6593 2633 2643 HA_5VX1 $T=-253000 -197120 0 180 $X=-262390 $Y=-202240
X43763 5 4 278 8018 261 6588 HA_5VX1 $T=-250760 -268800 0 180 $X=-260150 $Y=-273920
X43764 5 4 270 6596 6581 6589 HA_5VX1 $T=-250760 -259840 1 180 $X=-260150 $Y=-260480
X43765 5 4 6577 6587 2677 2425 HA_5VX1 $T=-259720 -179200 0 0 $X=-260150 $Y=-179840
X43766 5 4 279 2650 6583 6593 HA_5VX1 $T=-248520 -224000 0 180 $X=-257910 $Y=-229120
X43767 5 4 283 2643 6592 2666 HA_5VX1 $T=-247960 -188160 1 180 $X=-257350 $Y=-188800
X43768 5 4 297 6616 2694 2705 HA_5VX1 $T=-239560 -143360 1 180 $X=-248950 $Y=-144000
X43769 5 4 2147 6617 2692 2708 HA_5VX1 $T=-239000 -80640 0 180 $X=-248390 $Y=-85760
X43770 5 4 2748 6619 6608 6617 HA_5VX1 $T=-236760 -98560 1 180 $X=-246150 $Y=-99200
X43771 5 4 2745 2705 6582 6619 HA_5VX1 $T=-236200 -125440 1 180 $X=-245590 $Y=-126080
X43772 5 4 2760 2666 2651 6616 HA_5VX1 $T=-235640 -152320 0 180 $X=-245030 $Y=-157440
X43773 5 4 1454 6622 2718 2732 HA_5VX1 $T=-234520 -35840 0 180 $X=-243910 $Y=-40960
X43774 5 4 2460 2708 6629 6622 HA_5VX1 $T=-242920 -53760 0 0 $X=-243350 $Y=-54400
X43775 5 4 2737 6624 6635 2677 HA_5VX1 $T=-237320 -188160 1 0 $X=-237750 $Y=-193280
X43776 5 4 3597 2768 8019 318 HA_5VX1 $T=-227240 -8960 1 180 $X=-236630 $Y=-9600
X43777 5 4 2444 2732 6625 2768 HA_5VX1 $T=-226680 -17920 0 180 $X=-236070 $Y=-23040
X43778 5 4 6628 6630 2803 6635 HA_5VX1 $T=-233960 -206080 1 0 $X=-234390 $Y=-211200
X43779 5 4 2804 6643 7998 2822 HA_5VX1 $T=-226680 -197120 1 0 $X=-227110 $Y=-202240
X43780 5 4 2814 334 2836 2829 HA_5VX1 $T=-222760 -250880 1 0 $X=-223190 $Y=-256000
X43781 5 4 2870 2822 2818 6647 HA_5VX1 $T=-212680 -170240 0 180 $X=-222070 $Y=-175360
X43782 5 4 3017 6695 6705 6701 HA_5VX1 $T=-183000 -179200 1 0 $X=-183430 $Y=-184320
X43783 5 4 8020 6701 8021 3034 HA_5VX1 $T=-173480 -170240 1 180 $X=-182870 $Y=-170880
X43784 5 4 8022 6704 8023 6699 HA_5VX1 $T=-172920 -224000 1 180 $X=-182310 $Y=-224640
X43785 5 4 8024 3036 6696 3039 HA_5VX1 $T=-172920 -89600 0 180 $X=-182310 $Y=-94720
X43786 5 4 3119 3054 3026 3044 HA_5VX1 $T=-172920 0 1 180 $X=-182310 $Y=-640
X43787 5 4 3049 3034 6694 6702 HA_5VX1 $T=-172360 -152320 1 180 $X=-181750 $Y=-152960
X43788 5 4 8025 3047 8026 6704 HA_5VX1 $T=-171800 -241920 1 180 $X=-181190 $Y=-242560
X43789 5 4 8027 6713 6702 3038 HA_5VX1 $T=-171240 -125440 0 180 $X=-180630 $Y=-130560
X43790 5 4 8028 3038 3027 3036 HA_5VX1 $T=-171240 -107520 0 180 $X=-180630 $Y=-112640
X43791 5 4 6718 3060 3028 3043 HA_5VX1 $T=-171240 -8960 0 180 $X=-180630 $Y=-14080
X43792 5 4 6717 408 6697 3047 HA_5VX1 $T=-170120 -250880 0 180 $X=-179510 $Y=-256000
X43793 5 4 1473 3022 6699 6705 HA_5VX1 $T=-170120 -206080 0 180 $X=-179510 $Y=-211200
X43794 5 4 399 6708 6719 414 HA_5VX1 $T=-177400 8960 0 0 $X=-177830 $Y=8320
X43795 5 4 3090 6703 3052 3070 HA_5VX1 $T=-167320 -62720 1 180 $X=-176710 $Y=-63360
X43796 5 4 3066 6725 3049 6715 HA_5VX1 $T=-166200 -143360 0 180 $X=-175590 $Y=-148480
X43797 5 4 6711 6706 3070 3080 HA_5VX1 $T=-174600 -44800 0 0 $X=-175030 $Y=-45440
X43798 5 4 3100 3039 6710 3052 HA_5VX1 $T=-165080 -71680 0 180 $X=-174470 $Y=-76800
X43799 5 4 6730 3059 6711 6716 HA_5VX1 $T=-165080 -35840 0 180 $X=-174470 $Y=-40960
X43800 5 4 3026 6714 3092 6719 HA_5VX1 $T=-173480 0 1 0 $X=-173910 $Y=-5120
X43801 5 4 3103 3095 8022 3085 HA_5VX1 $T=-163960 -224000 1 180 $X=-173350 $Y=-224640
X43802 5 4 3050 3098 8024 3068 HA_5VX1 $T=-163960 -89600 0 180 $X=-173350 $Y=-94720
X43803 5 4 6712 3062 3017 6724 HA_5VX1 $T=-172360 -179200 1 0 $X=-172790 $Y=-184320
X43804 5 4 3028 2977 3080 3092 HA_5VX1 $T=-172360 -17920 1 0 $X=-172790 $Y=-23040
X43805 5 4 3082 6731 8025 3091 HA_5VX1 $T=-162280 -241920 1 180 $X=-171670 $Y=-242560
X43806 5 4 3083 6729 8020 3073 HA_5VX1 $T=-162280 -170240 1 180 $X=-171670 $Y=-170880
X43807 5 4 8029 2793 3077 2803 HA_5VX1 $T=-161720 -250880 1 180 $X=-171110 $Y=-251520
X43808 5 4 3067 6736 8027 3063 HA_5VX1 $T=-161720 -125440 0 180 $X=-171110 $Y=-130560
X43809 5 4 3056 3105 8028 3057 HA_5VX1 $T=-161720 -107520 0 180 $X=-171110 $Y=-112640
X43810 5 4 3064 3087 3100 3069 HA_5VX1 $T=-170680 -71680 0 0 $X=-171110 $Y=-72320
X43811 5 4 432 3107 6717 6723 HA_5VX1 $T=-161160 -259840 1 180 $X=-170550 $Y=-260480
X43812 5 4 3065 2898 3090 6733 HA_5VX1 $T=-170120 -53760 1 0 $X=-170550 $Y=-58880
X43813 5 4 3109 6726 1473 3061 HA_5VX1 $T=-157240 -206080 1 180 $X=-166630 $Y=-206720
X43814 5 4 6751 3029 431 3077 HA_5VX1 $T=-155560 -268800 1 180 $X=-164950 $Y=-269440
X43815 5 4 450 3148 8029 6615 HA_5VX1 $T=-152200 -250880 1 180 $X=-161590 $Y=-251520
X43816 5 4 6740 3149 3131 6745 HA_5VX1 $T=-156680 -134400 0 0 $X=-157110 $Y=-135040
X43817 5 4 455 6751 443 3148 HA_5VX1 $T=-146600 -268800 1 180 $X=-155990 $Y=-269440
X43818 5 4 3200 6765 3169 6758 HA_5VX1 $T=-139320 -232960 0 180 $X=-148710 $Y=-238080
X43819 5 4 3255 6785 3222 3230 HA_5VX1 $T=-128680 -250880 0 180 $X=-138070 $Y=-256000
X43820 5 4 3188 3292 3223 6777 HA_5VX1 $T=-127560 -26880 1 180 $X=-136950 $Y=-27520
X43821 5 4 3223 3235 6790 3236 HA_5VX1 $T=-136520 -17920 0 0 $X=-136950 $Y=-18560
X43822 5 4 3203 6779 3270 6786 HA_5VX1 $T=-135960 -62720 1 0 $X=-136390 $Y=-67840
X43823 5 4 3234 6776 3274 3253 HA_5VX1 $T=-135400 -44800 0 0 $X=-135830 $Y=-45440
X43824 5 4 3233 3202 8030 3259 HA_5VX1 $T=-134840 -80640 0 0 $X=-135270 $Y=-81280
X43825 5 4 482 485 494 487 HA_5VX1 $T=-134840 8960 0 0 $X=-135270 $Y=8320
X43826 5 4 3247 6791 8031 1475 HA_5VX1 $T=-130360 -125440 0 0 $X=-130790 $Y=-126080
X43827 5 4 3212 3227 6802 3269 HA_5VX1 $T=-130360 -107520 1 0 $X=-130790 $Y=-112640
X43828 5 4 3257 3246 8032 3268 HA_5VX1 $T=-129800 -143360 1 0 $X=-130230 $Y=-148480
X43829 5 4 1477 6792 8033 3252 HA_5VX1 $T=-129800 -89600 1 0 $X=-130230 $Y=-94720
X43830 5 4 6790 3272 7923 3283 HA_5VX1 $T=-129800 -17920 1 0 $X=-130230 $Y=-23040
X43831 5 4 3239 6789 3290 3215 HA_5VX1 $T=-129800 -8960 0 0 $X=-130230 $Y=-9600
X43832 5 4 3214 3271 3305 3292 HA_5VX1 $T=-125880 -26880 0 0 $X=-126310 $Y=-27520
X43833 5 4 6799 3293 6817 3261 HA_5VX1 $T=-121960 -232960 1 0 $X=-122390 $Y=-238080
X43834 5 4 3266 3279 8034 6806 HA_5VX1 $T=-121960 -161280 0 0 $X=-122390 $Y=-161920
X43835 5 4 8030 7925 3320 3308 HA_5VX1 $T=-121960 -80640 0 0 $X=-122390 $Y=-81280
X43836 5 4 3209 508 6811 485 HA_5VX1 $T=-121960 8960 0 0 $X=-122390 $Y=8320
X43837 5 4 3222 6803 535 3368 HA_5VX1 $T=-121400 -259840 0 0 $X=-121830 $Y=-260480
X43838 5 4 8031 3297 3314 3311 HA_5VX1 $T=-121400 -125440 0 0 $X=-121830 $Y=-126080
X43839 5 4 6802 3393 3311 3312 HA_5VX1 $T=-121400 -107520 1 0 $X=-121830 $Y=-112640
X43840 5 4 3265 3299 6818 3304 HA_5VX1 $T=-120840 -206080 1 0 $X=-121270 $Y=-211200
X43841 5 4 6794 3278 8035 3285 HA_5VX1 $T=-120840 -197120 0 0 $X=-121270 $Y=-197760
X43842 5 4 6804 3276 6813 3198 HA_5VX1 $T=-120840 -179200 0 0 $X=-121270 $Y=-179840
X43843 5 4 8032 3300 6834 3314 HA_5VX1 $T=-120840 -143360 1 0 $X=-121270 $Y=-148480
X43844 5 4 8033 6805 3312 3320 HA_5VX1 $T=-120840 -89600 1 0 $X=-121270 $Y=-94720
X43845 5 4 3270 3301 3308 3315 HA_5VX1 $T=-120840 -62720 0 0 $X=-121270 $Y=-63360
X43846 5 4 3274 3303 3315 3294 HA_5VX1 $T=-120840 -44800 1 0 $X=-121270 $Y=-49920
X43847 5 4 3305 3317 3294 7923 HA_5VX1 $T=-111880 -17920 0 180 $X=-121270 $Y=-23040
X43848 5 4 3290 3365 3283 3295 HA_5VX1 $T=-111880 -8960 1 180 $X=-121270 $Y=-9600
X43849 5 4 6811 3318 3295 517 HA_5VX1 $T=-111880 0 0 180 $X=-121270 $Y=-5120
X43850 5 4 6817 6826 3368 3357 HA_5VX1 $T=-97880 -232960 0 0 $X=-98310 $Y=-233600
X43851 5 4 6818 6828 3357 3349 HA_5VX1 $T=-97880 -215040 0 0 $X=-98310 $Y=-215680
X43852 5 4 8035 6829 3349 3353 HA_5VX1 $T=-97880 -197120 0 0 $X=-98310 $Y=-197760
X43853 5 4 6813 3340 3353 3358 HA_5VX1 $T=-97880 -179200 1 0 $X=-98310 $Y=-184320
X43854 5 4 6819 3342 3643 6835 HA_5VX1 $T=-97880 -80640 0 0 $X=-98310 $Y=-81280
X43855 5 4 3332 3364 3370 6836 HA_5VX1 $T=-97880 -53760 1 0 $X=-98310 $Y=-58880
X43856 5 4 3325 3343 3373 561 HA_5VX1 $T=-97880 0 0 0 $X=-98310 $Y=-640
X43857 5 4 536 548 6840 6830 HA_5VX1 $T=-97320 -268800 1 0 $X=-97750 $Y=-273920
X43858 5 4 6816 6830 3330 6833 HA_5VX1 $T=-97320 -250880 0 0 $X=-97750 $Y=-251520
X43859 5 4 8034 6831 3358 6834 HA_5VX1 $T=-97320 -161280 0 0 $X=-97750 $Y=-161920
X43860 5 4 3321 6835 3384 3364 HA_5VX1 $T=-96760 -62720 1 0 $X=-97190 $Y=-67840
X43861 5 4 6820 6833 8036 6838 HA_5VX1 $T=-95640 -224000 1 0 $X=-96070 $Y=-229120
X43862 5 4 558 3401 3391 3382 HA_5VX1 $T=-93960 -170240 1 0 $X=-94390 $Y=-175360
X43863 5 4 556 6838 6854 6846 HA_5VX1 $T=-91720 -197120 1 0 $X=-92150 $Y=-202240
X43864 5 4 3288 3375 6864 3342 HA_5VX1 $T=-91160 -98560 0 0 $X=-91590 $Y=-99200
X43865 5 4 559 564 3382 3392 HA_5VX1 $T=-90600 -152320 1 0 $X=-91030 $Y=-157440
X43866 5 4 568 6846 6856 3401 HA_5VX1 $T=-88920 -179200 1 0 $X=-89350 $Y=-184320
X43867 5 4 557 3386 3430 3375 HA_5VX1 $T=-88920 -116480 1 0 $X=-89350 $Y=-121600
X43868 5 4 2704 6836 3421 7953 HA_5VX1 $T=-87800 -35840 0 0 $X=-88230 $Y=-36480
X43869 5 4 3441 3433 7953 3343 HA_5VX1 $T=-76040 -17920 0 180 $X=-85430 $Y=-23040
X43870 5 4 572 3392 3452 3386 HA_5VX1 $T=-83320 -134400 1 0 $X=-83750 $Y=-139520
X43871 5 4 3545 620 614 3524 HA_5VX1 $T=-50280 -89600 1 180 $X=-59670 $Y=-90240
X43872 5 4 641 609 629 3537 HA_5VX1 $T=-46920 0 0 180 $X=-56310 $Y=-5120
X43873 5 4 3629 607 611 3590 HA_5VX1 $T=-37960 0 0 180 $X=-47350 $Y=-5120
X43874 5 4 6943 670 679 6953 HA_5VX1 $T=-35160 -268800 0 0 $X=-35590 $Y=-269440
X43875 5 4 3673 679 637 6961 HA_5VX1 $T=-31240 -259840 0 0 $X=-31670 $Y=-260480
X43876 5 4 3710 595 586 3682 HA_5VX1 $T=-22280 -152320 1 180 $X=-31670 $Y=-152960
X43877 5 4 3736 632 592 6964 HA_5VX1 $T=-16120 -188160 1 180 $X=-25510 $Y=-188800
X43878 5 4 6980 592 595 3636 HA_5VX1 $T=-14440 -179200 1 180 $X=-23830 $Y=-179840
X43879 5 4 3708 637 677 3727 HA_5VX1 $T=-22840 -232960 0 0 $X=-23270 $Y=-233600
X43880 5 4 3762 677 632 3740 HA_5VX1 $T=-7160 -206080 0 180 $X=-16550 $Y=-211200
X43881 5 4 3803 586 624 3763 HA_5VX1 $T=680 -152320 1 180 $X=-8710 $Y=-152960
X43882 5 4 7928 3829 722 3798 HA_5VX1 $T=-8280 0 1 0 $X=-8710 $Y=-5120
X43883 5 4 3822 725 711 7008 HA_5VX1 $T=2920 -215040 0 180 $X=-6470 $Y=-220160
X43884 5 4 3792 624 584 7014 HA_5VX1 $T=-3240 -125440 1 0 $X=-3670 $Y=-130560
X43885 5 4 3823 1489 1496 7012 HA_5VX1 $T=5720 -107520 1 180 $X=-3670 $Y=-108160
X43886 5 4 7021 584 1489 7015 HA_5VX1 $T=7400 -116480 0 180 $X=-1990 $Y=-121600
X43887 5 4 3839 1496 3504 3788 HA_5VX1 $T=7400 -89600 1 180 $X=-1990 $Y=-90240
X43888 5 4 7016 625 607 3847 HA_5VX1 $T=2920 -44800 0 0 $X=2490 $Y=-45440
X43889 5 4 745 3862 3880 7029 HA_5VX1 $T=8520 -206080 0 0 $X=8090 $Y=-206720
X43890 5 4 746 7029 3866 3879 HA_5VX1 $T=8520 -179200 1 0 $X=8090 $Y=-184320
X43891 5 4 3852 7028 8037 3887 HA_5VX1 $T=9080 -241920 1 0 $X=8650 $Y=-247040
X43892 5 4 750 3870 3883 3862 HA_5VX1 $T=10200 -224000 0 0 $X=9770 $Y=-224640
X43893 5 4 3842 607 611 3893 HA_5VX1 $T=10760 -26880 0 0 $X=10330 $Y=-27520
X43894 5 4 3911 7043 3875 7034 HA_5VX1 $T=21400 -188160 0 180 $X=12010 $Y=-193280
X43895 5 4 758 3852 3919 3870 HA_5VX1 $T=13560 -232960 1 0 $X=13130 $Y=-238080
X43896 5 4 762 3879 3843 3908 HA_5VX1 $T=13560 -161280 1 0 $X=13130 $Y=-166400
X43897 5 4 3925 7045 7034 3881 HA_5VX1 $T=23080 -188160 1 180 $X=13690 $Y=-188800
X43898 5 4 7054 7048 3888 7042 HA_5VX1 $T=23640 -232960 1 180 $X=14250 $Y=-233600
X43899 5 4 7051 3916 3881 3898 HA_5VX1 $T=23640 -170240 0 180 $X=14250 $Y=-175360
X43900 5 4 3906 1496 625 7039 HA_5VX1 $T=23640 -35840 1 180 $X=14250 $Y=-36480
X43901 5 4 8037 7044 8038 3888 HA_5VX1 $T=18040 -241920 1 0 $X=17610 $Y=-247040
X43902 5 4 7065 3907 7042 3875 HA_5VX1 $T=29240 -215040 0 180 $X=19850 $Y=-220160
X43903 5 4 3897 1489 3504 7052 HA_5VX1 $T=20840 -62720 0 0 $X=20410 $Y=-63360
X43904 5 4 784 3952 3908 7062 HA_5VX1 $T=21960 -143360 0 0 $X=21530 $Y=-144000
X43905 5 4 3954 595 624 3972 HA_5VX1 $T=26440 -143360 1 0 $X=26010 $Y=-148480
X43906 5 4 794 3504 607 3965 HA_5VX1 $T=29240 -17920 0 0 $X=28810 $Y=-18560
X43907 5 4 7067 3984 7081 4001 HA_5VX1 $T=30920 -98560 0 0 $X=30490 $Y=-99200
X43908 5 4 7090 7079 3898 3995 HA_5VX1 $T=40440 -143360 1 180 $X=31050 $Y=-144000
X43909 5 4 4026 7077 7062 3984 HA_5VX1 $T=40440 -125440 1 180 $X=31050 $Y=-126080
X43910 5 4 3928 3987 3953 1494 HA_5VX1 $T=32040 -125440 1 0 $X=31610 $Y=-130560
X43911 5 4 3979 592 586 7085 HA_5VX1 $T=34280 -206080 0 0 $X=33850 $Y=-206720
X43912 5 4 3983 624 1489 4025 HA_5VX1 $T=34840 -152320 0 0 $X=34410 $Y=-152960
X43913 5 4 7094 3914 7093 807 HA_5VX1 $T=37080 0 1 0 $X=36650 $Y=-5120
X43914 5 4 4021 679 677 4013 HA_5VX1 $T=48840 -224000 0 180 $X=39450 $Y=-229120
X43915 5 4 4020 7083 7096 7093 HA_5VX1 $T=39880 -26880 1 0 $X=39450 $Y=-32000
X43916 5 4 4015 584 1496 4047 HA_5VX1 $T=40440 -71680 1 0 $X=40010 $Y=-76800
X43917 5 4 4096 4066 3995 4038 HA_5VX1 $T=52200 -134400 1 180 $X=42810 $Y=-135040
X43918 5 4 4083 4040 4035 7096 HA_5VX1 $T=52760 -44800 1 180 $X=43370 $Y=-45440
X43919 5 4 4084 7106 7071 810 HA_5VX1 $T=52760 -8960 0 180 $X=43370 $Y=-14080
X43920 5 4 7109 7101 4038 4039 HA_5VX1 $T=53320 -98560 1 180 $X=43930 $Y=-99200
X43921 5 4 4087 7929 4039 4035 HA_5VX1 $T=53320 -80640 0 180 $X=43930 $Y=-85760
X43922 5 4 4113 3895 4064 7106 HA_5VX1 $T=57800 -26880 0 180 $X=48410 $Y=-32000
X43923 5 4 4058 4072 4049 4099 HA_5VX1 $T=49400 -188160 0 0 $X=48970 $Y=-188800
X43924 5 4 4109 4036 4061 4079 HA_5VX1 $T=58920 -215040 1 180 $X=49530 $Y=-215680
X43925 5 4 3890 7117 4082 7111 HA_5VX1 $T=63960 -53760 1 180 $X=54570 $Y=-54400
X43926 5 4 847 7120 4118 830 HA_5VX1 $T=65640 -8960 0 180 $X=56250 $Y=-14080
X43927 5 4 4150 632 595 4042 HA_5VX1 $T=66200 -197120 1 180 $X=56810 $Y=-197760
X43928 5 4 4119 7111 7127 7120 HA_5VX1 $T=57240 -17920 1 0 $X=56810 $Y=-23040
X43929 5 4 832 835 854 7124 HA_5VX1 $T=59480 -268800 0 0 $X=59050 $Y=-269440
X43930 5 4 851 7129 8039 4139 HA_5VX1 $T=68440 -62720 1 180 $X=59050 $Y=-63360
X43931 5 4 4164 4001 4091 7117 HA_5VX1 $T=69000 -89600 1 180 $X=59610 $Y=-90240
X43932 5 4 4081 4162 4532 7129 HA_5VX1 $T=71800 -89600 0 180 $X=62410 $Y=-94720
X43933 5 4 840 7124 4170 7131 HA_5VX1 $T=65080 -250880 1 0 $X=64650 $Y=-256000
X43934 5 4 842 7131 7141 4153 HA_5VX1 $T=66200 -232960 1 0 $X=65770 $Y=-238080
X43935 5 4 843 4153 7156 7138 HA_5VX1 $T=66200 -206080 1 0 $X=65770 $Y=-211200
X43936 5 4 864 7138 4180 871 HA_5VX1 $T=69560 -188160 1 0 $X=69130 $Y=-193280
X43937 5 4 869 875 890 4189 HA_5VX1 $T=71800 -170240 0 0 $X=71370 $Y=-170880
X43938 5 4 872 4181 4189 7146 HA_5VX1 $T=72360 -143360 0 0 $X=71930 $Y=-144000
X43939 5 4 4100 7146 4233 4162 HA_5VX1 $T=76840 -107520 1 0 $X=76410 $Y=-112640
X43940 5 4 4246 620 623 4256 HA_5VX1 $T=84680 -89600 0 0 $X=84250 $Y=-90240
X43941 5 4 7181 607 611 4342 HA_5VX1 $T=112120 -26880 1 0 $X=111690 $Y=-32000
X43942 5 4 7219 4503 4302 7231 HA_5VX1 $T=151880 -232960 1 0 $X=151450 $Y=-238080
X43943 5 4 1006 4528 8040 4517 HA_5VX1 $T=160840 -206080 1 180 $X=151450 $Y=-206720
X43944 5 4 1007 7229 4488 7222 HA_5VX1 $T=160840 -170240 0 180 $X=151450 $Y=-175360
X43945 5 4 4529 4513 7208 4514 HA_5VX1 $T=160840 -170240 1 180 $X=151450 $Y=-170880
X43946 5 4 1002 7205 7222 4510 HA_5VX1 $T=160840 -161280 0 180 $X=151450 $Y=-166400
X43947 5 4 7243 4525 4498 4496 HA_5VX1 $T=160840 -134400 1 180 $X=151450 $Y=-135040
X43948 5 4 1003 4519 8041 7234 HA_5VX1 $T=160840 -125440 1 180 $X=151450 $Y=-126080
X43949 5 4 8042 4526 7223 4499 HA_5VX1 $T=160840 -107520 1 180 $X=151450 $Y=-108160
X43950 5 4 4537 7234 7216 4508 HA_5VX1 $T=160840 -98560 1 180 $X=151450 $Y=-99200
X43951 5 4 4540 4487 4499 7226 HA_5VX1 $T=160840 -89600 0 180 $X=151450 $Y=-94720
X43952 5 4 976 4508 4536 7227 HA_5VX1 $T=151880 -71680 0 0 $X=151450 $Y=-72320
X43953 5 4 8043 7226 4434 4511 HA_5VX1 $T=160840 -62720 0 180 $X=151450 $Y=-67840
X43954 5 4 4541 4446 4502 4515 HA_5VX1 $T=160840 -26880 0 180 $X=151450 $Y=-32000
X43955 5 4 1001 7232 7218 4506 HA_5VX1 $T=160840 -8960 1 180 $X=151450 $Y=-9600
X43956 5 4 1004 4495 4506 995 HA_5VX1 $T=160840 0 1 180 $X=151450 $Y=-640
X43957 5 4 8044 4531 7215 4512 HA_5VX1 $T=161400 -215040 0 180 $X=152010 $Y=-220160
X43958 5 4 7264 4512 7220 4513 HA_5VX1 $T=161400 -197120 0 180 $X=152010 $Y=-202240
X43959 5 4 1008 4517 8045 7229 HA_5VX1 $T=161400 -188160 0 180 $X=152010 $Y=-193280
X43960 5 4 7239 4514 7217 4498 HA_5VX1 $T=161400 -152320 0 180 $X=152010 $Y=-157440
X43961 5 4 1009 4510 1498 4519 HA_5VX1 $T=161400 -143360 0 180 $X=152010 $Y=-148480
X43962 5 4 4554 4493 4496 7223 HA_5VX1 $T=161400 -116480 1 180 $X=152010 $Y=-117120
X43963 5 4 1010 7227 4486 7225 HA_5VX1 $T=161400 -44800 0 180 $X=152010 $Y=-49920
X43964 5 4 4475 7225 4489 7232 HA_5VX1 $T=152440 -26880 0 0 $X=152010 $Y=-27520
X43965 5 4 4539 4511 8046 4502 HA_5VX1 $T=161960 -62720 1 180 $X=152570 $Y=-63360
X43966 5 4 7244 4515 4467 996 HA_5VX1 $T=163640 0 0 180 $X=154250 $Y=-5120
X43967 5 4 8047 7242 4516 7237 HA_5VX1 $T=165320 -259840 1 180 $X=155930 $Y=-260480
X43968 5 4 4583 7241 990 4516 HA_5VX1 $T=165880 -268800 0 180 $X=156490 $Y=-273920
X43969 5 4 985 7231 1499 4528 HA_5VX1 $T=156920 -224000 1 0 $X=156490 $Y=-229120
X43970 5 4 4578 4491 7237 4531 HA_5VX1 $T=169240 -241920 1 180 $X=159850 $Y=-242560
X43971 5 4 1047 7256 8047 4568 HA_5VX1 $T=174280 -259840 1 180 $X=164890 $Y=-260480
X43972 5 4 1048 4583 1025 7256 HA_5VX1 $T=174840 -268800 0 180 $X=165450 $Y=-273920
X43973 5 4 4654 4716 7292 7285 HA_5VX1 $T=188840 -259840 0 0 $X=188410 $Y=-260480
X43974 5 4 3910 7289 7297 7292 HA_5VX1 $T=191640 -259840 1 0 $X=191210 $Y=-264960
X43975 5 4 4616 1097 4719 7289 HA_5VX1 $T=192200 -268800 1 0 $X=191770 $Y=-273920
X43976 5 4 4115 7285 7298 4697 HA_5VX1 $T=192760 -250880 1 0 $X=192330 $Y=-256000
X43977 5 4 7284 4687 4717 7296 HA_5VX1 $T=193320 -215040 1 0 $X=192890 $Y=-220160
X43978 5 4 7297 4712 8048 4755 HA_5VX1 $T=198920 -259840 0 0 $X=198490 $Y=-260480
X43979 5 4 7298 7302 7310 4736 HA_5VX1 $T=200040 -241920 0 0 $X=199610 $Y=-242560
X43980 5 4 4716 4727 4755 7310 HA_5VX1 $T=201720 -250880 1 0 $X=201290 $Y=-256000
X43981 5 4 4719 7311 1114 4712 HA_5VX1 $T=211240 -268800 0 180 $X=201850 $Y=-273920
X43982 5 4 7301 4730 4736 4751 HA_5VX1 $T=202280 -215040 1 0 $X=201850 $Y=-220160
X43983 5 4 4743 7312 4751 4774 HA_5VX1 $T=206200 -206080 0 0 $X=205770 $Y=-206720
X43984 5 4 8049 7315 4774 4777 HA_5VX1 $T=207880 -188160 1 0 $X=207450 $Y=-193280
X43985 5 4 8050 4782 7325 4808 HA_5VX1 $T=211800 -143360 1 0 $X=211370 $Y=-148480
X43986 5 4 7317 4783 4808 4851 HA_5VX1 $T=211800 -134400 0 0 $X=211370 $Y=-135040
X43987 5 4 7319 7320 4824 4811 HA_5VX1 $T=212360 -89600 1 0 $X=211930 $Y=-94720
X43988 5 4 7318 4790 4816 7325 HA_5VX1 $T=212920 -152320 1 0 $X=212490 $Y=-157440
X43989 5 4 8051 4798 4777 4816 HA_5VX1 $T=213480 -170240 1 0 $X=213050 $Y=-175360
X43990 5 4 8052 7321 4811 4821 HA_5VX1 $T=214040 -71680 1 0 $X=213610 $Y=-76800
X43991 5 4 4770 4803 7968 7324 HA_5VX1 $T=214040 -8960 0 0 $X=213610 $Y=-9600
X43992 5 4 8053 4857 4851 4835 HA_5VX1 $T=216840 -116480 1 0 $X=216410 $Y=-121600
X43993 5 4 8054 7323 4821 4837 HA_5VX1 $T=217400 -62720 0 0 $X=216970 $Y=-63360
X43994 5 4 4723 7326 7332 4844 HA_5VX1 $T=217960 -26880 1 0 $X=217530 $Y=-32000
X43995 5 4 7333 4848 7324 1147 HA_5VX1 $T=226920 8960 1 180 $X=217530 $Y=8320
X43996 5 4 7327 7330 4844 7968 HA_5VX1 $T=219640 -17920 0 0 $X=219210 $Y=-18560
X43997 5 4 4753 4843 4837 7332 HA_5VX1 $T=221320 -44800 1 0 $X=220890 $Y=-49920
X43998 5 4 4776 4831 4835 4824 HA_5VX1 $T=224120 -116480 0 0 $X=223690 $Y=-117120
X43999 5 4 4889 1154 1161 4920 HA_5VX1 $T=231960 -71680 0 0 $X=231530 $Y=-72320
X44000 5 4 7380 1173 1157 4996 HA_5VX1 $T=257720 -62720 1 180 $X=248330 $Y=-63360
X44001 5 4 1200 1186 1191 5035 HA_5VX1 $T=266680 0 1 180 $X=257290 $Y=-640
X44002 5 4 4884 7393 7405 5086 HA_5VX1 $T=267240 -26880 1 0 $X=266810 $Y=-32000
X44003 5 4 1205 1154 1162 5060 HA_5VX1 $T=267240 -17920 0 0 $X=266810 $Y=-18560
X44004 5 4 5070 7403 5080 7398 HA_5VX1 $T=267800 -179200 0 0 $X=267370 $Y=-179840
X44005 5 4 5059 5067 5094 7400 HA_5VX1 $T=267800 -143360 1 0 $X=267370 $Y=-148480
X44006 5 4 5212 5075 7410 7403 HA_5VX1 $T=268920 -188160 1 0 $X=268490 $Y=-193280
X44007 5 4 5235 5104 5088 5094 HA_5VX1 $T=268920 -161280 0 0 $X=268490 $Y=-161920
X44008 5 4 7411 7408 7394 7402 HA_5VX1 $T=278440 -89600 1 180 $X=269050 $Y=-90240
X44009 5 4 4934 5125 7414 7405 HA_5VX1 $T=269480 -44800 0 0 $X=269050 $Y=-45440
X44010 5 4 5480 7396 5086 5106 HA_5VX1 $T=269480 -17920 1 0 $X=269050 $Y=-23040
X44011 5 4 5003 7398 7413 5104 HA_5VX1 $T=270040 -170240 0 0 $X=269610 $Y=-170880
X44012 5 4 5027 5116 7420 7408 HA_5VX1 $T=270040 -98560 1 0 $X=269610 $Y=-103680
X44013 5 4 5074 7401 5106 5107 HA_5VX1 $T=270600 -8960 1 0 $X=270170 $Y=-14080
X44014 5 4 5069 7399 5092 5075 HA_5VX1 $T=271160 -197120 1 0 $X=270730 $Y=-202240
X44015 5 4 7379 7400 8055 5099 HA_5VX1 $T=271160 -134400 0 0 $X=270730 $Y=-135040
X44016 5 4 5085 5095 5115 7414 HA_5VX1 $T=271720 -62720 1 0 $X=271290 $Y=-67840
X44017 5 4 5082 5099 7418 7404 HA_5VX1 $T=272280 -125440 0 0 $X=271850 $Y=-126080
X44018 5 4 5068 7404 7419 5116 HA_5VX1 $T=272280 -116480 0 0 $X=271850 $Y=-117120
X44019 5 4 5437 7402 7416 5095 HA_5VX1 $T=272280 -71680 1 0 $X=271850 $Y=-76800
X44020 5 4 5091 5101 5107 5117 HA_5VX1 $T=272280 0 0 0 $X=271850 $Y=-640
X44021 5 4 5113 7415 5117 1221 HA_5VX1 $T=276200 8960 1 0 $X=275770 $Y=3840
X44022 5 4 5254 7470 7974 5278 HA_5VX1 $T=304760 -170240 0 0 $X=304330 $Y=-170880
X44023 5 4 7500 1109 4754 5307 HA_5VX1 $T=322120 -188160 1 180 $X=312730 $Y=-188800
X44024 5 4 5290 1168 1159 7489 HA_5VX1 $T=313720 -53760 0 0 $X=313290 $Y=-54400
X44025 5 4 7488 1523 4769 7505 HA_5VX1 $T=318760 -107520 0 0 $X=318330 $Y=-108160
X44026 5 4 5346 1157 1161 5350 HA_5VX1 $T=328840 -26880 0 0 $X=328410 $Y=-27520
X44027 5 4 5380 1170 1173 5353 HA_5VX1 $T=338360 -89600 0 180 $X=328970 $Y=-94720
X44028 5 4 7563 7543 5455 1511 HA_5VX1 $T=343960 -80640 0 0 $X=343530 $Y=-81280
X44029 5 4 5430 7542 5462 1291 HA_5VX1 $T=346200 -8960 1 0 $X=345770 $Y=-14080
X44030 5 4 7550 7544 5464 5462 HA_5VX1 $T=347320 -26880 1 0 $X=346890 $Y=-32000
X44031 5 4 7570 7566 1511 5456 HA_5VX1 $T=356840 -62720 1 180 $X=347450 $Y=-63360
X44032 5 4 7552 5428 5456 5464 HA_5VX1 $T=347880 -53760 0 0 $X=347450 $Y=-54400
X44033 5 4 7574 7572 5430 5431 HA_5VX1 $T=356840 -8960 1 180 $X=347450 $Y=-9600
X44034 5 4 8056 7545 1288 5441 HA_5VX1 $T=357400 -268800 1 180 $X=348010 $Y=-269440
X44035 5 4 7976 7567 5434 7561 HA_5VX1 $T=357400 -250880 1 180 $X=348010 $Y=-251520
X44036 5 4 7580 7568 7552 5461 HA_5VX1 $T=357400 -35840 0 180 $X=348010 $Y=-40960
X44037 5 4 5475 5467 7550 5453 HA_5VX1 $T=357400 -17920 0 180 $X=348010 $Y=-23040
X44038 5 4 1305 7553 5441 7567 HA_5VX1 $T=357960 -259840 1 180 $X=348570 $Y=-260480
X44039 5 4 5478 7555 5443 7559 HA_5VX1 $T=357960 -179200 0 180 $X=348570 $Y=-184320
X44040 5 4 8057 7525 7559 5444 HA_5VX1 $T=357960 -161280 0 180 $X=348570 $Y=-166400
X44041 5 4 7551 5432 1303 1298 HA_5VX1 $T=349000 8960 1 0 $X=348570 $Y=3840
X44042 5 4 5458 7558 5444 5445 HA_5VX1 $T=358520 -152320 1 180 $X=349130 $Y=-152960
X44043 5 4 5459 5454 5445 7562 HA_5VX1 $T=358520 -134400 0 180 $X=349130 $Y=-139520
X44044 5 4 5446 5460 5466 5455 HA_5VX1 $T=350120 -98560 0 0 $X=349690 $Y=-99200
X44045 5 4 5552 7560 7562 5466 HA_5VX1 $T=360200 -116480 1 180 $X=350810 $Y=-117120
X44046 5 4 7597 7977 5446 5506 HA_5VX1 $T=360760 -89600 1 180 $X=351370 $Y=-90240
X44047 5 4 5484 5450 7561 7975 HA_5VX1 $T=361880 -232960 0 180 $X=352490 $Y=-238080
X44048 5 4 5505 5486 5458 5469 HA_5VX1 $T=361880 -143360 1 180 $X=352490 $Y=-144000
X44049 5 4 5498 5487 5459 5473 HA_5VX1 $T=361880 -134400 1 180 $X=352490 $Y=-135040
X44050 5 4 5500 7582 7563 5474 HA_5VX1 $T=361880 -80640 1 180 $X=352490 $Y=-81280
X44051 5 4 5512 7564 7975 5471 HA_5VX1 $T=362440 -224000 1 180 $X=353050 $Y=-224640
X44052 5 4 7593 7586 7570 7578 HA_5VX1 $T=364120 -62720 0 180 $X=354730 $Y=-67840
X44053 5 4 5514 5472 5477 5443 HA_5VX1 $T=365240 -197120 0 180 $X=355850 $Y=-202240
X44054 5 4 1310 7591 8056 7587 HA_5VX1 $T=366360 -268800 1 180 $X=356970 $Y=-269440
X44055 5 4 5522 5542 5484 5491 HA_5VX1 $T=366360 -250880 1 180 $X=356970 $Y=-251520
X44056 5 4 5489 7594 7976 5503 HA_5VX1 $T=366920 -259840 1 180 $X=357530 $Y=-260480
X44057 5 4 5526 7595 7576 5492 HA_5VX1 $T=366920 -215040 0 180 $X=357530 $Y=-220160
X44058 5 4 7576 5476 5471 5477 HA_5VX1 $T=358520 -206080 1 0 $X=358090 $Y=-211200
X44059 5 4 7606 7596 8057 5497 HA_5VX1 $T=367480 -161280 0 180 $X=358090 $Y=-166400
X44060 5 4 7592 5519 5552 5515 HA_5VX1 $T=363560 -107520 1 0 $X=363130 $Y=-112640
X44061 5 4 5517 5524 5557 1312 HA_5VX1 $T=363560 0 0 0 $X=363130 $Y=-640
X44062 5 4 5535 5525 5512 7607 HA_5VX1 $T=375320 -224000 0 180 $X=365930 $Y=-229120
X44063 5 4 7609 5551 5514 5530 HA_5VX1 $T=369720 -197120 0 0 $X=369290 $Y=-197760
X44064 5 4 7602 7612 5478 5537 HA_5VX1 $T=369720 -188160 0 0 $X=369290 $Y=-188800
X44065 5 4 7611 5562 5571 5579 HA_5VX1 $T=370840 -26880 1 0 $X=370410 $Y=-32000
X44066 5 4 5604 5579 7617 5524 HA_5VX1 $T=381480 -8960 0 180 $X=372090 $Y=-14080
X44067 5 4 7641 7632 5594 7628 HA_5VX1 $T=387080 -241920 1 180 $X=377690 $Y=-242560
X44068 5 4 5591 7630 7653 5601 HA_5VX1 $T=378120 -197120 1 0 $X=377690 $Y=-202240
X44069 5 4 5632 7639 5590 7630 HA_5VX1 $T=387640 -215040 1 180 $X=378250 $Y=-215680
X44070 5 4 7622 5602 7649 7633 HA_5VX1 $T=378680 -152320 0 0 $X=378250 $Y=-152960
X44071 5 4 1319 5606 1323 7637 HA_5VX1 $T=379240 -268800 1 0 $X=378810 $Y=-273920
X44072 5 4 1322 7637 5593 7632 HA_5VX1 $T=388200 -250880 0 180 $X=378810 $Y=-256000
X44073 5 4 5545 7628 8058 5590 HA_5VX1 $T=379240 -224000 1 0 $X=378810 $Y=-229120
X44074 5 4 5596 5601 8059 5607 HA_5VX1 $T=379240 -179200 1 0 $X=378810 $Y=-184320
X44075 5 4 5555 5607 8060 5602 HA_5VX1 $T=379240 -170240 0 0 $X=378810 $Y=-170880
X44076 5 4 5543 7633 7647 5608 HA_5VX1 $T=379240 -143360 0 0 $X=378810 $Y=-144000
X44077 5 4 5626 5608 7650 5625 HA_5VX1 $T=379240 -116480 0 0 $X=378810 $Y=-117120
X44078 5 4 8061 7631 5625 5609 HA_5VX1 $T=379240 -98560 0 0 $X=378810 $Y=-99200
X44079 5 4 5598 5609 8062 5610 HA_5VX1 $T=379240 -80640 1 0 $X=378810 $Y=-85760
X44080 5 4 8063 5610 8064 5611 HA_5VX1 $T=379240 -71680 0 0 $X=378810 $Y=-72320
X44081 5 4 7626 5611 7645 7640 HA_5VX1 $T=379240 -53760 0 0 $X=378810 $Y=-54400
X44082 5 4 7642 7640 7625 5562 HA_5VX1 $T=388200 -44800 0 180 $X=378810 $Y=-49920
X44083 5 4 5769 1119 1117 5741 HA_5VX1 $T=433000 -197120 1 180 $X=423610 $Y=-197760
X44084 5 4 1354 1168 1165 5718 HA_5VX1 $T=435240 0 1 180 $X=425850 $Y=-640
X44085 5 4 5771 4754 1515 5789 HA_5VX1 $T=428520 -116480 0 0 $X=428090 $Y=-117120
X44086 5 4 1348 1165 1159 5782 HA_5VX1 $T=429640 8960 1 0 $X=429210 $Y=3840
X44087 5 4 5795 1117 1133 5761 HA_5VX1 $T=440280 -179200 0 180 $X=430890 $Y=-184320
X44088 5 4 5739 1504 1523 7715 HA_5VX1 $T=432440 -89600 0 0 $X=432010 $Y=-90240
X44089 5 4 5744 1515 1504 7719 HA_5VX1 $T=433560 -98560 0 0 $X=433130 $Y=-99200
X44090 5 4 5805 4769 1168 7727 HA_5VX1 $T=436920 -26880 1 0 $X=436490 $Y=-32000
X44091 5 4 7712 1523 1506 5814 HA_5VX1 $T=437480 -44800 1 0 $X=437050 $Y=-49920
X44092 5 4 5822 5802 7717 5807 HA_5VX1 $T=448120 -116480 0 180 $X=438730 $Y=-121600
X44093 5 4 5799 5810 7739 1365 HA_5VX1 $T=439160 8960 1 0 $X=438730 $Y=3840
X44094 5 4 5834 1180 1119 5811 HA_5VX1 $T=449240 -259840 0 180 $X=439850 $Y=-264960
X44095 5 4 1363 1170 1173 5830 HA_5VX1 $T=441400 0 1 0 $X=440970 $Y=-5120
X44096 5 4 5806 4762 4754 7738 HA_5VX1 $T=441960 -125440 1 0 $X=441530 $Y=-130560
X44097 5 4 5813 1123 1109 7740 HA_5VX1 $T=443080 -152320 1 0 $X=442650 $Y=-157440
X44098 5 4 5819 7732 7751 5840 HA_5VX1 $T=443640 -53760 0 0 $X=443210 $Y=-54400
X44099 5 4 5770 1133 1123 7744 HA_5VX1 $T=444200 -170240 1 0 $X=443770 $Y=-175360
X44100 5 4 5829 5840 5863 5844 HA_5VX1 $T=445880 -26880 1 0 $X=445450 $Y=-32000
X44101 5 4 5826 5844 6045 5810 HA_5VX1 $T=445880 -8960 1 0 $X=445450 $Y=-14080
X44102 5 4 5835 5849 7756 7751 HA_5VX1 $T=447560 -62720 1 0 $X=447130 $Y=-67840
X44103 5 4 7895 5848 7760 5853 HA_5VX1 $T=448120 -98560 1 0 $X=447690 $Y=-103680
X44104 5 4 7734 1210 1192 1362 HA_5VX1 $T=448680 -250880 0 0 $X=448250 $Y=-251520
X44105 5 4 6185 5853 5891 5849 HA_5VX1 $T=449240 -89600 0 0 $X=448810 $Y=-90240
X44106 5 4 5889 1515 1523 7755 HA_5VX1 $T=459880 -89600 0 180 $X=450490 $Y=-94720
X44107 5 4 5867 4754 1504 7754 HA_5VX1 $T=460440 -116480 1 180 $X=451050 $Y=-117120
X44108 5 4 5857 5866 7765 7760 HA_5VX1 $T=452600 -116480 1 0 $X=452170 $Y=-121600
X44109 5 4 1520 1165 1170 5904 HA_5VX1 $T=454280 -35840 0 0 $X=453850 $Y=-36480
X44110 5 4 5860 1195 1210 1389 HA_5VX1 $T=458200 -250880 0 0 $X=457770 $Y=-251520
X44111 5 4 5947 1504 1506 5963 HA_5VX1 $T=462680 -107520 0 0 $X=462250 $Y=-108160
X44112 5 4 5942 5934 6002 5945 HA_5VX1 $T=466040 -161280 1 0 $X=465610 $Y=-166400
X44113 5 4 5924 1523 4769 5943 HA_5VX1 $T=466040 -80640 0 0 $X=465610 $Y=-81280
X44114 5 4 6013 1398 1195 1403 HA_5VX1 $T=481720 -268800 0 180 $X=472330 $Y=-273920
X44115 5 4 5985 1180 1117 7815 HA_5VX1 $T=478920 -215040 0 0 $X=478490 $Y=-215680
X44116 5 4 5893 4762 1515 6008 HA_5VX1 $T=479480 -161280 0 0 $X=479050 $Y=-161920
X44117 5 4 6010 1192 1119 6036 HA_5VX1 $T=489560 -224000 1 0 $X=489130 $Y=-229120
X44118 5 4 7987 7825 6067 1416 HA_5VX1 $T=506920 0 1 180 $X=497530 $Y=-640
X44119 5 4 6116 6057 6072 6067 HA_5VX1 $T=507480 -17920 1 180 $X=498090 $Y=-18560
X44120 5 4 6111 7830 6080 6072 HA_5VX1 $T=508040 -26880 1 180 $X=498650 $Y=-27520
X44121 5 4 8065 7844 8066 1418 HA_5VX1 $T=508600 8960 1 180 $X=499210 $Y=8320
X44122 5 4 6084 6092 7857 5866 HA_5VX1 $T=500760 -143360 0 0 $X=500330 $Y=-144000
X44123 5 4 7864 7849 7836 7844 HA_5VX1 $T=510280 -17920 0 180 $X=500890 $Y=-23040
X44124 5 4 6122 7835 6089 6080 HA_5VX1 $T=510840 -44800 0 180 $X=501450 $Y=-49920
X44125 5 4 6121 7853 6090 7849 HA_5VX1 $T=510840 -35840 0 180 $X=501450 $Y=-40960
X44126 5 4 6095 6101 7866 6092 HA_5VX1 $T=503560 -143360 1 0 $X=503130 $Y=-148480
X44127 5 4 7845 6103 6113 6104 HA_5VX1 $T=504680 -179200 1 0 $X=504250 $Y=-184320
X44128 5 4 8067 7863 7843 7853 HA_5VX1 $T=513640 -53760 0 180 $X=504250 $Y=-58880
X44129 5 4 6108 6104 6107 6101 HA_5VX1 $T=505240 -161280 1 0 $X=504810 $Y=-166400
X44130 5 4 6134 7873 8068 7859 HA_5VX1 $T=515880 -188160 1 180 $X=506490 $Y=-188800
X44131 5 4 6139 6126 6110 6089 HA_5VX1 $T=515880 -62720 1 180 $X=506490 $Y=-63360
X44132 5 4 6144 7847 6125 6120 HA_5VX1 $T=516440 -89600 1 180 $X=507050 $Y=-90240
X44133 5 4 6136 6120 7848 7863 HA_5VX1 $T=516440 -71680 1 180 $X=507050 $Y=-72320
X44134 5 4 6149 7852 6109 6110 HA_5VX1 $T=517000 -80640 1 180 $X=507610 $Y=-81280
X44135 5 4 7886 5957 7776 6164 HA_5VX1 $T=517560 -206080 1 180 $X=508170 $Y=-206720
X44136 5 4 6143 7874 6119 7868 HA_5VX1 $T=518120 -134400 0 180 $X=508730 $Y=-139520
X44137 5 4 7900 7856 7859 7865 HA_5VX1 $T=518680 -170240 0 180 $X=509290 $Y=-175360
X44138 5 4 6155 6135 8069 6125 HA_5VX1 $T=518680 -107520 1 180 $X=509290 $Y=-108160
X44139 5 4 6165 7860 7865 6119 HA_5VX1 $T=519240 -152320 0 180 $X=509850 $Y=-157440
X44140 5 4 6148 7877 7868 7872 HA_5VX1 $T=519240 -125440 0 180 $X=509850 $Y=-130560
X44141 5 4 6157 6132 7872 7875 HA_5VX1 $T=520920 -107520 0 180 $X=511530 $Y=-112640
X44142 5 4 6166 6152 7861 6145 HA_5VX1 $T=522600 -152320 1 180 $X=513210 $Y=-152960
X44143 5 4 6103 6141 6134 7891 HA_5VX1 $T=514760 -179200 1 0 $X=514330 $Y=-184320
X44144 5 4 6177 7888 5949 6152 HA_5VX1 $T=523720 -161280 0 180 $X=514330 $Y=-166400
X44145 5 4 6173 6164 6138 7888 HA_5VX1 $T=524840 -188160 1 180 $X=515450 $Y=-188800
X44146 5 4 7901 6129 7875 6109 HA_5VX1 $T=524840 -98560 1 180 $X=515450 $Y=-99200
X44147 5 4 7902 6145 6098 6135 HA_5VX1 $T=525400 -125440 1 180 $X=516010 $Y=-126080
X44148 5 4 51 1809 55 1827 EO3_5VX1 $T=-449560 -17920 1 0 $X=-449990 $Y=-23040
X44149 5 4 1824 48 54 6319 EO3_5VX1 $T=-442840 -80640 0 0 $X=-443270 $Y=-81280
X44150 5 4 1826 59 1850 6324 EO3_5VX1 $T=-442280 -98560 1 0 $X=-442710 $Y=-103680
X44151 5 4 1841 1890 59 6306 EO3_5VX1 $T=-426040 -125440 0 180 $X=-438790 $Y=-130560
X44152 5 4 1881 1886 54 1966 EO3_5VX1 $T=-432200 -35840 1 0 $X=-432630 $Y=-40960
X44153 5 4 1930 59 47 6329 EO3_5VX1 $T=-414840 -98560 0 180 $X=-427590 $Y=-103680
X44154 5 4 1917 1958 49 1844 EO3_5VX1 $T=-413720 -26880 0 180 $X=-426470 $Y=-32000
X44155 5 4 1941 1944 1841 6355 EO3_5VX1 $T=-420440 -116480 0 0 $X=-420870 $Y=-117120
X44156 5 4 1968 47 49 1875 EO3_5VX1 $T=-406440 -71680 1 180 $X=-419190 $Y=-72320
X44157 5 4 45 1972 90 1922 EO3_5VX1 $T=-405880 -8960 1 180 $X=-418630 $Y=-9600
X44158 5 4 2026 2018 80 1996 EO3_5VX1 $T=-394680 -170240 1 180 $X=-407430 $Y=-170880
X44159 5 4 2035 79 1447 6388 EO3_5VX1 $T=-386280 -224000 1 180 $X=-399030 $Y=-224640
X44160 5 4 2071 84 80 2063 EO3_5VX1 $T=-379000 -241920 1 180 $X=-391750 $Y=-242560
X44161 5 4 2319 54 2332 2288 EO3_5VX1 $T=-312360 -89600 1 180 $X=-325110 $Y=-90240
X44162 5 4 2331 2370 2348 6489 EO3_5VX1 $T=-309000 -98560 0 180 $X=-321750 $Y=-103680
X44163 5 4 2343 137 2412 6502 EO3_5VX1 $T=-319640 -224000 1 0 $X=-320070 $Y=-229120
X44164 5 4 6504 2392 2399 6497 EO3_5VX1 $T=-305080 -116480 0 180 $X=-317830 $Y=-121600
X44165 5 4 2410 45 55 7946 EO3_5VX1 $T=-303400 -17920 0 180 $X=-316150 $Y=-23040
X44166 5 4 2436 48 47 2348 EO3_5VX1 $T=-301160 -98560 1 180 $X=-313910 $Y=-99200
X44167 5 4 214 210 137 6507 EO3_5VX1 $T=-294440 -259840 1 180 $X=-307190 $Y=-260480
X44168 5 4 2440 59 48 2399 EO3_5VX1 $T=-293320 -116480 1 180 $X=-306070 $Y=-117120
X44169 5 4 2476 2480 79 6544 EO3_5VX1 $T=-292200 -170240 1 0 $X=-292630 $Y=-175360
X44170 5 4 1452 2475 2447 2521 EO3_5VX1 $T=-292200 -44800 1 0 $X=-292630 $Y=-49920
X44171 5 4 2463 1447 1452 2485 EO3_5VX1 $T=-278760 -152320 0 180 $X=-291510 $Y=-157440
X44172 5 4 224 84 79 2553 EO3_5VX1 $T=-287720 -259840 1 0 $X=-288150 $Y=-264960
X44173 5 4 2512 2532 58 2559 EO3_5VX1 $T=-285480 -17920 0 0 $X=-285910 $Y=-18560
X44174 5 4 2495 79 80 6559 EO3_5VX1 $T=-283800 -250880 0 0 $X=-284230 $Y=-251520
X44175 5 4 2557 80 1447 2543 EO3_5VX1 $T=-270360 -241920 1 180 $X=-283110 $Y=-242560
X44176 5 4 2402 80 1447 2536 EO3_5VX1 $T=-282120 -179200 1 0 $X=-282550 $Y=-184320
X44177 5 4 1452 2523 2516 2577 EO3_5VX1 $T=-282120 -134400 1 0 $X=-282550 $Y=-139520
X44178 5 4 2531 2530 1841 2583 EO3_5VX1 $T=-281560 -35840 1 0 $X=-281990 $Y=-40960
X44179 5 4 1462 2509 2565 2578 EO3_5VX1 $T=-278760 -89600 1 0 $X=-279190 $Y=-94720
X44180 5 4 2615 2598 1447 6562 EO3_5VX1 $T=-259720 -116480 1 180 $X=-272470 $Y=-117120
X44181 5 4 247 49 45 6595 EO3_5VX1 $T=-263640 -17920 0 0 $X=-264070 $Y=-18560
X44182 5 4 59 2642 2646 257 EO3_5VX1 $T=-248520 -8960 1 180 $X=-261270 $Y=-9600
X44183 5 4 54 2629 51 6607 EO3_5VX1 $T=-258040 -26880 1 0 $X=-258470 $Y=-32000
X44184 5 4 2506 1900 1841 6601 EO3_5VX1 $T=-238440 -152320 1 180 $X=-251190 $Y=-152960
X44185 5 4 1465 1452 1462 2726 EO3_5VX1 $T=-250200 -188160 1 0 $X=-250630 $Y=-193280
X44186 5 4 2814 141 100 2841 EO3_5VX1 $T=-222760 -241920 1 0 $X=-223190 $Y=-247040
X44187 5 4 84 2838 2867 2888 EO3_5VX1 $T=-218840 -224000 0 0 $X=-219270 $Y=-224640
X44188 5 4 2837 2890 80 2911 EO3_5VX1 $T=-217720 -215040 0 0 $X=-218150 $Y=-215680
X44189 5 4 92 292 79 357 EO3_5VX1 $T=-215480 -268800 1 0 $X=-215910 $Y=-273920
X44190 5 4 2826 1447 2855 2914 EO3_5VX1 $T=-213240 -197120 1 0 $X=-213670 $Y=-202240
X44191 5 4 1470 6672 79 2946 EO3_5VX1 $T=-210440 -241920 1 0 $X=-210870 $Y=-247040
X44192 5 4 2884 1462 2914 2937 EO3_5VX1 $T=-209320 -197120 0 0 $X=-209750 $Y=-197760
X44193 5 4 2774 6674 1452 2931 EO3_5VX1 $T=-207640 -188160 0 0 $X=-208070 $Y=-188800
X44194 5 4 2899 1452 1900 2960 EO3_5VX1 $T=-207080 -206080 1 0 $X=-207510 $Y=-211200
X44195 5 4 349 1447 2923 2951 EO3_5VX1 $T=-206520 -250880 1 0 $X=-206950 $Y=-256000
X44196 5 4 2931 2919 2938 2971 EO3_5VX1 $T=-205960 -179200 0 0 $X=-206390 $Y=-179840
X44197 5 4 2900 2828 1462 2967 EO3_5VX1 $T=-205960 -152320 1 0 $X=-206390 $Y=-157440
X44198 5 4 2912 58 48 2932 EO3_5VX1 $T=-204840 -134400 0 0 $X=-205270 $Y=-135040
X44199 5 4 2881 1900 58 2938 EO3_5VX1 $T=-203720 -161280 1 0 $X=-204150 $Y=-166400
X44200 5 4 2929 49 45 2998 EO3_5VX1 $T=-202040 -44800 1 0 $X=-202470 $Y=-49920
X44201 5 4 2933 59 47 2993 EO3_5VX1 $T=-200360 -116480 1 0 $X=-200790 $Y=-121600
X44202 5 4 2932 2950 2920 3009 EO3_5VX1 $T=-199800 -134400 1 0 $X=-200230 $Y=-139520
X44203 5 4 2916 47 49 2994 EO3_5VX1 $T=-199800 -80640 0 0 $X=-200230 $Y=-81280
X44204 5 4 2936 2946 2953 2986 EO3_5VX1 $T=-199240 -232960 0 0 $X=-199670 $Y=-233600
X44205 5 4 2940 54 51 3003 EO3_5VX1 $T=-199240 -62720 1 0 $X=-199670 $Y=-67840
X44206 5 4 2944 2939 48 2989 EO3_5VX1 $T=-198680 -98560 1 0 $X=-199110 $Y=-103680
X44207 5 4 1841 6683 2937 3005 EO3_5VX1 $T=-197000 -188160 1 0 $X=-197430 $Y=-193280
X44208 5 4 369 2959 2942 3015 EO3_5VX1 $T=-194200 8960 1 0 $X=-194630 $Y=3840
X44209 5 4 2960 2911 2954 2999 EO3_5VX1 $T=-193640 -215040 0 0 $X=-194070 $Y=-215680
X44210 5 4 2972 2975 2994 3019 EO3_5VX1 $T=-191960 -89600 0 0 $X=-192390 $Y=-90240
X44211 5 4 2973 2976 2998 6693 EO3_5VX1 $T=-191960 -53760 0 0 $X=-192390 $Y=-54400
X44212 5 4 2989 54 3023 3011 EO3_5VX1 $T=-190280 -107520 0 0 $X=-190710 $Y=-108160
X44213 5 4 2982 2990 3003 3021 EO3_5VX1 $T=-190280 -71680 0 0 $X=-190710 $Y=-72320
X44214 5 4 2993 3002 2962 3035 EO3_5VX1 $T=-188040 -125440 0 0 $X=-188470 $Y=-126080
X44215 5 4 3117 3132 3053 2776 EO3_5VX1 $T=-166760 -44800 0 180 $X=-179510 $Y=-49920
X44216 5 4 3151 3130 3102 427 EO3_5VX1 $T=-156120 8960 1 180 $X=-168870 $Y=8320
X44217 5 4 3156 3147 6734 2788 EO3_5VX1 $T=-152760 -35840 0 180 $X=-165510 $Y=-40960
X44218 5 4 3106 3136 3142 2787 EO3_5VX1 $T=-152200 -80640 0 180 $X=-164950 $Y=-85760
X44219 5 4 3137 3143 3133 331 EO3_5VX1 $T=-151080 -17920 0 180 $X=-163830 $Y=-23040
X44220 5 4 3150 3155 3123 2873 EO3_5VX1 $T=-149400 -71680 1 180 $X=-162150 $Y=-72320
X44221 5 4 3128 3129 3140 439 EO3_5VX1 $T=-144920 0 0 180 $X=-157670 $Y=-5120
X44222 5 4 3181 3170 3171 2824 EO3_5VX1 $T=-141560 -179200 1 180 $X=-154310 $Y=-179840
X44223 5 4 3253 3214 3185 8070 EO3_5VX1 $T=-135400 -44800 1 180 $X=-148150 $Y=-45440
X44224 5 4 6784 3259 3203 8071 EO3_5VX1 $T=-130920 -71680 0 180 $X=-143670 $Y=-76800
X44225 5 4 6786 3234 3220 8072 EO3_5VX1 $T=-129240 -53760 0 180 $X=-141990 $Y=-58880
X44226 5 4 3224 3215 3209 3189 EO3_5VX1 $T=-111880 0 1 180 $X=-124630 $Y=-640
X44227 5 4 2906 3351 3346 3376 EO3_5VX1 $T=-97880 -44800 0 0 $X=-98310 $Y=-45440
X44228 5 4 3372 3377 1480 3334 EO3_5VX1 $T=-85560 -17920 1 180 $X=-98310 $Y=-18560
X44229 5 4 544 3334 3355 3385 EO3_5VX1 $T=-97880 -8960 1 0 $X=-98310 $Y=-14080
X44230 5 4 569 3380 3383 3337 EO3_5VX1 $T=-85000 -107520 0 180 $X=-97750 $Y=-112640
X44231 5 4 3350 3338 563 3397 EO3_5VX1 $T=-93960 -53760 0 0 $X=-94390 $Y=-54400
X44232 5 4 3390 3388 3428 6863 EO3_5VX1 $T=-88920 -215040 0 0 $X=-89350 $Y=-215680
X44233 5 4 3416 3432 3470 6885 EO3_5VX1 $T=-81640 -53760 0 0 $X=-82070 $Y=-54400
X44234 5 4 3465 3477 3484 6894 EO3_5VX1 $T=-79400 -89600 0 0 $X=-79830 $Y=-90240
X44235 5 4 3468 3508 3501 3513 EO3_5VX1 $T=-74360 -134400 1 0 $X=-74790 $Y=-139520
X44236 5 4 3463 3509 6895 6901 EO3_5VX1 $T=-73800 -116480 1 0 $X=-74230 $Y=-121600
X44237 5 4 3507 3494 3490 6879 EO3_5VX1 $T=-60360 -152320 0 180 $X=-73110 $Y=-157440
X44238 5 4 3504 3497 607 3495 EO3_5VX1 $T=-55320 -179200 0 180 $X=-68070 $Y=-184320
X44239 5 4 607 1482 620 3490 EO3_5VX1 $T=-49160 -134400 1 180 $X=-61910 $Y=-135040
X44240 5 4 654 647 637 3564 EO3_5VX1 $T=-41320 -268800 0 180 $X=-54070 $Y=-273920
X44241 5 4 595 3646 3661 6948 EO3_5VX1 $T=-22280 -206080 0 180 $X=-35030 $Y=-211200
X44242 5 4 3624 584 3710 3704 EO3_5VX1 $T=-34600 -134400 0 0 $X=-35030 $Y=-135040
X44243 5 4 684 3673 632 3617 EO3_5VX1 $T=-20600 -224000 1 180 $X=-33350 $Y=-224640
X44244 5 4 3714 3708 592 3689 EO3_5VX1 $T=-13880 -206080 1 180 $X=-26630 $Y=-206720
X44245 5 4 624 3711 6980 3758 EO3_5VX1 $T=-22280 -152320 0 0 $X=-22710 $Y=-152960
X44246 5 4 1489 1487 3803 3765 EO3_5VX1 $T=-15560 -134400 0 0 $X=-15990 $Y=-135040
X44247 5 4 607 3742 3839 7019 EO3_5VX1 $T=-8840 -35840 1 0 $X=-9270 $Y=-40960
X44248 5 4 3830 3739 3796 3778 EO3_5VX1 $T=5160 -161280 1 180 $X=-7590 $Y=-161920
X44249 5 4 3678 3827 3795 3578 EO3_5VX1 $T=6280 -179200 0 180 $X=-6470 $Y=-184320
X44250 5 4 3504 3783 7021 7025 EO3_5VX1 $T=-3800 -98560 1 0 $X=-4230 $Y=-103680
X44251 5 4 625 1490 3823 7006 EO3_5VX1 $T=10760 -71680 0 180 $X=-1990 $Y=-76800
X44252 5 4 732 730 3835 3819 EO3_5VX1 $T=-440 -268800 0 0 $X=-870 $Y=-269440
X44253 5 4 3836 3856 3846 3502 EO3_5VX1 $T=14120 -143360 1 180 $X=1370 $Y=-144000
X44254 5 4 3841 3871 3849 3531 EO3_5VX1 $T=16360 -125440 1 180 $X=3610 $Y=-126080
X44255 5 4 623 3867 3842 3732 EO3_5VX1 $T=19160 -8960 0 180 $X=6410 $Y=-14080
X44256 5 4 1493 3906 611 751 EO3_5VX1 $T=22520 -8960 1 180 $X=9770 $Y=-9600
X44257 5 4 3857 3963 3892 3341 EO3_5VX1 $T=24760 -80640 0 180 $X=12010 $Y=-85760
X44258 5 4 7092 632 595 3947 EO3_5VX1 $T=49400 -241920 1 180 $X=36650 $Y=-242560
X44259 5 4 4006 4021 592 7107 EO3_5VX1 $T=37080 -197120 1 0 $X=36650 $Y=-202240
X44260 5 4 4078 677 813 7084 EO3_5VX1 $T=56680 -232960 0 180 $X=43930 $Y=-238080
X44261 5 4 4214 4194 3974 3453 EO3_5VX1 $T=83000 -71680 0 180 $X=70250 $Y=-76800
X44262 5 4 4203 4190 4184 6865 EO3_5VX1 $T=85240 -62720 1 180 $X=72490 $Y=-63360
X44263 5 4 903 633 645 4247 EO3_5VX1 $T=99240 8960 0 180 $X=86490 $Y=3840
X44264 5 4 4260 611 620 7188 EO3_5VX1 $T=95320 -107520 0 0 $X=94890 $Y=-108160
X44265 5 4 922 608 629 4292 EO3_5VX1 $T=109880 -35840 1 180 $X=97130 $Y=-36480
X44266 5 4 4368 614 604 4312 EO3_5VX1 $T=113800 -71680 0 180 $X=101050 $Y=-76800
X44267 5 4 4306 3504 625 4375 EO3_5VX1 $T=102040 -161280 1 0 $X=101610 $Y=-166400
X44268 5 4 4314 1496 3504 7197 EO3_5VX1 $T=102600 -197120 1 0 $X=102170 $Y=-202240
X44269 5 4 4383 625 607 4400 EO3_5VX1 $T=114920 -143360 1 0 $X=114490 $Y=-148480
X44270 5 4 4315 607 611 7194 EO3_5VX1 $T=128920 -134400 0 180 $X=116170 $Y=-139520
X44271 5 4 4310 584 1489 7204 EO3_5VX1 $T=135640 -241920 1 180 $X=122890 $Y=-242560
X44272 5 4 964 624 584 4468 EO3_5VX1 $T=123880 -250880 1 0 $X=123450 $Y=-256000
X44273 5 4 968 586 624 7206 EO3_5VX1 $T=137320 -268800 1 180 $X=124570 $Y=-269440
X44274 5 4 4259 1489 1496 7207 EO3_5VX1 $T=138440 -224000 1 180 $X=125690 $Y=-224640
X44275 5 4 1143 1109 4762 1152 EO3_5VX1 $T=220760 -268800 1 0 $X=220330 $Y=-273920
X44276 5 4 1148 4762 4754 7343 EO3_5VX1 $T=221320 -259840 0 0 $X=220890 $Y=-260480
X44277 5 4 4905 1515 1504 7329 EO3_5VX1 $T=233640 -241920 1 180 $X=220890 $Y=-242560
X44278 5 4 4908 1506 4769 4829 EO3_5VX1 $T=235880 -197120 0 180 $X=223130 $Y=-202240
X44279 5 4 1163 4754 1515 7334 EO3_5VX1 $T=240360 -250880 1 180 $X=227610 $Y=-251520
X44280 5 4 4954 1170 1157 7345 EO3_5VX1 $T=246520 -125440 0 180 $X=233770 $Y=-130560
X44281 5 4 4929 1165 1159 7341 EO3_5VX1 $T=247080 -152320 1 180 $X=234330 $Y=-152960
X44282 5 4 4999 1173 1157 7344 EO3_5VX1 $T=247080 -107520 1 180 $X=234330 $Y=-108160
X44283 5 4 4909 1159 1170 4951 EO3_5VX1 $T=235320 -134400 1 0 $X=234890 $Y=-139520
X44284 5 4 4944 1168 1165 4922 EO3_5VX1 $T=249880 -170240 1 180 $X=237130 $Y=-170880
X44285 5 4 4960 4754 4987 7387 EO3_5VX1 $T=252120 -170240 1 0 $X=251690 $Y=-175360
X44286 5 4 5291 1173 1154 5336 EO3_5VX1 $T=311480 0 0 0 $X=311050 $Y=-640
X44287 5 4 5294 1157 1161 7508 EO3_5VX1 $T=312040 -53760 1 0 $X=311610 $Y=-58880
X44288 5 4 5289 1170 1173 7498 EO3_5VX1 $T=312600 -71680 1 0 $X=312170 $Y=-76800
X44289 5 4 5300 1173 1154 5340 EO3_5VX1 $T=315400 -62720 1 0 $X=314970 $Y=-67840
X44290 5 4 1260 1109 4754 5373 EO3_5VX1 $T=318200 -250880 1 0 $X=317770 $Y=-256000
X44291 5 4 1123 1273 4762 7504 EO3_5VX1 $T=335000 -268800 1 180 $X=322250 $Y=-269440
X44292 5 4 7501 1168 1159 5379 EO3_5VX1 $T=324360 -152320 0 0 $X=323930 $Y=-152960
X44293 5 4 1277 1161 1162 5357 EO3_5VX1 $T=337800 -17920 1 180 $X=325050 $Y=-18560
X44294 5 4 1523 5292 4769 5354 EO3_5VX1 $T=343400 -197120 0 180 $X=330650 $Y=-202240
X44295 5 4 7684 1173 1161 1512 EO3_5VX1 $T=421800 -44800 1 180 $X=409050 $Y=-45440
X44296 5 4 5748 1165 1159 5694 EO3_5VX1 $T=434680 -17920 1 180 $X=421930 $Y=-18560
X44297 5 4 5765 5770 4762 7694 EO3_5VX1 $T=436360 -134400 1 180 $X=423610 $Y=-135040
X44298 5 4 1506 5768 5744 5737 EO3_5VX1 $T=436920 -53760 1 180 $X=424170 $Y=-54400
X44299 5 4 5779 5771 1523 7980 EO3_5VX1 $T=438040 -71680 0 180 $X=425290 $Y=-76800
X44300 5 4 5743 7712 1168 5745 EO3_5VX1 $T=439720 -35840 1 180 $X=426970 $Y=-36480
X44301 5 4 1518 1180 1119 7699 EO3_5VX1 $T=440280 -259840 0 180 $X=427530 $Y=-264960
X44302 5 4 5756 1117 1133 5792 EO3_5VX1 $T=430760 -224000 1 0 $X=430330 $Y=-229120
X44303 5 4 5762 5795 1109 7724 EO3_5VX1 $T=430760 -152320 1 0 $X=430330 $Y=-157440
X44304 5 4 1170 1356 1354 1350 EO3_5VX1 $T=443080 8960 1 180 $X=430330 $Y=8320
X44305 5 4 1159 5794 5805 5696 EO3_5VX1 $T=449800 -8960 1 180 $X=437050 $Y=-9600
X44306 5 4 1515 5812 5822 5757 EO3_5VX1 $T=451480 -116480 1 180 $X=438730 $Y=-117120
X44307 5 4 5881 5893 1523 5850 EO3_5VX1 $T=463800 -143360 1 180 $X=451050 $Y=-144000
X44308 5 4 5874 4754 1504 5928 EO3_5VX1 $T=455960 -152320 0 0 $X=455530 $Y=-152960
X44309 5 4 5931 1109 4754 5993 EO3_5VX1 $T=466600 -179200 1 0 $X=466170 $Y=-184320
X44310 5 4 1159 5921 1157 7785 EO3_5VX1 $T=480040 -35840 1 180 $X=467290 $Y=-36480
X44311 5 4 1210 1397 1180 7820 EO3_5VX1 $T=469400 -250880 1 0 $X=468970 $Y=-256000
X44312 5 4 5929 5924 1165 5966 EO3_5VX1 $T=470520 -26880 0 0 $X=470090 $Y=-27520
X44313 5 4 5946 5947 1168 7794 EO3_5VX1 $T=483960 -62720 0 180 $X=471210 $Y=-67840
X44314 5 4 5968 1180 1117 6023 EO3_5VX1 $T=475000 -241920 1 0 $X=474570 $Y=-247040
X44315 5 4 1410 1192 1119 7841 EO3_5VX1 $T=489560 -259840 1 0 $X=489130 $Y=-264960
X44316 5 4 1117 5958 1123 6097 EO3_5VX1 $T=489560 -215040 0 0 $X=489130 $Y=-215680
X44317 5 4 1411 1192 1119 7842 EO3_5VX1 $T=490120 -241920 1 0 $X=489690 $Y=-247040
X44318 5 4 39 6257 31 1644 35 FA_5VX1 $T=-461880 8960 1 180 $X=-479110 $Y=8320
X44319 5 4 1449 6259 1565 6244 6253 FA_5VX1 $T=-461320 -26880 1 180 $X=-478550 $Y=-27520
X44320 5 4 1722 6253 1537 1649 6257 FA_5VX1 $T=-460760 -8960 1 180 $X=-477990 $Y=-9600
X44321 5 4 1731 1677 6246 1653 6259 FA_5VX1 $T=-459640 -44800 0 180 $X=-476870 $Y=-49920
X44322 5 4 1747 6272 1656 6249 1677 FA_5VX1 $T=-457960 -62720 1 180 $X=-475190 $Y=-63360
X44323 5 4 1739 6271 1444 1672 6263 FA_5VX1 $T=-457400 -98560 1 180 $X=-474630 $Y=-99200
X44324 5 4 1752 6263 6248 6251 6272 FA_5VX1 $T=-456280 -71680 0 180 $X=-473510 $Y=-76800
X44325 5 4 1757 1694 7934 6256 6271 FA_5VX1 $T=-454600 -116480 1 180 $X=-471830 $Y=-117120
X44326 5 4 1767 6279 6260 6258 1694 FA_5VX1 $T=-453480 -125440 0 180 $X=-470710 $Y=-130560
X44327 5 4 1803 6283 6268 1686 6279 FA_5VX1 $T=-450680 -143360 0 180 $X=-467910 $Y=-148480
X44328 5 4 1807 6289 6280 1724 6283 FA_5VX1 $T=-447320 -170240 1 180 $X=-464550 $Y=-170880
X44329 5 4 1716 1783 7938 6293 6289 FA_5VX1 $T=-462440 -179200 0 0 $X=-462870 $Y=-179840
X44330 5 4 1704 45 6300 8073 1709 FA_5VX1 $T=-459080 -26880 1 0 $X=-459510 $Y=-32000
X44331 5 4 6278 49 1818 1821 1718 FA_5VX1 $T=-457960 -44800 1 0 $X=-458390 $Y=-49920
X44332 5 4 1744 47 1823 8074 1800 FA_5VX1 $T=-456840 -98560 0 0 $X=-457270 $Y=-99200
X44333 5 4 1756 1820 6302 6303 1783 FA_5VX1 $T=-455160 -197120 0 0 $X=-455590 $Y=-197760
X44334 5 4 1727 48 1832 1840 1777 FA_5VX1 $T=-454600 -116480 0 0 $X=-455030 $Y=-117120
X44335 5 4 1759 1827 1835 1837 1760 FA_5VX1 $T=-453480 -17920 0 0 $X=-453910 $Y=-18560
X44336 5 4 1678 55 6304 1838 57 FA_5VX1 $T=-453480 0 1 0 $X=-453910 $Y=-5120
X44337 5 4 1685 51 54 6307 1698 FA_5VX1 $T=-452920 -35840 0 0 $X=-453350 $Y=-36480
X44338 5 4 1687 1819 1790 1845 1710 FA_5VX1 $T=-452920 0 0 0 $X=-453350 $Y=-640
X44339 5 4 1780 52 6309 1830 60 FA_5VX1 $T=-451800 8960 1 0 $X=-452230 $Y=3840
X44340 5 4 1749 1780 1860 1863 61 FA_5VX1 $T=-451240 8960 0 0 $X=-451670 $Y=8320
X44341 5 4 1720 54 1843 6314 1729 FA_5VX1 $T=-450680 -71680 0 0 $X=-451110 $Y=-72320
X44342 5 4 1790 1844 7940 51 1830 FA_5VX1 $T=-450120 -8960 1 0 $X=-450550 $Y=-14080
X44343 5 4 1762 59 1841 6316 1733 FA_5VX1 $T=-449560 -125440 0 0 $X=-449990 $Y=-126080
X44344 5 4 1758 1856 1868 1872 1748 FA_5VX1 $T=-448440 -53760 0 0 $X=-448870 $Y=-54400
X44345 5 4 1793 6313 1874 1911 1805 FA_5VX1 $T=-447320 -107520 1 0 $X=-447750 $Y=-112640
X44346 5 4 1763 6299 6317 1897 1768 FA_5VX1 $T=-447320 -62720 0 0 $X=-447750 $Y=-63360
X44347 5 4 1769 58 1876 1879 1775 FA_5VX1 $T=-446760 -134400 1 0 $X=-447190 $Y=-139520
X44348 5 4 1817 1841 6320 6321 1804 FA_5VX1 $T=-445640 -179200 0 0 $X=-446070 $Y=-179840
X44349 5 4 1796 6306 1885 6322 1814 FA_5VX1 $T=-445080 -143360 0 0 $X=-445510 $Y=-144000
X44350 5 4 1789 6319 1892 1896 1785 FA_5VX1 $T=-444520 -80640 1 0 $X=-444950 $Y=-85760
X44351 5 4 1772 1875 6324 6323 1779 FA_5VX1 $T=-444520 -71680 1 0 $X=-444950 $Y=-76800
X44352 5 4 1808 6305 1878 6328 1825 FA_5VX1 $T=-442280 -152320 1 0 $X=-442710 $Y=-157440
X44353 5 4 1836 1462 1919 6331 1884 FA_5VX1 $T=-437800 -206080 1 0 $X=-438230 $Y=-211200
X44354 5 4 6305 58 6347 1936 6322 FA_5VX1 $T=-437800 -143360 1 0 $X=-438230 $Y=-148480
X44355 5 4 1822 6329 6339 6337 1798 FA_5VX1 $T=-435560 -89600 1 0 $X=-435990 $Y=-94720
X44356 5 4 1910 1841 1928 1996 6328 FA_5VX1 $T=-435000 -170240 0 0 $X=-435430 $Y=-170880
X44357 5 4 1810 1910 1929 6341 1834 FA_5VX1 $T=-435000 -161280 1 0 $X=-435430 $Y=-166400
X44358 5 4 1734 1922 1893 1923 1705 FA_5VX1 $T=-435000 -8960 0 0 $X=-435430 $Y=-9600
X44359 5 4 1867 6334 1935 1940 1828 FA_5VX1 $T=-434440 -170240 1 0 $X=-434870 $Y=-175360
X44360 5 4 6317 6325 6336 48 1887 FA_5VX1 $T=-434440 -62720 1 0 $X=-434870 $Y=-67840
X44361 5 4 1864 1452 6342 6344 1901 FA_5VX1 $T=-433320 -224000 0 0 $X=-433750 $Y=-224640
X44362 5 4 1855 1900 6343 1934 1848 FA_5VX1 $T=-432760 -197120 0 0 $X=-433190 $Y=-197760
X44363 5 4 1893 49 1960 1966 1931 FA_5VX1 $T=-429400 -26880 0 0 $X=-429830 $Y=-27520
X44364 5 4 1898 1447 6349 6352 1918 FA_5VX1 $T=-427720 -232960 1 0 $X=-428150 $Y=-238080
X44365 5 4 6325 59 1967 6353 1984 FA_5VX1 $T=-427720 -71680 1 0 $X=-428150 $Y=-76800
X44366 5 4 1868 1976 1984 47 1809 FA_5VX1 $T=-424360 -53760 1 0 $X=-424790 $Y=-58880
X44367 5 4 75 79 89 6363 1950 FA_5VX1 $T=-423800 -268800 0 0 $X=-424230 $Y=-269440
X44368 5 4 1912 80 6356 6365 1927 FA_5VX1 $T=-423240 -250880 0 0 $X=-423670 $Y=-251520
X44369 5 4 1892 6355 6357 58 1968 FA_5VX1 $T=-422680 -80640 1 0 $X=-423110 $Y=-85760
X44370 5 4 1921 47 6364 8075 1960 FA_5VX1 $T=-422680 -53760 0 0 $X=-423110 $Y=-54400
X44371 5 4 1885 6346 6366 1462 1906 FA_5VX1 $T=-422120 -134400 1 0 $X=-422550 $Y=-139520
X44372 5 4 2017 1988 1865 6338 1820 FA_5VX1 $T=-404760 -215040 0 180 $X=-421990 $Y=-220160
X44373 5 4 1939 6350 6373 1991 1899 FA_5VX1 $T=-420440 -188160 0 0 $X=-420870 $Y=-188800
X44374 5 4 110 45 1909 1938 2014 FA_5VX1 $T=-403640 -17920 0 180 $X=-420870 $Y=-23040
X44375 5 4 6339 6368 6371 1841 1824 FA_5VX1 $T=-419880 -98560 0 0 $X=-420310 $Y=-99200
X44376 5 4 1835 1921 1980 54 1972 FA_5VX1 $T=-419880 -35840 1 0 $X=-420310 $Y=-40960
X44377 5 4 1874 1978 2006 1900 1930 FA_5VX1 $T=-419320 -116480 1 0 $X=-419750 $Y=-121600
X44378 5 4 81 90 2003 2014 96 FA_5VX1 $T=-418200 -8960 1 0 $X=-418630 $Y=-14080
X44379 5 4 1976 48 1956 1965 1980 FA_5VX1 $T=-400840 -62720 0 180 $X=-418070 $Y=-67840
X44380 5 4 1935 2000 6381 80 1928 FA_5VX1 $T=-416520 -170240 1 0 $X=-416950 $Y=-175360
X44381 5 4 6346 1452 2024 6387 2006 FA_5VX1 $T=-414280 -134400 0 0 $X=-414710 $Y=-135040
X44382 5 4 2040 6377 1894 1975 1988 FA_5VX1 $T=-395800 -224000 0 180 $X=-413030 $Y=-229120
X44383 5 4 8010 6382 1916 6359 6377 FA_5VX1 $T=-393560 -232960 0 180 $X=-410790 $Y=-238080
X44384 5 4 6358 6389 1933 2016 6382 FA_5VX1 $T=-409800 -250880 1 0 $X=-410230 $Y=-256000
X44385 5 4 1987 2063 6397 2052 2030 FA_5VX1 $T=-408120 -241920 0 0 $X=-408550 $Y=-242560
X44386 5 4 6373 2044 2064 79 1955 FA_5VX1 $T=-405880 -188160 1 0 $X=-406310 $Y=-193280
X44387 5 4 2008 112 2074 47 6395 FA_5VX1 $T=-404760 -17920 0 0 $X=-405190 $Y=-18560
X44388 5 4 6406 2029 1900 58 2041 FA_5VX1 $T=-386280 -35840 0 180 $X=-403510 $Y=-40960
X44389 5 4 6407 119 58 48 2038 FA_5VX1 $T=-385160 0 1 180 $X=-402390 $Y=-640
X44390 5 4 2056 6388 7941 2057 2005 FA_5VX1 $T=-384600 -215040 0 180 $X=-401830 $Y=-220160
X44391 5 4 2099 6395 6385 2037 122 FA_5VX1 $T=-384040 -8960 0 180 $X=-401270 $Y=-14080
X44392 5 4 7941 89 92 6408 1986 FA_5VX1 $T=-400280 -206080 1 0 $X=-400710 $Y=-211200
X44393 5 4 2028 118 6405 6406 2070 FA_5VX1 $T=-399720 -35840 0 0 $X=-400150 $Y=-36480
X44394 5 4 6385 54 59 2102 126 FA_5VX1 $T=-399720 -26880 0 0 $X=-400150 $Y=-27520
X44395 5 4 2113 121 2038 2008 2055 FA_5VX1 $T=-382920 8960 0 180 $X=-400150 $Y=3840
X44396 5 4 134 49 48 2029 124 FA_5VX1 $T=-381800 8960 1 180 $X=-399030 $Y=8320
X44397 5 4 107 2095 133 79 2022 FA_5VX1 $T=-398040 -259840 1 0 $X=-398470 $Y=-264960
X44398 5 4 6378 6391 2126 84 1946 FA_5VX1 $T=-397480 -206080 0 0 $X=-397910 $Y=-206720
X44399 5 4 2033 123 2107 2101 2082 FA_5VX1 $T=-397480 -116480 1 0 $X=-397910 $Y=-121600
X44400 5 4 6391 89 2111 100 2064 FA_5VX1 $T=-396920 -197120 1 0 $X=-397350 $Y=-202240
X44401 5 4 2048 119 2118 2121 2093 FA_5VX1 $T=-395800 -98560 1 0 $X=-396230 $Y=-103680
X44402 5 4 2084 2037 6412 2123 2079 FA_5VX1 $T=-395240 -71680 0 0 $X=-395670 $Y=-72320
X44403 5 4 6397 92 6413 6416 2035 FA_5VX1 $T=-393560 -241920 1 0 $X=-393990 $Y=-247040
X44404 5 4 2131 2029 2065 2053 2092 FA_5VX1 $T=-376760 -134400 0 180 $X=-393990 $Y=-139520
X44405 5 4 2060 112 6419 2134 6404 FA_5VX1 $T=-393000 -89600 0 0 $X=-393430 $Y=-90240
X44406 5 4 2068 128 6415 6417 2069 FA_5VX1 $T=-393000 -53760 1 0 $X=-393430 $Y=-58880
X44407 5 4 6417 2102 1462 1841 6405 FA_5VX1 $T=-376200 -53760 1 180 $X=-393430 $Y=-54400
X44408 5 4 2072 2128 92 84 2086 FA_5VX1 $T=-391320 -179200 0 0 $X=-391750 $Y=-179840
X44409 5 4 2144 2102 2086 6401 2106 FA_5VX1 $T=-372840 -152320 0 180 $X=-390070 $Y=-157440
X44410 5 4 6401 2139 89 79 2065 FA_5VX1 $T=-389640 -152320 0 0 $X=-390070 $Y=-152960
X44411 5 4 2134 2141 1447 1462 6412 FA_5VX1 $T=-389080 -80640 1 0 $X=-389510 $Y=-85760
X44412 5 4 6402 2088 145 100 2071 FA_5VX1 $T=-388520 -259840 0 0 $X=-388950 $Y=-260480
X44413 5 4 2053 2146 84 80 2107 FA_5VX1 $T=-388520 -134400 0 0 $X=-388950 $Y=-135040
X44414 5 4 2088 137 6422 139 6413 FA_5VX1 $T=-387400 -250880 1 0 $X=-387830 $Y=-256000
X44415 5 4 2163 123 1841 59 2103 FA_5VX1 $T=-370600 -17920 0 180 $X=-387830 $Y=-23040
X44416 5 4 2095 89 132 6402 2052 FA_5VX1 $T=-370040 -268800 1 180 $X=-387270 $Y=-269440
X44417 5 4 2121 2152 80 1452 6419 FA_5VX1 $T=-385720 -107520 0 0 $X=-386150 $Y=-108160
X44418 5 4 2178 135 2103 6407 2137 FA_5VX1 $T=-368920 -8960 1 180 $X=-386150 $Y=-9600
X44419 5 4 2101 2231 79 1447 2118 FA_5VX1 $T=-384040 -125440 0 0 $X=-384470 $Y=-126080
X44420 5 4 2123 2074 1452 1900 6415 FA_5VX1 $T=-366680 -71680 0 180 $X=-383910 $Y=-76800
X44421 5 4 6408 6425 6431 137 2126 FA_5VX1 $T=-382360 -215040 1 0 $X=-382790 $Y=-220160
X44422 5 4 2130 2074 2122 2072 2133 FA_5VX1 $T=-364440 -170240 1 180 $X=-381670 $Y=-170880
X44423 5 4 2129 142 2041 2163 2136 FA_5VX1 $T=-364440 -26880 1 180 $X=-381670 $Y=-27520
X44424 5 4 6437 2151 140 139 2153 FA_5VX1 $T=-362760 -250880 1 180 $X=-379990 $Y=-251520
X44425 5 4 6435 2115 137 92 2138 FA_5VX1 $T=-362760 -215040 1 180 $X=-379990 $Y=-215680
X44426 5 4 2116 2183 100 89 2122 FA_5VX1 $T=-379560 -197120 1 0 $X=-379990 $Y=-202240
X44427 5 4 2127 2152 2239 6435 2168 FA_5VX1 $T=-379560 -197120 0 0 $X=-379990 $Y=-197760
X44428 5 4 2277 149 143 138 2151 FA_5VX1 $T=-362200 -259840 0 180 $X=-379430 $Y=-264960
X44429 5 4 2215 141 138 2153 2210 FA_5VX1 $T=-362200 -241920 1 180 $X=-379430 $Y=-242560
X44430 5 4 6416 100 6434 141 6425 FA_5VX1 $T=-379000 -232960 0 0 $X=-379430 $Y=-233600
X44431 5 4 2179 2141 2138 2116 2143 FA_5VX1 $T=-362200 -188160 1 180 $X=-379430 $Y=-188800
X44432 5 4 6444 165 173 175 2253 FA_5VX1 $T=-348200 -268800 1 0 $X=-348630 $Y=-273920
X44433 5 4 6468 2128 6437 2208 2238 FA_5VX1 $T=-331400 -241920 0 180 $X=-348630 $Y=-247040
X44434 5 4 2279 2139 2215 2209 2211 FA_5VX1 $T=-331400 -241920 1 180 $X=-348630 $Y=-242560
X44435 5 4 2274 2217 141 100 2239 FA_5VX1 $T=-331400 -206080 1 180 $X=-348630 $Y=-206720
X44436 5 4 6448 6458 139 137 2255 FA_5VX1 $T=-347640 -232960 0 0 $X=-348070 $Y=-233600
X44437 5 4 6447 2291 2277 2253 2258 FA_5VX1 $T=-346520 -268800 0 0 $X=-346950 $Y=-269440
X44438 5 4 2360 6463 2269 2275 6457 FA_5VX1 $T=-346520 -89600 1 0 $X=-346950 $Y=-94720
X44439 5 4 2233 2231 2255 2274 2228 FA_5VX1 $T=-345960 -197120 1 0 $X=-346390 $Y=-202240
X44440 5 4 2227 2146 2210 6448 2245 FA_5VX1 $T=-328600 -224000 0 180 $X=-345830 $Y=-229120
X44441 5 4 2243 6465 2221 6450 6454 FA_5VX1 $T=-328040 -62720 1 180 $X=-345270 $Y=-63360
X44442 5 4 2292 6454 6451 2232 6455 FA_5VX1 $T=-327480 -35840 0 180 $X=-344710 $Y=-40960
X44443 5 4 2305 6455 2225 1458 2267 FA_5VX1 $T=-324680 -17920 0 180 $X=-341910 $Y=-23040
X44444 5 4 2165 6481 2250 2247 6463 FA_5VX1 $T=-323560 -107520 0 180 $X=-340790 $Y=-112640
X44445 5 4 2339 6457 2276 6453 6465 FA_5VX1 $T=-323560 -71680 0 180 $X=-340790 $Y=-76800
X44446 5 4 2264 172 2320 2335 2293 FA_5VX1 $T=-337560 0 0 0 $X=-337990 $Y=-640
X44447 5 4 2710 6485 2321 6488 6477 FA_5VX1 $T=-337000 -143360 0 0 $X=-337430 $Y=-144000
X44448 5 4 2347 6477 6466 6462 6481 FA_5VX1 $T=-317960 -125440 1 180 $X=-335190 $Y=-126080
X44449 5 4 2213 2330 2346 6496 6485 FA_5VX1 $T=-333080 -161280 1 0 $X=-333510 $Y=-166400
X44450 5 4 2373 2267 2266 2271 184 FA_5VX1 $T=-312360 0 0 180 $X=-329590 $Y=-5120
X44451 5 4 2341 137 139 195 2342 FA_5VX1 $T=-328600 -250880 1 0 $X=-329030 $Y=-256000
X44452 5 4 6501 141 138 182 2327 FA_5VX1 $T=-311240 -268800 1 180 $X=-328470 $Y=-269440
X44453 5 4 2301 6499 2378 51 2312 FA_5VX1 $T=-327480 -53760 1 0 $X=-327910 $Y=-58880
X44454 5 4 2302 6490 2380 1460 2359 FA_5VX1 $T=-326920 -17920 0 0 $X=-327350 $Y=-18560
X44455 5 4 2499 2341 2327 100 2349 FA_5VX1 $T=-307880 -259840 1 180 $X=-325110 $Y=-260480
X44456 5 4 2300 6494 2371 49 2324 FA_5VX1 $T=-324120 -80640 0 0 $X=-324550 $Y=-81280
X44457 5 4 6487 7946 2361 2366 2333 FA_5VX1 $T=-324120 -35840 0 0 $X=-324550 $Y=-36480
X44458 5 4 2314 51 6503 2403 2366 FA_5VX1 $T=-323560 -53760 0 0 $X=-323990 $Y=-54400
X44459 5 4 2319 47 2377 2393 2371 FA_5VX1 $T=-323000 -89600 1 0 $X=-323430 $Y=-94720
X44460 5 4 6509 2397 6491 2329 2330 FA_5VX1 $T=-305080 -179200 1 180 $X=-322310 $Y=-179840
X44461 5 4 2331 2387 2406 1841 2377 FA_5VX1 $T=-321880 -107520 0 0 $X=-322310 $Y=-108160
X44462 5 4 2325 2314 6508 45 2340 FA_5VX1 $T=-321320 -44800 0 0 $X=-321750 $Y=-45440
X44463 5 4 6490 90 6511 55 2335 FA_5VX1 $T=-320760 -8960 1 0 $X=-321190 $Y=-14080
X44464 5 4 201 192 189 187 2368 FA_5VX1 $T=-303400 -268800 0 180 $X=-320630 $Y=-273920
X44465 5 4 6495 2407 2417 84 2389 FA_5VX1 $T=-319080 -215040 1 0 $X=-319510 $Y=-220160
X44466 5 4 6494 54 6518 2437 2378 FA_5VX1 $T=-318520 -71680 1 0 $X=-318950 $Y=-76800
X44467 5 4 2358 48 2426 6520 6503 FA_5VX1 $T=-316840 -62720 1 0 $X=-317270 $Y=-67840
X44468 5 4 2407 89 2362 6498 2401 FA_5VX1 $T=-299480 -232960 1 180 $X=-316710 $Y=-233600
X44469 5 4 6499 49 6521 2358 6508 FA_5VX1 $T=-316280 -62720 0 0 $X=-316710 $Y=-63360
X44470 5 4 2439 89 6500 2363 2402 FA_5VX1 $T=-298360 -197120 1 180 $X=-315590 $Y=-197760
X44471 5 4 2403 47 2432 2423 2410 FA_5VX1 $T=-315160 -44800 1 0 $X=-315590 $Y=-49920
X44472 5 4 2361 6519 2433 54 6511 FA_5VX1 $T=-315160 -35840 1 0 $X=-315590 $Y=-40960
X44473 5 4 6525 199 2342 92 2411 FA_5VX1 $T=-295560 -250880 1 180 $X=-312790 $Y=-251520
X44474 5 4 197 202 6522 2421 204 FA_5VX1 $T=-312360 8960 1 0 $X=-312790 $Y=3840
X44475 5 4 1461 1447 6502 2401 6516 FA_5VX1 $T=-295000 -215040 1 180 $X=-312230 $Y=-215680
X44476 5 4 2393 6510 2442 58 6518 FA_5VX1 $T=-311800 -89600 0 0 $X=-312230 $Y=-90240
X44477 5 4 2388 2434 2445 2452 207 FA_5VX1 $T=-311800 -26880 0 0 $X=-312230 $Y=-27520
X44478 5 4 2469 89 137 92 2422 FA_5VX1 $T=-293320 -188160 1 180 $X=-310550 $Y=-188800
X44479 5 4 2398 2456 6524 2464 2406 FA_5VX1 $T=-310120 -125440 1 0 $X=-310550 $Y=-130560
X44480 5 4 2320 2388 2457 51 211 FA_5VX1 $T=-310120 -17920 0 0 $X=-310550 $Y=-18560
X44481 5 4 2478 1447 84 80 2465 FA_5VX1 $T=-292200 -98560 0 180 $X=-309430 $Y=-103680
X44482 5 4 2400 2447 2465 6529 2426 FA_5VX1 $T=-309000 -80640 1 0 $X=-309430 $Y=-85760
X44483 5 4 6536 6514 2396 6507 2417 FA_5VX1 $T=-291080 -250880 0 180 $X=-308310 $Y=-256000
X44484 5 4 2394 2459 2455 1462 2440 FA_5VX1 $T=-307880 -134400 0 0 $X=-308310 $Y=-135040
X44485 5 4 6504 2398 2441 1900 2436 FA_5VX1 $T=-307880 -125440 0 0 $X=-308310 $Y=-126080
X44486 5 4 6506 6515 2474 1452 2409 FA_5VX1 $T=-307320 -161280 0 0 $X=-307750 $Y=-161920
X44487 5 4 2437 59 2413 2400 6521 FA_5VX1 $T=-290520 -80640 1 180 $X=-307750 $Y=-81280
X44488 5 4 6533 6525 2349 84 2435 FA_5VX1 $T=-289960 -241920 0 180 $X=-307190 $Y=-247040
X44489 5 4 6512 84 100 89 6524 FA_5VX1 $T=-305640 -134400 1 0 $X=-306070 $Y=-139520
X44490 5 4 6515 6531 2484 2469 2455 FA_5VX1 $T=-305080 -179200 0 0 $X=-305510 $Y=-179840
X44491 5 4 2459 2427 2422 6512 2441 FA_5VX1 $T=-288280 -143360 1 180 $X=-305510 $Y=-144000
X44492 5 4 6510 2475 2471 2478 2413 FA_5VX1 $T=-305080 -89600 1 0 $X=-305510 $Y=-94720
X44493 5 4 2387 2477 2487 2514 2442 FA_5VX1 $T=-304520 -116480 1 0 $X=-304950 $Y=-121600
X44494 5 4 2502 1900 6513 6516 2446 FA_5VX1 $T=-287160 -206080 1 180 $X=-304390 $Y=-206720
X44495 5 4 2380 6530 6535 49 218 FA_5VX1 $T=-303960 -8960 1 0 $X=-304390 $Y=-14080
X44496 5 4 2500 1447 2411 79 2450 FA_5VX1 $T=-286600 -224000 1 180 $X=-303830 $Y=-224640
X44497 5 4 2420 84 2470 92 2463 FA_5VX1 $T=-303400 -161280 1 0 $X=-303830 $Y=-166400
X44498 5 4 206 2482 2416 2473 220 FA_5VX1 $T=-303400 0 0 0 $X=-303830 $Y=-640
X44499 5 4 2423 2483 2494 2498 2433 FA_5VX1 $T=-302840 -53760 0 0 $X=-303270 $Y=-54400
X44500 5 4 2490 137 213 6501 2458 FA_5VX1 $T=-285480 -268800 1 180 $X=-302710 $Y=-269440
X44501 5 4 2501 1462 6495 2450 6527 FA_5VX1 $T=-285480 -215040 0 180 $X=-302710 $Y=-220160
X44502 5 4 6542 1462 2420 2430 2454 FA_5VX1 $T=-284920 -170240 1 180 $X=-302150 $Y=-170880
X44503 5 4 2514 80 89 79 2471 FA_5VX1 $T=-283800 -107520 0 180 $X=-301030 $Y=-112640
X44504 5 4 228 2461 2467 54 2473 FA_5VX1 $T=-283800 -8960 1 180 $X=-301030 $Y=-9600
X44505 5 4 6520 6532 2513 2515 2432 FA_5VX1 $T=-299480 -71680 0 0 $X=-299910 $Y=-72320
X44506 5 4 2508 1452 2448 80 2462 FA_5VX1 $T=-281560 -232960 0 180 $X=-298790 $Y=-238080
X44507 5 4 6519 2503 2550 2521 6535 FA_5VX1 $T=-298360 -35840 1 0 $X=-298790 $Y=-40960
X44508 5 4 6546 1452 6526 2435 2491 FA_5VX1 $T=-279880 -232960 1 180 $X=-297110 $Y=-233600
X44509 5 4 2546 1900 1461 2462 6537 FA_5VX1 $T=-278200 -215040 1 180 $X=-295430 $Y=-215680
X44510 5 4 6530 221 2520 6552 2457 FA_5VX1 $T=-295000 -26880 0 0 $X=-295430 $Y=-27520
X44511 5 4 6551 58 2485 2454 2496 FA_5VX1 $T=-277640 -152320 1 180 $X=-294870 $Y=-152960
X44512 5 4 2555 1452 2439 2481 2544 FA_5VX1 $T=-275960 -188160 1 180 $X=-293190 $Y=-188800
X44513 5 4 2563 92 225 2490 2495 FA_5VX1 $T=-272600 -268800 0 180 $X=-289830 $Y=-273920
X44514 5 4 2573 2501 2508 2491 2538 FA_5VX1 $T=-269800 -224000 1 180 $X=-287030 $Y=-224640
X44515 5 4 6564 58 6542 2446 6548 FA_5VX1 $T=-269800 -161280 0 180 $X=-287030 $Y=-166400
X44516 5 4 2482 49 2503 54 230 FA_5VX1 $T=-269800 0 1 180 $X=-287030 $Y=-640
X44517 5 4 6563 89 2458 2499 2557 FA_5VX1 $T=-268680 -259840 1 180 $X=-285910 $Y=-260480
X44518 5 4 2507 6559 6563 2528 2591 FA_5VX1 $T=-285480 -250880 1 0 $X=-285910 $Y=-256000
X44519 5 4 2593 2553 2563 227 2545 FA_5VX1 $T=-268120 -268800 1 180 $X=-285350 $Y=-269440
X44520 5 4 2610 2518 2502 6537 2600 FA_5VX1 $T=-267560 -197120 1 180 $X=-284790 $Y=-197760
X44521 5 4 2518 1841 2555 2574 6557 FA_5VX1 $T=-283800 -188160 1 0 $X=-284230 $Y=-193280
X44522 5 4 2609 2543 6533 2505 2554 FA_5VX1 $T=-266440 -241920 0 180 $X=-283670 $Y=-247040
X44523 5 4 2595 1900 6544 2524 6555 FA_5VX1 $T=-266440 -170240 1 180 $X=-283670 $Y=-170880
X44524 5 4 6547 1462 2389 2580 2574 FA_5VX1 $T=-281560 -206080 1 0 $X=-281990 $Y=-211200
X44525 5 4 2617 6553 6551 6548 2569 FA_5VX1 $T=-264200 -161280 1 180 $X=-281430 $Y=-161920
X44526 5 4 2630 2546 6527 6547 2568 FA_5VX1 $T=-263640 -215040 0 180 $X=-280870 $Y=-220160
X44527 5 4 2622 6546 2500 2548 2567 FA_5VX1 $T=-263080 -232960 1 180 $X=-280310 $Y=-233600
X44528 5 4 2564 1841 2536 2544 2575 FA_5VX1 $T=-262520 -179200 1 180 $X=-279750 $Y=-179840
X44529 5 4 2547 6574 2583 2606 247 FA_5VX1 $T=-278200 -26880 0 0 $X=-278630 $Y=-27520
X44530 5 4 6553 59 2595 2575 2596 FA_5VX1 $T=-277640 -152320 1 0 $X=-278070 $Y=-157440
X44531 5 4 2637 6575 2559 2552 2581 FA_5VX1 $T=-260840 0 0 180 $X=-278070 $Y=-5120
X44532 5 4 6580 59 1841 6555 2582 FA_5VX1 $T=-260280 -143360 0 180 $X=-277510 $Y=-148480
X44533 5 4 2613 6564 2564 6557 2631 FA_5VX1 $T=-258040 -170240 0 180 $X=-275270 $Y=-175360
X44534 5 4 6586 2571 2576 6558 2597 FA_5VX1 $T=-258040 -116480 0 180 $X=-275270 $Y=-121600
X44535 5 4 2654 59 2577 2572 2604 FA_5VX1 $T=-256920 -62720 0 180 $X=-274150 $Y=-67840
X44536 5 4 2619 48 2578 6560 6571 FA_5VX1 $T=-256920 -53760 0 180 $X=-274150 $Y=-58880
X44537 5 4 2635 6567 6562 2541 2660 FA_5VX1 $T=-256360 -98560 1 180 $X=-273590 $Y=-99200
X44538 5 4 2590 47 6594 2660 2626 FA_5VX1 $T=-270360 -89600 0 0 $X=-270790 $Y=-90240
X44539 5 4 2675 47 2601 6568 2629 FA_5VX1 $T=-252440 -35840 0 180 $X=-269670 $Y=-40960
X44540 5 4 2655 49 2605 6571 6579 FA_5VX1 $T=-251320 -53760 1 180 $X=-268550 $Y=-54400
X44541 5 4 2612 54 2654 2668 6585 FA_5VX1 $T=-267000 -71680 1 0 $X=-267430 $Y=-76800
X44542 5 4 2614 6597 2682 1447 2519 FA_5VX1 $T=-265880 -197120 0 0 $X=-266310 $Y=-197760
X44543 5 4 6604 6579 2547 45 2647 FA_5VX1 $T=-248520 -17920 0 180 $X=-265750 $Y=-23040
X44544 5 4 6603 2612 2590 2618 2663 FA_5VX1 $T=-247960 -89600 0 180 $X=-265190 $Y=-94720
X44545 5 4 2688 49 2619 2626 6584 FA_5VX1 $T=-247400 -62720 1 180 $X=-264630 $Y=-63360
X44546 5 4 6609 2582 2635 47 2618 FA_5VX1 $T=-246280 -107520 1 180 $X=-263510 $Y=-108160
X44547 5 4 2702 2687 2634 6577 2397 FA_5VX1 $T=-245720 -179200 0 180 $X=-262950 $Y=-184320
X44548 5 4 2721 6604 6607 2681 2676 FA_5VX1 $T=-261400 -26880 0 0 $X=-261830 $Y=-27520
X44549 5 4 2672 2698 6580 2596 2674 FA_5VX1 $T=-244040 -134400 0 180 $X=-261270 $Y=-139520
X44550 5 4 6612 2632 2637 259 2670 FA_5VX1 $T=-244040 0 0 180 $X=-261270 $Y=-5120
X44551 5 4 2636 51 2675 2695 2681 FA_5VX1 $T=-260280 -44800 0 0 $X=-260710 $Y=-45440
X44552 5 4 6614 55 2648 2581 268 FA_5VX1 $T=-243480 8960 0 180 $X=-260710 $Y=3840
X44553 5 4 7949 48 2597 58 2668 FA_5VX1 $T=-242920 -116480 1 180 $X=-260150 $Y=-117120
X44554 5 4 2639 89 290 288 2653 FA_5VX1 $T=-259160 -268800 0 0 $X=-259590 $Y=-269440
X44555 5 4 2698 48 6586 2496 2673 FA_5VX1 $T=-242360 -125440 0 180 $X=-259590 $Y=-130560
X44556 5 4 2693 2636 2655 6584 2669 FA_5VX1 $T=-242360 -44800 0 180 $X=-259590 $Y=-49920
X44557 5 4 2645 6609 7949 2673 2662 FA_5VX1 $T=-258600 -107520 1 0 $X=-259030 $Y=-112640
X44558 5 4 2599 264 6614 2670 284 FA_5VX1 $T=-258600 0 0 0 $X=-259030 $Y=-640
X44559 5 4 2649 265 2713 141 2659 FA_5VX1 $T=-258040 -232960 1 0 $X=-258470 $Y=-238080
X44560 5 4 2720 79 2659 2656 2611 FA_5VX1 $T=-240680 -224000 1 180 $X=-257910 $Y=-224640
X44561 5 4 2728 54 2570 2604 2695 FA_5VX1 $T=-240120 -62720 0 180 $X=-257350 $Y=-67840
X44562 5 4 2724 6612 6595 2647 2686 FA_5VX1 $T=-240120 -8960 0 180 $X=-257350 $Y=-14080
X44563 5 4 2656 6618 2749 2733 2746 FA_5VX1 $T=-254120 -241920 0 0 $X=-254550 $Y=-242560
X44564 5 4 2679 80 2746 2736 2506 FA_5VX1 $T=-250200 -179200 0 0 $X=-250630 $Y=-179840
X44565 5 4 2680 2688 2728 6585 2703 FA_5VX1 $T=-233400 -71680 0 180 $X=-250630 $Y=-76800
X44566 5 4 2780 6613 6610 1447 2725 FA_5VX1 $T=-231160 -250880 0 180 $X=-248390 $Y=-256000
X44567 5 4 6613 80 322 2639 2740 FA_5VX1 $T=-244040 -259840 1 0 $X=-244470 $Y=-264960
X44568 5 4 2796 6628 2539 6615 2741 FA_5VX1 $T=-226680 -206080 1 180 $X=-243910 $Y=-206720
X44569 5 4 2799 303 295 291 305 FA_5VX1 $T=-226120 8960 1 180 $X=-243350 $Y=8320
X44570 5 4 2713 306 140 139 2749 FA_5VX1 $T=-240120 -259840 0 0 $X=-240550 $Y=-260480
X44571 5 4 2736 6638 336 333 2682 FA_5VX1 $T=-238440 -215040 1 0 $X=-238870 $Y=-220160
X44572 5 4 2820 2741 2120 2737 2687 FA_5VX1 $T=-221640 -197120 1 180 $X=-238870 $Y=-197760
X44573 5 4 2860 137 317 2755 2802 FA_5VX1 $T=-218280 -241920 1 180 $X=-235510 $Y=-242560
X44574 5 4 2774 80 2832 6660 2828 FA_5VX1 $T=-230040 -179200 0 0 $X=-230470 $Y=-179840
X44575 5 4 8076 2795 1466 137 2832 FA_5VX1 $T=-209880 -206080 1 180 $X=-227110 $Y=-206720
X44576 5 4 2850 79 89 2801 6656 FA_5VX1 $T=-206520 -143360 0 180 $X=-223750 $Y=-148480
X44577 5 4 2839 80 6649 6650 2857 FA_5VX1 $T=-204840 -134400 1 180 $X=-222070 $Y=-135040
X44578 5 4 6676 1462 6656 2839 2872 FA_5VX1 $T=-202040 -125440 0 180 $X=-219270 $Y=-130560
X44579 5 4 2867 345 6654 141 1470 FA_5VX1 $T=-201480 -250880 1 180 $X=-218710 $Y=-251520
X44580 5 4 2868 1447 2851 2843 2877 FA_5VX1 $T=-201480 -116480 0 180 $X=-218710 $Y=-121600
X44581 5 4 2887 58 6655 2844 2874 FA_5VX1 $T=-201480 -26880 0 180 $X=-218710 $Y=-32000
X44582 5 4 2900 1447 6657 6652 2876 FA_5VX1 $T=-200920 -161280 1 180 $X=-218150 $Y=-161920
X44583 5 4 6679 1452 2856 2850 2915 FA_5VX1 $T=-199800 -143360 1 180 $X=-217030 $Y=-144000
X44584 5 4 2885 1462 6659 2852 2882 FA_5VX1 $T=-199800 -80640 1 180 $X=-217030 $Y=-81280
X44585 5 4 6678 1900 6661 6658 2892 FA_5VX1 $T=-199240 -62720 0 180 $X=-216470 $Y=-67840
X44586 5 4 2904 1452 6665 6663 6671 FA_5VX1 $T=-198120 -98560 1 180 $X=-215350 $Y=-99200
X44587 5 4 2862 59 2882 6678 2908 FA_5VX1 $T=-214920 -62720 0 0 $X=-215350 $Y=-63360
X44588 5 4 6680 1900 2857 2868 2901 FA_5VX1 $T=-196440 -116480 1 180 $X=-213670 $Y=-117120
X44589 5 4 2963 54 2874 6667 359 FA_5VX1 $T=-194200 -8960 1 180 $X=-211430 $Y=-9600
X44590 5 4 2944 6680 2872 58 2916 FA_5VX1 $T=-193640 -107520 0 180 $X=-210870 $Y=-112640
X44591 5 4 2855 79 92 8076 6674 FA_5VX1 $T=-193080 -206080 1 180 $X=-210310 $Y=-206720
X44592 5 4 6682 58 6671 2885 2902 FA_5VX1 $T=-193080 -71680 0 180 $X=-210310 $Y=-76800
X44593 5 4 2934 47 2889 2887 2918 FA_5VX1 $T=-192520 -26880 1 180 $X=-209750 $Y=-27520
X44594 5 4 2973 2862 2902 47 2926 FA_5VX1 $T=-191400 -53760 0 180 $X=-208630 $Y=-58880
X44595 5 4 2972 59 2901 2896 2940 FA_5VX1 $T=-190840 -89600 0 180 $X=-208070 $Y=-94720
X44596 5 4 2970 1841 2886 6670 2889 FA_5VX1 $T=-190840 -35840 0 180 $X=-208070 $Y=-40960
X44597 5 4 2982 6682 2907 48 2929 FA_5VX1 $T=-190280 -71680 1 180 $X=-207510 $Y=-72320
X44598 5 4 2896 1841 2877 2904 2907 FA_5VX1 $T=-189720 -80640 0 180 $X=-206950 $Y=-85760
X44599 5 4 3002 6676 2915 1841 2939 FA_5VX1 $T=-188600 -125440 1 180 $X=-205830 $Y=-126080
X44600 5 4 2991 2917 2908 54 2930 FA_5VX1 $T=-187480 -35840 1 180 $X=-204710 $Y=-36480
X44601 5 4 2950 6679 2876 1900 2933 FA_5VX1 $T=-186920 -152320 1 180 $X=-204150 $Y=-152960
X44602 5 4 2917 48 2892 2970 2941 FA_5VX1 $T=-203720 -44800 0 0 $X=-204150 $Y=-45440
X44603 5 4 2959 2963 2918 51 371 FA_5VX1 $T=-185800 0 0 180 $X=-203030 $Y=-5120
X44604 5 4 2992 49 2941 2934 372 FA_5VX1 $T=-183560 -17920 0 180 $X=-200790 $Y=-23040
X44605 5 4 3120 6727 3057 3050 6721 FA_5VX1 $T=-159480 -107520 1 180 $X=-176710 $Y=-108160
X44606 5 4 3121 3110 3061 6712 6728 FA_5VX1 $T=-158360 -188160 0 180 $X=-175590 $Y=-193280
X44607 5 4 2863 3086 3063 3056 6727 FA_5VX1 $T=-158360 -116480 1 180 $X=-175590 $Y=-117120
X44608 5 4 3084 6721 3068 3064 6722 FA_5VX1 $T=-157800 -80640 1 180 $X=-175030 $Y=-81280
X44609 5 4 3872 6722 3069 3065 3089 FA_5VX1 $T=-157800 -62720 0 180 $X=-175030 $Y=-67840
X44610 5 4 3889 6732 3073 3066 3096 FA_5VX1 $T=-156680 -161280 1 180 $X=-173910 $Y=-161920
X44611 5 4 2823 3096 6715 3067 3086 FA_5VX1 $T=-156680 -134400 1 180 $X=-173910 $Y=-135040
X44612 5 4 2875 3093 3043 3072 426 FA_5VX1 $T=-156120 0 1 180 $X=-173350 $Y=-640
X44613 5 4 1474 6728 6724 3083 6732 FA_5VX1 $T=-155000 -179200 1 180 $X=-172230 $Y=-179840
X44614 5 4 2979 6738 6716 6718 3093 FA_5VX1 $T=-154440 -8960 0 180 $X=-171670 $Y=-14080
X44615 5 4 7023 429 6723 3082 3108 FA_5VX1 $T=-153320 -250880 0 180 $X=-170550 $Y=-256000
X44616 5 4 2835 3139 8077 3154 3142 FA_5VX1 $T=-169000 -98560 1 0 $X=-169430 $Y=-103680
X44617 5 4 2825 3145 3153 6747 3126 FA_5VX1 $T=-167880 -152320 1 0 $X=-168310 $Y=-157440
X44618 5 4 3160 3089 6733 6730 6738 FA_5VX1 $T=-149960 -44800 0 180 $X=-167190 $Y=-49920
X44619 5 4 6734 6749 3164 8070 3146 FA_5VX1 $T=-164520 -44800 0 0 $X=-164950 $Y=-45440
X44620 5 4 3106 3159 3167 3173 6742 FA_5VX1 $T=-163960 -89600 1 0 $X=-164390 $Y=-94720
X44621 5 4 459 6743 3085 3109 3110 FA_5VX1 $T=-146600 -215040 1 180 $X=-163830 $Y=-215680
X44622 5 4 3182 3108 3091 3103 6743 FA_5VX1 $T=-143800 -232960 1 180 $X=-161030 $Y=-233600
X44623 5 4 3117 3163 2767 8072 6749 FA_5VX1 $T=-160600 -53760 1 0 $X=-161030 $Y=-58880
X44624 5 4 3123 6742 2781 8071 3163 FA_5VX1 $T=-160040 -71680 1 0 $X=-160470 $Y=-76800
X44625 5 4 6762 3166 2717 6739 6748 FA_5VX1 $T=-142680 -125440 1 180 $X=-159910 $Y=-126080
X44626 5 4 6764 6758 8078 3124 3157 FA_5VX1 $T=-142120 -224000 0 180 $X=-159350 $Y=-229120
X44627 5 4 3131 3175 3183 6766 3166 FA_5VX1 $T=-158920 -143360 0 0 $X=-159350 $Y=-144000
X44628 5 4 3154 6748 2797 8079 3159 FA_5VX1 $T=-158920 -107520 0 0 $X=-159350 $Y=-108160
X44629 5 4 2807 6756 3187 6762 3139 FA_5VX1 $T=-157800 -116480 0 0 $X=-158230 $Y=-117120
X44630 5 4 3102 3174 2813 3189 453 FA_5VX1 $T=-157800 8960 1 0 $X=-158230 $Y=3840
X44631 5 4 3138 6759 3161 6768 6757 FA_5VX1 $T=-156680 -170240 0 0 $X=-157110 $Y=-170880
X44632 5 4 2847 6761 3199 3138 3145 FA_5VX1 $T=-155000 -161280 0 0 $X=-155430 $Y=-161920
X44633 5 4 3140 6763 2794 3221 3174 FA_5VX1 $T=-153320 -26880 0 0 $X=-153750 $Y=-27520
X44634 5 4 6773 3157 3104 6746 3177 FA_5VX1 $T=-135960 -206080 0 180 $X=-153190 $Y=-211200
X44635 5 4 3143 3146 2779 6772 6763 FA_5VX1 $T=-152760 -35840 1 0 $X=-153190 $Y=-40960
X44636 5 4 6737 3201 6771 6773 3181 FA_5VX1 $T=-152200 -197120 0 0 $X=-152630 $Y=-197760
X44637 5 4 3170 3177 3088 8080 6759 FA_5VX1 $T=-152200 -188160 1 0 $X=-152630 $Y=-193280
X44638 5 4 6747 6757 3079 8081 3175 FA_5VX1 $T=-151080 -152320 1 0 $X=-151510 $Y=-157440
X44639 5 4 3152 472 3240 3190 6770 FA_5VX1 $T=-147160 -259840 1 0 $X=-147590 $Y=-264960
X44640 5 4 6754 6764 3237 3225 3201 FA_5VX1 $T=-146600 -224000 0 0 $X=-147030 $Y=-224640
X44641 5 4 8082 6770 3216 3200 3225 FA_5VX1 $T=-145480 -241920 0 0 $X=-145910 $Y=-242560
X44642 5 4 3169 6783 3230 6799 3232 FA_5VX1 $T=-143240 -241920 1 0 $X=-143670 $Y=-247040
X44643 5 4 3190 478 502 3255 6783 FA_5VX1 $T=-140440 -268800 0 0 $X=-140870 $Y=-269440
X44644 5 4 8081 6793 6806 3257 3206 FA_5VX1 $T=-132040 -152320 1 0 $X=-132470 $Y=-157440
X44645 5 4 6826 6848 6852 3409 6841 FA_5VX1 $T=-97880 -241920 0 0 $X=-98310 $Y=-242560
X44646 5 4 3414 7951 3116 6823 6837 FA_5VX1 $T=-81080 -89600 0 180 $X=-98310 $Y=-94720
X44647 5 4 3318 3395 575 576 565 FA_5VX1 $T=-97880 8960 1 0 $X=-98310 $Y=3840
X44648 5 4 6803 555 3366 3367 6848 FA_5VX1 $T=-97320 -259840 0 0 $X=-97750 $Y=-260480
X44649 5 4 3338 6847 3402 6865 3346 FA_5VX1 $T=-97320 -62720 0 0 $X=-97750 $Y=-63360
X44650 5 4 6823 6851 3356 3363 6844 FA_5VX1 $T=-96200 -89600 0 0 $X=-96630 $Y=-90240
X44651 5 4 6824 6844 6735 3485 6847 FA_5VX1 $T=-96200 -71680 1 0 $X=-96630 $Y=-76800
X44652 5 4 6828 6841 6862 6863 6845 FA_5VX1 $T=-95640 -215040 1 0 $X=-96070 $Y=-220160
X44653 5 4 6825 6853 578 3417 3383 FA_5VX1 $T=-95640 -134400 0 0 $X=-96070 $Y=-135040
X44654 5 4 3354 6855 585 3439 6853 FA_5VX1 $T=-92840 -143360 1 0 $X=-93270 $Y=-148480
X44655 5 4 3359 3406 590 3449 6855 FA_5VX1 $T=-92280 -161280 1 0 $X=-92710 $Y=-166400
X44656 5 4 3365 3426 3427 3447 3395 FA_5VX1 $T=-91160 0 1 0 $X=-91590 $Y=-5120
X44657 5 4 1479 3404 3533 3455 3408 FA_5VX1 $T=-89480 -250880 1 0 $X=-89910 $Y=-256000
X44658 5 4 6829 6845 3424 8083 6860 FA_5VX1 $T=-88920 -197120 0 0 $X=-89350 $Y=-197760
X44659 5 4 3340 6860 3411 3462 6858 FA_5VX1 $T=-88920 -179200 0 0 $X=-89350 $Y=-179840
X44660 5 4 7925 3443 3458 3466 6861 FA_5VX1 $T=-88920 -80640 0 0 $X=-89350 $Y=-81280
X44661 5 4 3317 6868 3460 3467 6859 FA_5VX1 $T=-88920 -26880 0 0 $X=-89350 $Y=-27520
X44662 5 4 566 6849 6871 3469 582 FA_5VX1 $T=-88920 0 0 0 $X=-89350 $Y=-640
X44663 5 4 6831 6858 3457 6879 6866 FA_5VX1 $T=-86680 -161280 0 0 $X=-87110 $Y=-161920
X44664 5 4 3303 6870 3479 3437 6868 FA_5VX1 $T=-85560 -44800 0 0 $X=-85990 $Y=-45440
X44665 5 4 3272 6859 6881 3446 3426 FA_5VX1 $T=-85560 -8960 1 0 $X=-85990 $Y=-14080
X44666 5 4 6843 6874 6888 3472 6867 FA_5VX1 $T=-85000 -232960 1 0 $X=-85430 $Y=-238080
X44667 5 4 3301 6861 3394 6885 6870 FA_5VX1 $T=-85000 -53760 1 0 $X=-85430 $Y=-58880
X44668 5 4 3393 3475 6887 6889 6873 FA_5VX1 $T=-83880 -107520 1 0 $X=-84310 $Y=-112640
X44669 5 4 3378 6878 6893 8084 3434 FA_5VX1 $T=-81080 -241920 1 0 $X=-81510 $Y=-247040
X44670 5 4 3404 1496 7954 584 3472 FA_5VX1 $T=-81080 -241920 0 0 $X=-81510 $Y=-242560
X44671 5 4 6805 6873 3491 6894 3443 FA_5VX1 $T=-81080 -89600 1 0 $X=-81510 $Y=-94720
X44672 5 4 3300 6866 6890 3513 6877 FA_5VX1 $T=-79960 -143360 0 0 $X=-80390 $Y=-144000
X44673 5 4 3297 6877 3488 6901 3475 FA_5VX1 $T=-78840 -125440 0 0 $X=-79270 $Y=-126080
X44674 5 4 589 593 8085 584 3492 FA_5VX1 $T=-77720 -268800 0 0 $X=-78150 $Y=-269440
X44675 5 4 3381 6869 3483 3492 3374 FA_5VX1 $T=-77720 -259840 0 0 $X=-78150 $Y=-260480
X44676 5 4 3405 6875 6900 8086 3493 FA_5VX1 $T=-77720 -215040 1 0 $X=-78150 $Y=-220160
X44677 5 4 3390 3511 3529 584 3497 FA_5VX1 $T=-75480 -224000 0 0 $X=-75910 $Y=-224640
X44678 5 4 6869 599 3534 1489 6893 FA_5VX1 $T=-74920 -250880 0 0 $X=-75350 $Y=-251520
X44679 5 4 583 600 617 595 7954 FA_5VX1 $T=-74360 -268800 1 0 $X=-74790 $Y=-273920
X44680 5 4 571 1489 618 624 3455 FA_5VX1 $T=-74360 -259840 1 0 $X=-74790 $Y=-264960
X44681 5 4 3448 3525 3538 1489 3474 FA_5VX1 $T=-74360 -206080 1 0 $X=-74790 $Y=-211200
X44682 5 4 3423 6899 619 3528 613 FA_5VX1 $T=-74360 8960 0 0 $X=-74790 $Y=8320
X44683 5 4 6874 3504 3574 1489 3388 FA_5VX1 $T=-73240 -232960 0 0 $X=-73670 $Y=-233600
X44684 5 4 3456 3530 3518 8087 3473 FA_5VX1 $T=-73240 -197120 1 0 $X=-73670 $Y=-202240
X44685 5 4 3403 609 3552 3556 3523 FA_5VX1 $T=-72680 -17920 0 0 $X=-73110 $Y=-18560
X44686 5 4 6875 3504 6906 3553 3518 FA_5VX1 $T=-72120 -215040 0 0 $X=-72550 $Y=-215680
X44687 5 4 6878 3506 6908 1496 6900 FA_5VX1 $T=-71560 -224000 1 0 $X=-71990 $Y=-229120
X44688 5 4 3483 584 1481 3558 3506 FA_5VX1 $T=-70440 -250880 1 0 $X=-70870 $Y=-256000
X44689 5 4 3486 610 3523 633 3528 FA_5VX1 $T=-70440 8960 1 0 $X=-70870 $Y=3840
X44690 5 4 3416 6905 3561 614 3536 FA_5VX1 $T=-69320 -53760 0 0 $X=-69750 $Y=-54400
X44691 5 4 602 6903 3496 604 621 FA_5VX1 $T=-68760 -44800 0 0 $X=-69190 $Y=-45440
X44692 5 4 6888 3559 3565 624 3547 FA_5VX1 $T=-67080 -232960 1 0 $X=-67510 $Y=-238080
X44693 5 4 3419 7955 6911 611 3551 FA_5VX1 $T=-66520 -98560 1 0 $X=-66950 $Y=-103680
X44694 5 4 6892 6897 3571 604 598 FA_5VX1 $T=-66520 -35840 0 0 $X=-66950 $Y=-36480
X44695 5 4 8084 1489 3588 6918 3553 FA_5VX1 $T=-64280 -241920 1 0 $X=-64710 $Y=-247040
X44696 5 4 3465 620 6916 3560 3459 FA_5VX1 $T=-64280 -89600 1 0 $X=-64710 $Y=-94720
X44697 5 4 3521 1496 3581 8088 3599 FA_5VX1 $T=-63720 -143360 1 0 $X=-64150 $Y=-148480
X44698 5 4 6897 623 3584 6920 3552 FA_5VX1 $T=-63720 -35840 1 0 $X=-64150 $Y=-40960
X44699 5 4 642 3522 608 3489 628 FA_5VX1 $T=-46920 -8960 1 180 $X=-64150 $Y=-9600
X44700 5 4 6899 3563 3573 645 634 FA_5VX1 $T=-63720 0 0 0 $X=-64150 $Y=-640
X44701 5 4 3435 6910 6917 6921 3520 FA_5VX1 $T=-63160 -179200 0 0 $X=-63590 $Y=-179840
X44702 5 4 3508 3521 3594 625 3555 FA_5VX1 $T=-62040 -134400 1 0 $X=-62470 $Y=-139520
X44703 5 4 3507 3579 3593 3504 3539 FA_5VX1 $T=-61480 -161280 1 0 $X=-61910 $Y=-166400
X44704 5 4 3527 3580 6922 6924 3567 FA_5VX1 $T=-60920 -161280 0 0 $X=-61350 $Y=-161920
X44705 5 4 3463 3582 3599 607 3535 FA_5VX1 $T=-60920 -116480 1 0 $X=-61350 $Y=-121600
X44706 5 4 3517 3586 6923 608 3573 FA_5VX1 $T=-60360 -8960 1 0 $X=-60790 $Y=-14080
X44707 5 4 8085 595 650 3610 3558 FA_5VX1 $T=-59800 -268800 0 0 $X=-60230 $Y=-269440
X44708 5 4 8086 1496 3566 6927 6912 FA_5VX1 $T=-59800 -215040 1 0 $X=-60230 $Y=-220160
X44709 5 4 3582 3504 3549 3544 6911 FA_5VX1 $T=-43000 -125440 1 180 $X=-60230 $Y=-126080
X44710 5 4 3533 6907 646 586 3574 FA_5VX1 $T=-59240 -259840 0 0 $X=-59670 $Y=-260480
X44711 5 4 3431 3596 6925 623 3546 FA_5VX1 $T=-59240 -62720 1 0 $X=-59670 $Y=-67840
X44712 5 4 3530 6912 6929 625 6917 FA_5VX1 $T=-58680 -197120 0 0 $X=-59110 $Y=-197760
X44713 5 4 3534 586 3564 3615 6918 FA_5VX1 $T=-58120 -250880 0 0 $X=-58550 $Y=-251520
X44714 5 4 6905 620 6926 3569 3571 FA_5VX1 $T=-58120 -53760 1 0 $X=-58550 $Y=-58880
X44715 5 4 6907 592 657 6933 3565 FA_5VX1 $T=-57000 -259840 1 0 $X=-57430 $Y=-264960
X44716 5 4 3511 586 3613 6931 3538 FA_5VX1 $T=-56440 -232960 0 0 $X=-56870 $Y=-233600
X44717 5 4 6906 584 3617 6937 3598 FA_5VX1 $T=-55320 -206080 1 0 $X=-55750 $Y=-211200
X44718 5 4 8087 3504 6935 3598 3591 FA_5VX1 $T=-55320 -197120 1 0 $X=-55750 $Y=-202240
X44719 5 4 3560 607 3602 3622 6925 FA_5VX1 $T=-54760 -98560 0 0 $X=-55190 $Y=-99200
X44720 5 4 3525 624 3621 8089 3570 FA_5VX1 $T=-54200 -215040 0 0 $X=-54630 $Y=-215680
X44721 5 4 3544 6930 3601 584 3603 FA_5VX1 $T=-54200 -125440 1 0 $X=-54630 $Y=-130560
X44722 5 4 3568 3385 3614 3616 6926 FA_5VX1 $T=-54200 -62720 0 0 $X=-54630 $Y=-63360
X44723 5 4 6908 624 6939 3630 6927 FA_5VX1 $T=-53640 -224000 1 0 $X=-54070 $Y=-229120
X44724 5 4 6910 3591 3625 607 6924 FA_5VX1 $T=-53640 -170240 0 0 $X=-54070 $Y=-170880
X44725 5 4 3556 614 6936 6941 6923 FA_5VX1 $T=-53640 -26880 1 0 $X=-54070 $Y=-32000
X44726 5 4 7955 3619 3603 625 6916 FA_5VX1 $T=-52520 -107520 0 0 $X=-52950 $Y=-108160
X44727 5 4 3596 3568 3575 611 3561 FA_5VX1 $T=-35720 -71680 1 180 $X=-52950 $Y=-72320
X44728 5 4 3569 625 3623 3634 3584 FA_5VX1 $T=-52520 -53760 0 0 $X=-52950 $Y=-54400
X44729 5 4 6941 611 6915 6913 3666 FA_5VX1 $T=-35720 -17920 0 180 $X=-52950 $Y=-23040
X44730 5 4 3619 1489 3576 6914 3602 FA_5VX1 $T=-35160 -107520 0 180 $X=-52390 $Y=-112640
X44731 5 4 3622 1496 6919 3600 3575 FA_5VX1 $T=-33480 -80640 0 180 $X=-50710 $Y=-85760
X44732 5 4 6920 607 6944 8090 6936 FA_5VX1 $T=-49720 -35840 0 0 $X=-50150 $Y=-36480
X44733 5 4 669 3606 3590 3587 652 FA_5VX1 $T=-32920 8960 1 180 $X=-50150 $Y=8320
X44734 5 4 3563 3635 3640 629 666 FA_5VX1 $T=-48040 8960 1 0 $X=-48470 $Y=3840
X44735 5 4 3559 595 3660 8091 3529 FA_5VX1 $T=-47480 -241920 1 0 $X=-47910 $Y=-247040
X44736 5 4 8088 624 6946 3638 3549 FA_5VX1 $T=-46920 -143360 1 0 $X=-47350 $Y=-148480
X44737 5 4 6921 625 3641 3655 3637 FA_5VX1 $T=-46360 -179200 0 0 $X=-46790 $Y=-179840
X44738 5 4 3586 604 3666 3658 3640 FA_5VX1 $T=-46360 -26880 0 0 $X=-46790 $Y=-27520
X44739 5 4 3635 609 3592 6928 661 FA_5VX1 $T=-28440 -17920 1 180 $X=-45670 $Y=-18560
X44740 5 4 3579 7956 3650 1489 3594 FA_5VX1 $T=-44680 -161280 1 0 $X=-45110 $Y=-166400
X44741 5 4 3512 6948 6957 584 3593 FA_5VX1 $T=-43560 -188160 1 0 $X=-43990 $Y=-193280
X44742 5 4 3580 659 6958 3637 3651 FA_5VX1 $T=-43560 -152320 1 0 $X=-43990 $Y=-157440
X44743 5 4 6928 623 3659 3629 3587 FA_5VX1 $T=-43560 -8960 1 0 $X=-43990 $Y=-14080
X44744 5 4 3609 7957 6955 6960 3626 FA_5VX1 $T=-43000 -125440 0 0 $X=-43430 $Y=-126080
X44745 5 4 6929 1489 3689 6959 3655 FA_5VX1 $T=-42440 -188160 0 0 $X=-42870 $Y=-188800
X44746 5 4 7956 586 3681 6954 3581 FA_5VX1 $T=-42440 -170240 1 0 $X=-42870 $Y=-175360
X44747 5 4 3543 6942 3667 3651 3639 FA_5VX1 $T=-42440 -143360 0 0 $X=-42870 $Y=-144000
X44748 5 4 6931 632 3683 6956 3621 FA_5VX1 $T=-41880 -232960 1 0 $X=-42310 $Y=-238080
X44749 5 4 8089 592 6988 3720 6957 FA_5VX1 $T=-36840 -215040 0 0 $X=-37270 $Y=-215680
X44750 5 4 6942 675 6974 3712 6960 FA_5VX1 $T=-36840 -125440 1 0 $X=-37270 $Y=-130560
X44751 5 4 3618 6950 3648 3696 3674 FA_5VX1 $T=-36280 -98560 1 0 $X=-36710 $Y=-103680
X44752 5 4 6945 6949 6967 8092 3653 FA_5VX1 $T=-36280 -89600 0 0 $X=-36710 $Y=-90240
X44753 5 4 3654 3695 691 6970 682 FA_5VX1 $T=-36280 0 0 0 $X=-36710 $Y=-640
X44754 5 4 7957 6965 3663 623 3696 FA_5VX1 $T=-34040 -107520 1 0 $X=-34470 $Y=-112640
X44755 5 4 3648 623 6972 3705 3699 FA_5VX1 $T=-34040 -107520 0 0 $X=-34470 $Y=-108160
X44756 5 4 6933 637 6973 3713 3660 FA_5VX1 $T=-33480 -259840 1 0 $X=-33910 $Y=-264960
X44757 5 4 3695 610 6952 3718 686 FA_5VX1 $T=-16120 8960 1 180 $X=-33350 $Y=8320
X44758 5 4 6949 604 3706 3699 3702 FA_5VX1 $T=-32360 -80640 1 0 $X=-32790 $Y=-85760
X44759 5 4 3663 607 3704 6978 3705 FA_5VX1 $T=-31800 -116480 1 0 $X=-32230 $Y=-121600
X44760 5 4 6951 6968 3702 3707 3684 FA_5VX1 $T=-31800 -71680 0 0 $X=-32230 $Y=-72320
X44761 5 4 3667 659 3731 6977 6965 FA_5VX1 $T=-31240 -134400 1 0 $X=-31670 $Y=-139520
X44762 5 4 6952 629 3732 3756 690 FA_5VX1 $T=-31240 0 1 0 $X=-31670 $Y=-5120
X44763 5 4 8091 677 6981 8093 3613 FA_5VX1 $T=-30680 -241920 1 0 $X=-31110 $Y=-247040
X44764 5 4 6950 6975 3697 614 6967 FA_5VX1 $T=-30120 -89600 1 0 $X=-30550 $Y=-94720
X44765 5 4 6922 689 6987 3738 3712 FA_5VX1 $T=-28440 -161280 0 0 $X=-28870 $Y=-161920
X44766 5 4 3675 6969 6994 3735 3644 FA_5VX1 $T=-27880 -17920 0 0 $X=-28310 $Y=-18560
X44767 5 4 3685 6963 6983 3760 3686 FA_5VX1 $T=-27320 -26880 1 0 $X=-27750 $Y=-32000
X44768 5 4 3688 608 3755 6993 3726 FA_5VX1 $T=-26760 -44800 0 0 $X=-27190 $Y=-45440
X44769 5 4 3668 6982 3688 3759 3665 FA_5VX1 $T=-26760 -35840 1 0 $X=-27190 $Y=-40960
X44770 5 4 6994 633 3698 3692 3718 FA_5VX1 $T=-9960 -8960 0 180 $X=-27190 $Y=-14080
X44771 5 4 6958 3504 3744 3779 6977 FA_5VX1 $T=-26200 -143360 1 0 $X=-26630 $Y=-148480
X44772 5 4 6955 675 3741 6992 6975 FA_5VX1 $T=-26200 -125440 0 0 $X=-26630 $Y=-126080
X44773 5 4 3697 659 3765 6998 3793 FA_5VX1 $T=-25080 -98560 0 0 $X=-25510 $Y=-99200
X44774 5 4 6963 633 6995 3726 3735 FA_5VX1 $T=-25080 -17920 1 0 $X=-25510 $Y=-23040
X44775 5 4 3625 1496 3770 3772 3738 FA_5VX1 $T=-23960 -170240 0 0 $X=-24390 $Y=-170880
X44776 5 4 3707 604 3746 3749 6979 FA_5VX1 $T=-23400 -71680 1 0 $X=-23830 $Y=-76800
X44777 5 4 3664 3751 3743 3750 3694 FA_5VX1 $T=-23400 -62720 0 0 $X=-23830 $Y=-63360
X44778 5 4 3706 620 6999 7000 3749 FA_5VX1 $T=-22280 -80640 0 0 $X=-22710 $Y=-81280
X44779 5 4 6968 609 8094 3766 3750 FA_5VX1 $T=-22280 -62720 1 0 $X=-22710 $Y=-67840
X44780 5 4 3751 6979 6971 608 3759 FA_5VX1 $T=-5480 -44800 0 180 $X=-22710 $Y=-49920
X44781 5 4 3698 604 3785 614 3756 FA_5VX1 $T=-21160 -8960 0 0 $X=-21590 $Y=-9600
X44782 5 4 6974 625 3758 7003 6992 FA_5VX1 $T=-20040 -125440 1 0 $X=-20470 $Y=-130560
X44783 5 4 8092 614 3767 3793 3766 FA_5VX1 $T=-19480 -89600 0 0 $X=-19910 $Y=-90240
X44784 5 4 6971 614 7006 7007 6993 FA_5VX1 $T=-19480 -53760 0 0 $X=-19910 $Y=-54400
X44785 5 4 6969 645 3789 7002 6970 FA_5VX1 $T=-19480 0 0 0 $X=-19910 $Y=-640
X44786 5 4 7009 7005 696 3687 3761 FA_5VX1 $T=-1000 -197120 0 180 $X=-18230 $Y=-202240
X44787 5 4 3789 608 7010 716 710 FA_5VX1 $T=-16680 8960 1 0 $X=-17110 $Y=3840
X44788 5 4 3715 3761 700 3716 3406 FA_5VX1 $T=680 -188160 0 180 $X=-16550 $Y=-193280
X44789 5 4 6982 3780 3768 629 3760 FA_5VX1 $T=-14440 -35840 0 0 $X=-14870 $Y=-36480
X44790 5 4 6983 629 3791 3818 7002 FA_5VX1 $T=-14440 -26880 0 0 $X=-14870 $Y=-27520
X44791 5 4 6986 7008 3826 3806 3795 FA_5VX1 $T=-13880 -206080 0 0 $X=-14310 $Y=-206720
X44792 5 4 3743 609 7013 7958 3780 FA_5VX1 $T=-13320 -53760 1 0 $X=-13750 $Y=-58880
X44793 5 4 6990 3810 727 3825 7005 FA_5VX1 $T=-12760 -224000 0 0 $X=-13190 $Y=-224640
X44794 5 4 3768 604 7019 8095 3818 FA_5VX1 $T=-10520 -26880 1 0 $X=-10950 $Y=-32000
X44795 5 4 6995 609 7020 3837 3692 FA_5VX1 $T=-9960 -8960 1 0 $X=-10390 $Y=-14080
X44796 5 4 7020 611 3784 3787 3785 FA_5VX1 $T=8520 -17920 0 180 $X=-8710 $Y=-23040
X44797 5 4 3721 3834 741 744 3810 FA_5VX1 $T=-7720 -250880 0 0 $X=-8150 $Y=-251520
X44798 5 4 8094 623 7025 3861 7958 FA_5VX1 $T=-4920 -62720 1 0 $X=-5350 $Y=-67840
X44799 5 4 3838 604 7040 3991 767 FA_5VX1 $T=5160 0 1 0 $X=4730 $Y=-5120
X44800 5 4 3843 7041 779 7051 3891 FA_5VX1 $T=6280 -170240 0 0 $X=5850 $Y=-170880
X44801 5 4 3605 7032 4767 3904 3892 FA_5VX1 $T=6840 -107520 0 0 $X=6410 $Y=-108160
X44802 5 4 3919 3887 3927 7054 7037 FA_5VX1 $T=9080 -241920 0 0 $X=8650 $Y=-242560
X44803 5 4 7064 611 3504 3858 3864 FA_5VX1 $T=25880 -35840 0 180 $X=8650 $Y=-40960
X44804 5 4 3926 3838 3869 3848 770 FA_5VX1 $T=26440 0 1 180 $X=9210 $Y=-640
X44805 5 4 3866 7050 3933 3925 7041 FA_5VX1 $T=10200 -179200 0 0 $X=9770 $Y=-179840
X44806 5 4 3868 623 7061 7059 7047 FA_5VX1 $T=10760 -26880 1 0 $X=10330 $Y=-32000
X44807 5 4 3880 7055 3950 3911 7050 FA_5VX1 $T=13560 -197120 1 0 $X=13130 $Y=-202240
X44808 5 4 3883 7037 4116 7065 7055 FA_5VX1 $T=14680 -215040 0 0 $X=14250 $Y=-215680
X44809 5 4 3896 620 3975 3964 3936 FA_5VX1 $T=16920 -53760 0 0 $X=16490 $Y=-54400
X44810 5 4 3901 3967 1492 7072 3939 FA_5VX1 $T=17480 -206080 0 0 $X=17050 $Y=-206720
X44811 5 4 3913 611 3990 3994 3955 FA_5VX1 $T=18600 -71680 1 0 $X=18170 $Y=-76800
X44812 5 4 3959 7068 3985 3971 3949 FA_5VX1 $T=19160 -224000 0 0 $X=18730 $Y=-224640
X44813 5 4 3996 3896 7959 3955 3942 FA_5VX1 $T=36520 -53760 0 180 $X=19290 $Y=-58880
X44814 5 4 7073 3894 7053 7047 3945 FA_5VX1 $T=36520 -17920 0 180 $X=19290 $Y=-23040
X44815 5 4 4000 789 782 637 3943 FA_5VX1 $T=37080 -268800 1 180 $X=19850 $Y=-269440
X44816 5 4 800 592 783 3923 3958 FA_5VX1 $T=37640 -268800 0 180 $X=20410 $Y=-273920
X44817 5 4 3924 3947 4000 3958 3968 FA_5VX1 $T=21400 -259840 0 0 $X=20970 $Y=-260480
X44818 5 4 3922 790 7076 7080 795 FA_5VX1 $T=22520 -8960 0 0 $X=22090 $Y=-9600
X44819 5 4 3931 4004 7084 7086 3938 FA_5VX1 $T=24760 -232960 1 0 $X=24330 $Y=-238080
X44820 5 4 7053 7075 607 3997 3991 FA_5VX1 $T=24760 -35840 0 0 $X=24330 $Y=-36480
X44821 5 4 7061 625 4008 3988 3997 FA_5VX1 $T=25320 -71680 0 0 $X=24890 $Y=-72320
X44822 5 4 4019 3868 7064 3936 7069 FA_5VX1 $T=42680 -35840 0 180 $X=25450 $Y=-40960
X44823 5 4 3952 3891 4044 7090 4053 FA_5VX1 $T=28120 -134400 1 0 $X=27690 $Y=-139520
X44824 5 4 4046 3913 3980 3973 7082 FA_5VX1 $T=47720 -89600 0 180 $X=30490 $Y=-94720
X44825 5 4 1492 7089 4016 592 4005 FA_5VX1 $T=31480 -215040 0 0 $X=31050 $Y=-215680
X44826 5 4 3932 7087 4054 4024 3920 FA_5VX1 $T=32600 -188160 0 0 $X=32170 $Y=-188800
X44827 5 4 4056 607 3970 3989 3973 FA_5VX1 $T=49960 -107520 0 180 $X=32730 $Y=-112640
X44828 5 4 3960 4052 7097 4043 3978 FA_5VX1 $T=34280 -170240 1 0 $X=33850 $Y=-175360
X44829 5 4 4075 675 607 7078 4028 FA_5VX1 $T=53320 -17920 0 180 $X=36090 $Y=-23040
X44830 5 4 4031 4056 4080 4090 4034 FA_5VX1 $T=37080 -116480 0 0 $X=36650 $Y=-117120
X44831 5 4 4009 659 7108 4088 7095 FA_5VX1 $T=37080 -53760 0 0 $X=36650 $Y=-54400
X44832 5 4 7089 632 818 4108 4068 FA_5VX1 $T=41560 -241920 1 0 $X=41130 $Y=-247040
X44833 5 4 4078 4036 811 806 4065 FA_5VX1 $T=58920 -259840 1 180 $X=41690 $Y=-260480
X44834 5 4 7077 4053 4110 4096 4074 FA_5VX1 $T=42120 -125440 0 0 $X=41690 $Y=-126080
X44835 5 4 4022 4093 4073 7110 4059 FA_5VX1 $T=43240 -161280 1 0 $X=42810 $Y=-166400
X44836 5 4 4030 7105 7115 4098 4037 FA_5VX1 $T=46040 -134400 1 0 $X=45610 $Y=-139520
X44837 5 4 4118 4101 7098 7094 817 FA_5VX1 $T=62840 0 0 180 $X=45610 $Y=-5120
X44838 5 4 4097 607 7099 7102 4063 FA_5VX1 $T=64520 -71680 1 180 $X=47290 $Y=-72320
X44839 5 4 4054 7107 4068 595 4137 FA_5VX1 $T=65080 -188160 0 180 $X=47850 $Y=-193280
X44840 5 4 4052 1496 4137 7122 7110 FA_5VX1 $T=48280 -179200 1 0 $X=47850 $Y=-184320
X44841 5 4 4093 3504 4050 4017 4098 FA_5VX1 $T=65080 -170240 1 180 $X=47850 $Y=-170880
X44842 5 4 7127 7114 7100 4020 4101 FA_5VX1 $T=65080 -26880 1 180 $X=47850 $Y=-27520
X44843 5 4 4143 625 4086 7104 4111 FA_5VX1 $T=67320 -107520 1 180 $X=50090 $Y=-108160
X44844 5 4 4082 4126 4145 4083 7114 FA_5VX1 $T=51080 -44800 1 0 $X=50650 $Y=-49920
X44845 5 4 7105 625 4166 4117 4090 FA_5VX1 $T=52760 -143360 1 0 $X=52330 $Y=-148480
X44846 5 4 7081 4074 4152 7109 7118 FA_5VX1 $T=53320 -98560 0 0 $X=52890 $Y=-99200
X44847 5 4 4091 7118 4062 4087 4126 FA_5VX1 $T=53320 -80640 1 0 $X=52890 $Y=-85760
X44848 5 4 834 595 632 7961 4158 FA_5VX1 $T=58920 -259840 0 0 $X=58490 $Y=-260480
X44849 5 4 4147 3504 7121 4128 4151 FA_5VX1 $T=76840 -125440 1 180 $X=59610 $Y=-126080
X44850 5 4 3351 7145 4204 4178 7139 FA_5VX1 $T=64520 -35840 1 0 $X=64090 $Y=-40960
X44851 5 4 3372 7139 3562 4207 7144 FA_5VX1 $T=65640 -17920 0 0 $X=65210 $Y=-18560
X44852 5 4 4149 624 7147 7149 4173 FA_5VX1 $T=66760 -224000 0 0 $X=66330 $Y=-224640
X44853 5 4 4154 1496 7148 7151 4155 FA_5VX1 $T=68440 -152320 1 0 $X=68010 $Y=-157440
X44854 5 4 4196 881 7137 7135 4185 FA_5VX1 $T=86360 -250880 1 180 $X=69130 $Y=-251520
X44855 5 4 4159 7150 7152 584 4199 FA_5VX1 $T=70680 -197120 0 0 $X=70250 $Y=-197760
X44856 5 4 3469 7144 7154 3993 891 FA_5VX1 $T=70680 0 0 0 $X=70250 $Y=-640
X44857 5 4 4222 874 679 677 4198 FA_5VX1 $T=88040 -232960 1 180 $X=70810 $Y=-233600
X44858 5 4 4172 1489 7157 7159 4186 FA_5VX1 $T=71800 -179200 0 0 $X=71370 $Y=-179840
X44859 5 4 883 4239 907 4216 4206 FA_5VX1 $T=75160 -268800 0 0 $X=74730 $Y=-269440
X44860 5 4 4200 7162 4278 4269 4245 FA_5VX1 $T=78520 -107520 0 0 $X=78090 $Y=-108160
X44861 5 4 4286 7153 4212 604 903 FA_5VX1 $T=97000 -8960 0 180 $X=79770 $Y=-14080
X44862 5 4 918 7161 4221 4208 905 FA_5VX1 $T=97560 -35840 1 180 $X=80330 $Y=-36480
X44863 5 4 7170 7158 4215 614 4227 FA_5VX1 $T=98120 -35840 0 180 $X=80890 $Y=-40960
X44864 5 4 4210 7164 4284 1496 4260 FA_5VX1 $T=81880 -170240 1 0 $X=81450 $Y=-175360
X44865 5 4 895 4226 7168 614 911 FA_5VX1 $T=81880 -26880 0 0 $X=81450 $Y=-27520
X44866 5 4 7176 902 670 637 4231 FA_5VX1 $T=99240 -250880 0 180 $X=82010 $Y=-256000
X44867 5 4 4293 633 4227 629 7160 FA_5VX1 $T=99240 -17920 1 180 $X=82010 $Y=-18560
X44868 5 4 4216 901 698 670 4265 FA_5VX1 $T=83560 -268800 1 0 $X=83130 $Y=-273920
X44869 5 4 4287 4240 4231 4222 4248 FA_5VX1 $T=100360 -224000 0 180 $X=83130 $Y=-229120
X44870 5 4 7174 4241 4220 4224 4215 FA_5VX1 $T=100360 -71680 0 180 $X=83130 $Y=-76800
X44871 5 4 7153 910 4300 4291 4277 FA_5VX1 $T=84680 -17920 1 0 $X=84250 $Y=-23040
X44872 5 4 4264 4281 7171 7176 7163 FA_5VX1 $T=85240 -241920 0 0 $X=84810 $Y=-242560
X44873 5 4 4217 4258 4265 4304 4274 FA_5VX1 $T=85800 -259840 1 0 $X=85370 $Y=-264960
X44874 5 4 4235 4232 928 4294 4280 FA_5VX1 $T=86920 -152320 0 0 $X=86490 $Y=-152960
X44875 5 4 7158 4273 7178 4271 4212 FA_5VX1 $T=86920 -44800 1 0 $X=86490 $Y=-49920
X44876 5 4 4242 4289 4198 7182 4283 FA_5VX1 $T=87480 -206080 1 0 $X=87050 $Y=-211200
X44877 5 4 7184 4236 4355 4244 4255 FA_5VX1 $T=104280 -116480 1 180 $X=87050 $Y=-117120
X44878 5 4 4323 4200 4255 620 4275 FA_5VX1 $T=104280 -80640 0 180 $X=87050 $Y=-85760
X44879 5 4 4325 4247 4252 7160 916 FA_5VX1 $T=104280 0 1 180 $X=87050 $Y=-640
X44880 5 4 7182 914 637 632 4412 FA_5VX1 $T=104840 -215040 1 180 $X=87610 $Y=-215680
X44881 5 4 4334 4235 4249 3504 7167 FA_5VX1 $T=104840 -125440 0 180 $X=87610 $Y=-130560
X44882 5 4 4295 4290 933 4288 4284 FA_5VX1 $T=89720 -197120 0 0 $X=89290 $Y=-197760
X44883 5 4 4304 917 683 679 7171 FA_5VX1 $T=108760 -268800 1 180 $X=91530 $Y=-269440
X44884 5 4 7164 4261 939 4340 4249 FA_5VX1 $T=92520 -179200 0 0 $X=92090 $Y=-179840
X44885 5 4 4324 7174 4245 623 922 FA_5VX1 $T=109880 -71680 1 180 $X=92650 $Y=-72320
X44886 5 4 915 4338 4349 608 932 FA_5VX1 $T=94200 -8960 0 0 $X=93770 $Y=-9600
X44887 5 4 4311 4285 4280 625 4308 FA_5VX1 $T=111560 -134400 0 180 $X=94330 $Y=-139520
X44888 5 4 4252 7177 4277 609 929 FA_5VX1 $T=111560 0 0 180 $X=94330 $Y=-5120
X44889 5 4 4346 4295 4364 1489 4315 FA_5VX1 $T=112120 -161280 1 180 $X=94890 $Y=-161920
X44890 5 4 7190 608 4275 609 4298 FA_5VX1 $T=112120 -53760 1 180 $X=94890 $Y=-54400
X44891 5 4 4373 624 4279 4282 4306 FA_5VX1 $T=112680 -215040 0 180 $X=95450 $Y=-220160
X44892 5 4 4285 4228 4367 4376 4322 FA_5VX1 $T=96440 -143360 1 0 $X=96010 $Y=-148480
X44893 5 4 4377 4293 4286 920 4333 FA_5VX1 $T=114360 8960 1 180 $X=97130 $Y=8320
X44894 5 4 4297 609 7192 604 4341 FA_5VX1 $T=98120 -62720 0 0 $X=97690 $Y=-63360
X44895 5 4 4381 4292 7170 4298 4331 FA_5VX1 $T=114920 -35840 0 180 $X=97690 $Y=-40960
X44896 5 4 4338 936 4307 4301 937 FA_5VX1 $T=116040 -17920 1 180 $X=98810 $Y=-18560
X44897 5 4 923 670 949 683 4354 FA_5VX1 $T=100360 -268800 1 0 $X=99930 $Y=-273920
X44898 5 4 7196 595 930 7179 4259 FA_5VX1 $T=117720 -250880 1 180 $X=100490 $Y=-251520
X44899 5 4 4422 7180 4311 7175 4345 FA_5VX1 $T=117720 -98560 0 180 $X=100490 $Y=-103680
X44900 5 4 4407 4382 4316 7169 4347 FA_5VX1 $T=117720 -98560 1 180 $X=100490 $Y=-99200
X44901 5 4 7179 908 4354 7195 4318 FA_5VX1 $T=101480 -259840 0 0 $X=101050 $Y=-260480
X44902 5 4 7177 7962 4356 4360 4349 FA_5VX1 $T=101480 -17920 1 0 $X=101050 $Y=-23040
X44903 5 4 4391 586 4318 4313 4314 FA_5VX1 $T=118840 -232960 0 180 $X=101610 $Y=-238080
X44904 5 4 4402 7190 4324 4341 4348 FA_5VX1 $T=118840 -53760 0 180 $X=101610 $Y=-58880
X44905 5 4 7195 679 698 670 4326 FA_5VX1 $T=119400 -259840 0 180 $X=102170 $Y=-264960
X44906 5 4 4313 4218 4326 931 4279 FA_5VX1 $T=119400 -241920 1 180 $X=102170 $Y=-242560
X44907 5 4 4382 614 4308 623 4352 FA_5VX1 $T=119400 -89600 0 180 $X=102170 $Y=-94720
X44908 5 4 7200 4240 906 584 4358 FA_5VX1 $T=120520 -116480 0 180 $X=103290 $Y=-121600
X44909 5 4 4316 7187 4322 607 4368 FA_5VX1 $T=120520 -107520 0 180 $X=103290 $Y=-112640
X44910 5 4 7185 7184 4389 611 7192 FA_5VX1 $T=103720 -89600 0 0 $X=103290 $Y=-90240
X44911 5 4 4282 4305 957 958 4369 FA_5VX1 $T=104280 -224000 1 0 $X=103850 $Y=-229120
X44912 5 4 7202 924 677 592 4361 FA_5VX1 $T=121080 -206080 0 180 $X=103850 $Y=-211200
X44913 5 4 4408 4312 7185 4352 4362 FA_5VX1 $T=121080 -80640 0 180 $X=103850 $Y=-85760
X44914 5 4 8096 4258 592 906 4365 FA_5VX1 $T=121640 -170240 0 180 $X=104410 $Y=-175360
X44915 5 4 4431 4297 4323 4332 4366 FA_5VX1 $T=121640 -62720 0 180 $X=104410 $Y=-67840
X44916 5 4 4344 4396 4369 584 4383 FA_5VX1 $T=106520 -206080 0 0 $X=106090 $Y=-206720
X44917 5 4 4399 4400 4346 7183 4450 FA_5VX1 $T=123880 -152320 1 180 $X=106650 $Y=-152960
X44918 5 4 7201 4289 624 1489 4380 FA_5VX1 $T=123880 -134400 1 180 $X=106650 $Y=-135040
X44919 5 4 7187 4237 4419 4379 4389 FA_5VX1 $T=107640 -125440 0 0 $X=107210 $Y=-126080
X44920 5 4 4426 7194 4210 4370 4456 FA_5VX1 $T=125560 -143360 1 180 $X=108330 $Y=-144000
X44921 5 4 4392 7188 4334 4351 4384 FA_5VX1 $T=125560 -107520 1 180 $X=108330 $Y=-108160
X44922 5 4 4396 4243 940 7189 4364 FA_5VX1 $T=126120 -224000 1 180 $X=108890 $Y=-224640
X44923 5 4 4427 4375 4344 4336 7193 FA_5VX1 $T=126120 -188160 0 180 $X=108890 $Y=-193280
X44924 5 4 4378 4239 632 595 4385 FA_5VX1 $T=126120 -179200 0 180 $X=108890 $Y=-184320
X44925 5 4 4405 4281 595 624 7199 FA_5VX1 $T=130040 -161280 1 180 $X=112810 $Y=-161920
X44926 5 4 7209 4390 4361 4378 4404 FA_5VX1 $T=130600 -188160 1 180 $X=113370 $Y=-188800
X44927 5 4 4470 7197 4373 4267 4413 FA_5VX1 $T=131720 -197120 0 180 $X=114490 $Y=-202240
X44928 5 4 4469 955 625 611 966 FA_5VX1 $T=131720 8960 0 180 $X=114490 $Y=3840
X44929 5 4 971 953 4390 623 962 FA_5VX1 $T=131720 8960 1 180 $X=114490 $Y=8320
X44930 5 4 7211 950 3504 607 4411 FA_5VX1 $T=134520 -17920 1 180 $X=117290 $Y=-18560
X44931 5 4 4398 961 4447 7211 4453 FA_5VX1 $T=118840 -17920 1 0 $X=118410 $Y=-23040
X44932 5 4 7212 592 959 954 4310 FA_5VX1 $T=136200 -259840 0 180 $X=118970 $Y=-264960
X44933 5 4 4476 7204 7196 7198 4449 FA_5VX1 $T=136200 -241920 0 180 $X=118970 $Y=-247040
X44934 5 4 7213 969 4411 4469 4439 FA_5VX1 $T=136200 0 1 180 $X=118970 $Y=-640
X44935 5 4 4507 4468 7212 4440 4464 FA_5VX1 $T=119960 -259840 0 0 $X=119530 $Y=-260480
X44936 5 4 4473 950 4365 4405 4451 FA_5VX1 $T=136760 -152320 0 180 $X=119530 $Y=-157440
X44937 5 4 4416 4443 584 1496 4420 FA_5VX1 $T=136760 -80640 1 180 $X=119530 $Y=-81280
X44938 5 4 4421 945 1496 625 4447 FA_5VX1 $T=136760 -35840 1 180 $X=119530 $Y=-36480
X44939 5 4 7210 960 4358 7201 4452 FA_5VX1 $T=137320 -116480 1 180 $X=120090 $Y=-117120
X44940 5 4 4479 967 4420 4410 4459 FA_5VX1 $T=137320 -53760 0 180 $X=120090 $Y=-58880
X44941 5 4 4410 4390 1489 3504 4424 FA_5VX1 $T=137320 -53760 1 180 $X=120090 $Y=-54400
X44942 5 4 4472 7207 4391 4327 4461 FA_5VX1 $T=137880 -224000 0 180 $X=120650 $Y=-229120
X44943 5 4 4477 4443 4412 7202 4454 FA_5VX1 $T=137880 -206080 0 180 $X=120650 $Y=-211200
X44944 5 4 4478 955 7199 7200 4457 FA_5VX1 $T=137880 -125440 0 180 $X=120650 $Y=-130560
X44945 5 4 4482 953 4380 4416 4458 FA_5VX1 $T=137880 -80640 0 180 $X=120650 $Y=-85760
X44946 5 4 975 7206 963 4409 4460 FA_5VX1 $T=138440 -268800 0 180 $X=121210 $Y=-273920
X44947 5 4 4481 945 4385 8096 4455 FA_5VX1 $T=138440 -170240 0 180 $X=121210 $Y=-175360
X44948 5 4 4483 970 4424 4421 4463 FA_5VX1 $T=138440 -35840 0 180 $X=121210 $Y=-40960
X44949 5 4 4581 7252 4530 4539 4552 FA_5VX1 $T=173720 -53760 0 180 $X=156490 $Y=-58880
X44950 5 4 4587 7257 997 4529 4551 FA_5VX1 $T=174280 -179200 1 180 $X=157050 $Y=-179840
X44951 5 4 7235 7253 4494 4540 7248 FA_5VX1 $T=158040 -80640 1 0 $X=157610 $Y=-85760
X44952 5 4 7262 4578 4542 4568 4570 FA_5VX1 $T=177640 -241920 0 180 $X=160410 $Y=-247040
X44953 5 4 8097 7248 4547 8043 7252 FA_5VX1 $T=177640 -62720 0 180 $X=160410 $Y=-67840
X44954 5 4 7238 4574 1052 7264 7257 FA_5VX1 $T=161400 -197120 1 0 $X=160970 $Y=-202240
X44955 5 4 4561 4570 4550 8044 4574 FA_5VX1 $T=178760 -215040 0 180 $X=161530 $Y=-220160
X44956 5 4 4603 4551 1016 7239 7255 FA_5VX1 $T=178760 -152320 0 180 $X=161530 $Y=-157440
X44957 5 4 7265 7261 4538 8042 7253 FA_5VX1 $T=179320 -107520 1 180 $X=162090 $Y=-108160
X44958 5 4 4620 7255 4466 7243 7258 FA_5VX1 $T=180440 -134400 0 180 $X=163210 $Y=-139520
X44959 5 4 4594 4552 4553 4541 7259 FA_5VX1 $T=180440 -17920 1 180 $X=163210 $Y=-18560
X44960 5 4 4577 7259 1023 7244 1040 FA_5VX1 $T=181000 0 0 180 $X=163770 $Y=-5120
X44961 5 4 4589 7258 4572 4554 7261 FA_5VX1 $T=183240 -116480 0 180 $X=166010 $Y=-121600
X44962 5 4 4593 7272 4317 4666 4634 FA_5VX1 $T=173720 -44800 1 0 $X=173290 $Y=-49920
X44963 5 4 7282 1067 4597 1050 7269 FA_5VX1 $T=191640 -268800 1 180 $X=174410 $Y=-269440
X44964 5 4 8098 7278 4406 7263 4627 FA_5VX1 $T=191640 -80640 0 180 $X=174410 $Y=-85760
X44965 5 4 4598 7269 4671 7284 4643 FA_5VX1 $T=176520 -241920 0 0 $X=176090 $Y=-242560
X44966 5 4 4680 4627 4609 4604 7272 FA_5VX1 $T=193880 -71680 1 180 $X=176650 $Y=-72320
X44967 5 4 7263 4665 4681 4492 7275 FA_5VX1 $T=177640 -89600 0 0 $X=177210 $Y=-90240
X44968 5 4 7287 4674 4617 4610 7271 FA_5VX1 $T=195000 -197120 1 180 $X=177770 $Y=-197760
X44969 5 4 4624 7271 4618 4611 7273 FA_5VX1 $T=195000 -170240 1 180 $X=177770 $Y=-170880
X44970 5 4 4679 7277 4625 4621 7274 FA_5VX1 $T=196120 -125440 1 180 $X=178890 $Y=-126080
X44971 5 4 1098 4669 4632 7266 1083 FA_5VX1 $T=196680 0 1 180 $X=179450 $Y=-640
X44972 5 4 4664 7273 4633 7267 7277 FA_5VX1 $T=197240 -134400 0 180 $X=180010 $Y=-139520
X44973 5 4 7268 7283 4689 5747 4665 FA_5VX1 $T=181000 -107520 0 0 $X=180570 $Y=-108160
X44974 5 4 4666 7280 4631 5556 4650 FA_5VX1 $T=197800 -53760 1 180 $X=180570 $Y=-54400
X44975 5 4 7267 7281 7291 4693 7279 FA_5VX1 $T=181560 -143360 0 0 $X=181130 $Y=-144000
X44976 5 4 7266 7286 3728 4705 1092 FA_5VX1 $T=181560 0 1 0 $X=181130 $Y=-5120
X44977 5 4 4611 7965 4425 4702 7281 FA_5VX1 $T=182120 -161280 1 0 $X=181690 $Y=-166400
X44978 5 4 4610 4683 4695 4395 7965 FA_5VX1 $T=182680 -179200 1 0 $X=182250 $Y=-184320
X44979 5 4 4704 7274 4639 7268 7278 FA_5VX1 $T=199480 -98560 0 180 $X=182250 $Y=-103680
X44980 5 4 4621 7279 4699 4703 7283 FA_5VX1 $T=183240 -116480 1 0 $X=182810 $Y=-121600
X44981 5 4 4604 7275 3703 5547 7280 FA_5VX1 $T=200600 -62720 1 180 $X=183370 $Y=-63360
X44982 5 4 4662 4634 4640 4641 4669 FA_5VX1 $T=200600 -26880 0 180 $X=183370 $Y=-32000
X44983 5 4 4652 4700 4838 4723 4690 FA_5VX1 $T=186600 -35840 0 0 $X=186170 $Y=-36480
X44984 5 4 4729 4643 4656 7276 4674 FA_5VX1 $T=203960 -224000 0 180 $X=186730 $Y=-229120
X44985 5 4 4641 4650 5266 4160 7286 FA_5VX1 $T=204520 -44800 1 180 $X=187290 $Y=-45440
X44986 5 4 4092 4698 1111 4743 4713 FA_5VX1 $T=188840 -206080 1 0 $X=188410 $Y=-211200
X44987 5 4 4660 7301 1116 4697 4698 FA_5VX1 $T=189400 -224000 0 0 $X=188970 $Y=-224640
X44988 5 4 7276 7296 4745 4737 4683 FA_5VX1 $T=189400 -215040 0 0 $X=188970 $Y=-215680
X44989 5 4 3865 4713 1118 8049 7299 FA_5VX1 $T=191080 -188160 1 0 $X=190650 $Y=-193280
X44990 5 4 4678 4734 4653 4753 4700 FA_5VX1 $T=192760 -35840 1 0 $X=192330 $Y=-40960
X44991 5 4 3900 7305 4779 7319 7304 FA_5VX1 $T=194440 -89600 0 0 $X=194010 $Y=-90240
X44992 5 4 5248 4731 4756 8050 7303 FA_5VX1 $T=195000 -143360 1 0 $X=194570 $Y=-148480
X44993 5 4 3860 7306 1126 7318 4731 FA_5VX1 $T=195560 -161280 0 0 $X=195130 $Y=-161920
X44994 5 4 3902 7314 4765 4776 7305 FA_5VX1 $T=196120 -107520 1 0 $X=195690 $Y=-112640
X44995 5 4 3951 7299 1129 8051 7306 FA_5VX1 $T=196680 -170240 1 0 $X=196250 $Y=-175360
X44996 5 4 1102 4750 7316 4770 4742 FA_5VX1 $T=196680 0 0 0 $X=196250 $Y=-640
X44997 5 4 1103 7303 4775 7317 7308 FA_5VX1 $T=197240 -134400 1 0 $X=196810 $Y=-139520
X44998 5 4 1105 7304 4780 8052 7307 FA_5VX1 $T=197240 -71680 1 0 $X=196810 $Y=-76800
X44999 5 4 4710 7308 4799 8053 7314 FA_5VX1 $T=200040 -116480 1 0 $X=199610 $Y=-121600
X45000 5 4 4722 7307 4793 8054 4734 FA_5VX1 $T=200600 -62720 0 0 $X=200170 $Y=-63360
X45001 5 4 5019 4690 4832 7327 4750 FA_5VX1 $T=204520 -17920 1 0 $X=204090 $Y=-23040
X45002 5 4 4740 4797 1523 4823 4802 FA_5VX1 $T=205080 -224000 1 0 $X=204650 $Y=-229120
X45003 5 4 4748 7328 4841 1506 4809 FA_5VX1 $T=208440 -224000 0 0 $X=208010 $Y=-224640
X45004 5 4 4766 4829 7331 4863 4810 FA_5VX1 $T=209000 -206080 1 0 $X=208570 $Y=-211200
X45005 5 4 1127 4742 4854 7333 1144 FA_5VX1 $T=210120 8960 1 0 $X=209690 $Y=3840
X45006 5 4 4781 7329 4822 4893 4796 FA_5VX1 $T=217400 -241920 1 0 $X=216970 $Y=-247040
X45007 5 4 4772 7334 4903 7346 4795 FA_5VX1 $T=220200 -259840 1 0 $X=219770 $Y=-264960
X45008 5 4 4822 1109 4904 7349 4875 FA_5VX1 $T=220200 -250880 1 0 $X=219770 $Y=-256000
X45009 5 4 4826 4895 4911 4907 4880 FA_5VX1 $T=220200 -44800 0 0 $X=219770 $Y=-45440
X45010 5 4 4797 1504 4875 4849 4841 FA_5VX1 $T=221320 -232960 0 0 $X=220890 $Y=-233600
X45011 5 4 7967 4922 4882 4917 4855 FA_5VX1 $T=221880 -179200 1 0 $X=221450 $Y=-184320
X45012 5 4 4850 7341 7342 5022 4885 FA_5VX1 $T=221880 -152320 1 0 $X=221450 $Y=-157440
X45013 5 4 4834 7345 4916 4918 4869 FA_5VX1 $T=221880 -134400 0 0 $X=221450 $Y=-135040
X45014 5 4 4840 4899 7350 4977 4886 FA_5VX1 $T=221880 -17920 1 0 $X=221450 $Y=-23040
X45015 5 4 1135 7343 1160 7353 4804 FA_5VX1 $T=223560 -268800 0 0 $X=223130 $Y=-269440
X45016 5 4 4845 7336 4906 4926 4866 FA_5VX1 $T=223560 -53760 1 0 $X=223130 $Y=-58880
X45017 5 4 4849 4762 4927 4932 4928 FA_5VX1 $T=224680 -232960 1 0 $X=224250 $Y=-238080
X45018 5 4 7328 1523 4928 4894 4863 FA_5VX1 $T=225240 -224000 0 0 $X=224810 $Y=-224640
X45019 5 4 7354 4769 4867 4860 4917 FA_5VX1 $T=242040 -197120 1 180 $X=224810 $Y=-197760
X45020 5 4 7331 1515 4933 4937 4867 FA_5VX1 $T=225800 -215040 0 0 $X=225370 $Y=-215680
X45021 5 4 4814 7354 1168 4915 4813 FA_5VX1 $T=227480 -188160 0 0 $X=227050 $Y=-188800
X45022 5 4 4870 4901 4942 4945 4859 FA_5VX1 $T=227480 -98560 0 0 $X=227050 $Y=-99200
X45023 5 4 4882 1501 7359 1523 4929 FA_5VX1 $T=229160 -188160 1 0 $X=228730 $Y=-193280
X45024 5 4 4883 7348 4923 4961 4878 FA_5VX1 $T=230280 -107520 1 0 $X=229850 $Y=-112640
X45025 5 4 7336 1156 4888 4946 4907 FA_5VX1 $T=231400 -62720 0 0 $X=230970 $Y=-63360
X45026 5 4 4856 7344 7364 7365 4919 FA_5VX1 $T=231960 -125440 0 0 $X=231530 $Y=-126080
X45027 5 4 4852 4955 4902 4935 4873 FA_5VX1 $T=232520 -80640 0 0 $X=232090 $Y=-81280
X45028 5 4 4888 4956 4969 4980 4940 FA_5VX1 $T=232520 -62720 1 0 $X=232090 $Y=-67840
X45029 5 4 4894 4754 4981 4985 4908 FA_5VX1 $T=233640 -224000 1 0 $X=233210 $Y=-229120
X45030 5 4 4860 1504 5007 4921 4944 FA_5VX1 $T=233640 -206080 0 0 $X=233210 $Y=-206720
X45031 5 4 7342 7357 7363 1506 4909 FA_5VX1 $T=233640 -170240 1 0 $X=233210 $Y=-175360
X45032 5 4 4902 1157 4983 7367 4946 FA_5VX1 $T=233640 -80640 1 0 $X=233210 $Y=-85760
X45033 5 4 7340 7352 4992 4993 4881 FA_5VX1 $T=234200 -8960 0 0 $X=233770 $Y=-9600
X45034 5 4 7348 1161 4990 1173 4945 FA_5VX1 $T=235320 -98560 1 0 $X=234890 $Y=-103680
X45035 5 4 4906 1162 4991 1173 7362 FA_5VX1 $T=235320 -53760 0 0 $X=234890 $Y=-54400
X45036 5 4 4921 4966 4952 5001 7359 FA_5VX1 $T=236440 -215040 1 0 $X=236010 $Y=-220160
X45037 5 4 1501 4987 4965 5002 7363 FA_5VX1 $T=237000 -197120 1 0 $X=236570 $Y=-202240
X45038 5 4 4895 7362 5006 1193 4971 FA_5VX1 $T=237000 -44800 1 0 $X=236570 $Y=-49920
X45039 5 4 4911 1156 4940 1161 4963 FA_5VX1 $T=237000 -44800 0 0 $X=236570 $Y=-45440
X45040 5 4 4992 4975 1156 4973 4959 FA_5VX1 $T=237000 -35840 0 0 $X=236570 $Y=-36480
X45041 5 4 7371 4769 4925 7351 4954 FA_5VX1 $T=254360 -161280 0 180 $X=237130 $Y=-166400
X45042 5 4 4861 4951 7371 7370 4877 FA_5VX1 $T=238120 -143360 1 0 $X=237690 $Y=-148480
X45043 5 4 4923 7368 5012 1159 4887 FA_5VX1 $T=238120 -116480 1 0 $X=237690 $Y=-121600
X45044 5 4 7355 7361 7372 7378 4973 FA_5VX1 $T=238120 -89600 0 0 $X=237690 $Y=-90240
X45045 5 4 7350 7355 5009 1162 4976 FA_5VX1 $T=238120 -26880 0 0 $X=237690 $Y=-27520
X45046 5 4 7351 7369 4978 7373 4979 FA_5VX1 $T=238680 -179200 1 0 $X=238250 $Y=-184320
X45047 5 4 7352 1172 4976 1191 4941 FA_5VX1 $T=238680 0 1 0 $X=238250 $Y=-5120
X45048 5 4 4916 7366 4979 1168 4999 FA_5VX1 $T=239240 -152320 1 0 $X=238810 $Y=-157440
X45049 5 4 4890 5018 7374 4971 4912 FA_5VX1 $T=239240 -26880 1 0 $X=238810 $Y=-32000
X45050 5 4 4924 7356 5015 1193 1183 FA_5VX1 $T=239240 -8960 1 0 $X=238810 $Y=-14080
X45051 5 4 4846 4950 4924 4941 4896 FA_5VX1 $T=257720 0 1 180 $X=240490 $Y=-640
X45052 5 4 7356 5010 4962 8002 4997 FA_5VX1 $T=241480 -17920 1 0 $X=241050 $Y=-23040
X45053 5 4 7357 5011 4989 7381 4925 FA_5VX1 $T=242600 -179200 0 0 $X=242170 $Y=-179840
X45054 5 4 4950 1176 4959 1172 1187 FA_5VX1 $T=244280 8960 1 0 $X=243850 $Y=3840
X45055 5 4 1178 1181 5005 4964 1188 FA_5VX1 $T=244280 8960 0 0 $X=243850 $Y=8320
X45056 5 4 7364 4967 5024 1165 4990 FA_5VX1 $T=245960 -143360 0 0 $X=245530 $Y=-144000
X45057 5 4 4967 5008 5030 5036 5012 FA_5VX1 $T=247640 -152320 0 0 $X=247210 $Y=-152960
X45058 5 4 7366 5028 4994 7387 5024 FA_5VX1 $T=248760 -161280 0 0 $X=248330 $Y=-161920
X45059 5 4 7349 1171 7388 5049 4927 FA_5VX1 $T=250440 -250880 1 0 $X=250010 $Y=-256000
X45060 5 4 4903 5037 1199 1123 4905 FA_5VX1 $T=251000 -259840 0 0 $X=250570 $Y=-260480
X45061 5 4 1184 1186 5042 4997 1197 FA_5VX1 $T=251000 -8960 0 0 $X=250570 $Y=-9600
X45062 5 4 7368 5039 5026 5062 5031 FA_5VX1 $T=252120 -116480 0 0 $X=251690 $Y=-117120
X45063 5 4 4985 4960 7389 5054 4933 FA_5VX1 $T=252680 -224000 0 0 $X=252250 $Y=-224640
X45064 5 4 4942 5046 5031 1170 5033 FA_5VX1 $T=252680 -98560 1 0 $X=252250 $Y=-103680
X45065 5 4 5049 1180 1195 1192 5016 FA_5VX1 $T=270600 -250880 1 180 $X=253370 $Y=-251520
X45066 5 4 4932 4948 5016 7377 4981 FA_5VX1 $T=270600 -241920 1 180 $X=253370 $Y=-242560
X45067 5 4 4937 4953 5045 5066 5007 FA_5VX1 $T=253800 -215040 0 0 $X=253370 $Y=-215680
X45068 5 4 7375 7391 5038 5065 5009 FA_5VX1 $T=253800 -35840 1 0 $X=253370 $Y=-40960
X45069 5 4 5037 1189 1194 7376 4904 FA_5VX1 $T=271160 -268800 1 180 $X=253930 $Y=-269440
X45070 5 4 7374 7375 1154 7392 5048 FA_5VX1 $T=254360 -35840 0 0 $X=253930 $Y=-36480
X45071 5 4 5062 1523 4754 1504 5032 FA_5VX1 $T=271720 -116480 0 180 $X=254490 $Y=-121600
X45072 5 4 4975 5053 5025 5153 5015 FA_5VX1 $T=254920 -26880 0 0 $X=254490 $Y=-27520
X45073 5 4 7376 1192 1211 1210 7388 FA_5VX1 $T=255480 -259840 1 0 $X=255050 $Y=-264960
X45074 5 4 7377 1119 1210 1180 7389 FA_5VX1 $T=256040 -232960 1 0 $X=255610 $Y=-238080
X45075 5 4 7367 5000 7395 5076 4991 FA_5VX1 $T=256040 -80640 1 0 $X=255610 $Y=-85760
X45076 5 4 5054 1117 1192 1119 5045 FA_5VX1 $T=274520 -232960 1 180 $X=257290 $Y=-233600
X45077 5 4 5006 4984 5077 7406 7392 FA_5VX1 $T=259400 -62720 0 0 $X=258970 $Y=-63360
X45078 5 4 5046 5020 5032 7384 4983 FA_5VX1 $T=276760 -98560 1 180 $X=259530 $Y=-99200
X45079 5 4 4980 1168 1523 4769 5077 FA_5VX1 $T=261640 -53760 1 0 $X=261210 $Y=-58880
X45080 5 4 7384 1506 1515 1523 7395 FA_5VX1 $T=262760 -89600 1 0 $X=262330 $Y=-94720
X45081 5 4 5063 1212 1223 7427 5097 FA_5VX1 $T=268360 -268800 1 0 $X=267930 $Y=-273920
X45082 5 4 5064 5156 7426 1225 5118 FA_5VX1 $T=268920 -250880 1 0 $X=268490 $Y=-256000
X45083 5 4 7434 5108 1210 1180 5114 FA_5VX1 $T=286840 -224000 1 180 $X=269610 $Y=-224640
X45084 5 4 7429 1215 1211 1210 5098 FA_5VX1 $T=287400 -250880 1 180 $X=270170 $Y=-251520
X45085 5 4 5073 7424 5169 5176 7417 FA_5VX1 $T=270600 -35840 1 0 $X=270170 $Y=-40960
X45086 5 4 5079 5122 5173 5152 5143 FA_5VX1 $T=271720 -215040 0 0 $X=271290 $Y=-215680
X45087 5 4 5197 7431 5098 7397 5135 FA_5VX1 $T=289640 -241920 1 180 $X=272410 $Y=-242560
X45088 5 4 7397 1216 1195 1192 5151 FA_5VX1 $T=273400 -232960 1 0 $X=272970 $Y=-238080
X45089 5 4 5100 7432 5168 5141 7424 FA_5VX1 $T=273960 -53760 0 0 $X=273530 $Y=-54400
X45090 5 4 5112 5191 5194 5183 5168 FA_5VX1 $T=276200 -62720 0 0 $X=275770 $Y=-63360
X45091 5 4 5090 7417 5132 5244 7430 FA_5VX1 $T=276200 -26880 1 0 $X=275770 $Y=-32000
X45092 5 4 5130 5192 5199 8099 5149 FA_5VX1 $T=276760 -143360 1 0 $X=276330 $Y=-148480
X45093 5 4 7407 7437 5200 5126 5177 FA_5VX1 $T=276760 0 1 0 $X=276330 $Y=-5120
X45094 5 4 7412 7430 5188 7442 7435 FA_5VX1 $T=278440 -17920 1 0 $X=278010 $Y=-23040
X45095 5 4 5132 7440 5170 7444 5188 FA_5VX1 $T=279000 -35840 0 0 $X=278570 $Y=-36480
X45096 5 4 5126 5191 5209 5195 5190 FA_5VX1 $T=279560 -8960 1 0 $X=279130 $Y=-14080
X45097 5 4 7421 7435 5234 7448 7437 FA_5VX1 $T=280120 -17920 0 0 $X=279690 $Y=-18560
X45098 5 4 5131 5170 5218 5205 5150 FA_5VX1 $T=280680 -89600 1 0 $X=280250 $Y=-94720
X45099 5 4 7422 5204 5220 7450 5174 FA_5VX1 $T=281240 -125440 0 0 $X=280810 $Y=-126080
X45100 5 4 5141 1228 7447 5223 5169 FA_5VX1 $T=281240 -44800 0 0 $X=280810 $Y=-45440
X45101 5 4 5152 5193 1180 1117 5198 FA_5VX1 $T=282360 -206080 1 0 $X=281930 $Y=-211200
X45102 5 4 5189 5156 1192 1119 5173 FA_5VX1 $T=300280 -232960 1 180 $X=283050 $Y=-233600
X45103 5 4 5128 5206 5203 5232 5144 FA_5VX1 $T=283480 -179200 0 0 $X=283050 $Y=-179840
X45104 5 4 5219 5142 5161 7429 5196 FA_5VX1 $T=301400 -241920 0 180 $X=284170 $Y=-247040
X45105 5 4 7454 1231 1229 1211 5185 FA_5VX1 $T=301960 -268800 0 180 $X=284730 $Y=-273920
X45106 5 4 7409 7446 5198 5240 5147 FA_5VX1 $T=285160 -206080 0 0 $X=284730 $Y=-206720
X45107 5 4 7456 5142 1117 1123 5203 FA_5VX1 $T=301960 -197120 1 180 $X=284730 $Y=-197760
X45108 5 4 7428 5193 1241 7454 5207 FA_5VX1 $T=285720 -268800 0 0 $X=285290 $Y=-269440
X45109 5 4 5127 5228 7452 7456 5124 FA_5VX1 $T=285720 -188160 1 0 $X=285290 $Y=-193280
X45110 5 4 5232 7431 1133 1109 5208 FA_5VX1 $T=302520 -179200 0 180 $X=285290 $Y=-184320
X45111 5 4 5119 5229 5215 7457 5148 FA_5VX1 $T=285720 -161280 0 0 $X=285290 $Y=-161920
X45112 5 4 5216 5238 5185 7433 7441 FA_5VX1 $T=303080 -259840 1 180 $X=285850 $Y=-260480
X45113 5 4 5222 5202 5151 7434 7443 FA_5VX1 $T=303080 -224000 0 180 $X=285850 $Y=-229120
X45114 5 4 7457 5225 1109 4754 5199 FA_5VX1 $T=303080 -152320 0 180 $X=285850 $Y=-157440
X45115 5 4 7433 5231 1239 1195 5161 FA_5VX1 $T=286840 -250880 1 0 $X=286410 $Y=-256000
X45116 5 4 5154 1235 7455 5243 5180 FA_5VX1 $T=286840 -80640 1 0 $X=286410 $Y=-85760
X45117 5 4 7460 5202 1123 4762 5215 FA_5VX1 $T=304200 -170240 0 180 $X=286970 $Y=-175360
X45118 5 4 5103 5233 5208 7460 5137 FA_5VX1 $T=287400 -170240 0 0 $X=286970 $Y=-170880
X45119 5 4 5210 5225 5114 5189 5165 FA_5VX1 $T=304760 -215040 0 180 $X=287530 $Y=-220160
X45120 5 4 5146 5213 7459 5250 5186 FA_5VX1 $T=287960 -134400 1 0 $X=287530 $Y=-139520
X45121 5 4 7461 5213 1168 1159 5194 FA_5VX1 $T=304760 -62720 0 180 $X=287530 $Y=-67840
X45122 5 4 5139 5246 5236 5261 5187 FA_5VX1 $T=290200 -98560 0 0 $X=289770 $Y=-99200
X45123 5 4 5243 5192 4769 1165 5227 FA_5VX1 $T=307560 -80640 1 180 $X=290330 $Y=-81280
X45124 5 4 5167 1236 7461 5227 5155 FA_5VX1 $T=290760 -71680 0 0 $X=290330 $Y=-72320
X45125 5 4 5195 1156 5242 1161 5224 FA_5VX1 $T=290760 -8960 0 0 $X=290330 $Y=-9600
X45126 5 4 5163 5242 7466 7469 5179 FA_5VX1 $T=291320 -116480 1 0 $X=290890 $Y=-121600
X45127 5 4 5240 5238 1119 1133 7452 FA_5VX1 $T=308680 -197120 0 180 $X=291450 $Y=-202240
X45128 5 4 5205 5229 1506 1168 7455 FA_5VX1 $T=291880 -89600 0 0 $X=291450 $Y=-90240
X45129 5 4 7469 5206 1504 1506 5236 FA_5VX1 $T=309240 -116480 1 180 $X=292010 $Y=-117120
X45130 5 4 5250 7446 4754 1504 5220 FA_5VX1 $T=309800 -134400 1 180 $X=292570 $Y=-135040
X45131 5 4 5176 1238 7973 8100 5244 FA_5VX1 $T=293000 -26880 1 0 $X=292570 $Y=-32000
X45132 5 4 8099 5122 4762 1515 7459 FA_5VX1 $T=293560 -143360 1 0 $X=293130 $Y=-148480
X45133 5 4 5261 5233 1523 4769 5218 FA_5VX1 $T=310360 -107520 1 180 $X=293130 $Y=-108160
X45134 5 4 7442 1235 7473 7476 5234 FA_5VX1 $T=294120 -26880 0 0 $X=293690 $Y=-27520
X45135 5 4 5172 1228 5224 7445 1240 FA_5VX1 $T=311480 0 0 180 $X=294250 $Y=-5120
X45136 5 4 7445 1193 1154 5246 1247 FA_5VX1 $T=294680 8960 1 0 $X=294250 $Y=3840
X45137 5 4 7448 7468 5262 1236 5200 FA_5VX1 $T=296360 -8960 1 0 $X=295930 $Y=-14080
X45138 5 4 7450 5228 1515 1523 7466 FA_5VX1 $T=298040 -125440 0 0 $X=297610 $Y=-126080
X45139 5 4 5239 1523 7483 5306 7475 FA_5VX1 $T=300280 -107520 1 0 $X=299850 $Y=-112640
X45140 5 4 5241 1123 5288 7490 5283 FA_5VX1 $T=300840 -232960 0 0 $X=300410 $Y=-233600
X45141 5 4 7493 1249 1246 1133 5273 FA_5VX1 $T=318760 -259840 0 180 $X=301530 $Y=-264960
X45142 5 4 7491 7462 5251 1133 5274 FA_5VX1 $T=318760 -241920 1 180 $X=301530 $Y=-242560
X45143 5 4 5296 1133 5249 7458 5305 FA_5VX1 $T=319320 -206080 1 180 $X=302090 $Y=-206720
X45144 5 4 5311 1248 1244 1123 5282 FA_5VX1 $T=319880 -268800 1 180 $X=302650 $Y=-269440
X45145 5 4 7462 1180 7481 7486 5288 FA_5VX1 $T=303080 -241920 1 0 $X=302650 $Y=-247040
X45146 5 4 7490 1119 5255 5252 5275 FA_5VX1 $T=319880 -224000 0 180 $X=302650 $Y=-229120
X45147 5 4 5302 1123 5260 5253 7477 FA_5VX1 $T=319880 -188160 0 180 $X=302650 $Y=-193280
X45148 5 4 1243 1192 1259 1261 5251 FA_5VX1 $T=303640 -268800 1 0 $X=303210 $Y=-273920
X45149 5 4 5301 1117 5258 7465 5286 FA_5VX1 $T=321560 -215040 0 180 $X=304330 $Y=-220160
X45150 5 4 7497 1504 5265 7464 5287 FA_5VX1 $T=321560 -152320 1 180 $X=304330 $Y=-152960
X45151 5 4 5276 1506 7467 5259 5280 FA_5VX1 $T=321560 -80640 0 180 $X=304330 $Y=-85760
X45152 5 4 7502 1515 5269 7471 5293 FA_5VX1 $T=323240 -134400 0 180 $X=306010 $Y=-139520
X45153 5 4 5325 1165 5268 5267 5291 FA_5VX1 $T=323240 -17920 1 180 $X=306010 $Y=-18560
X45154 5 4 5326 1109 5264 7472 5265 FA_5VX1 $T=323800 -179200 0 180 $X=306570 $Y=-184320
X45155 5 4 7511 1159 5280 5271 5300 FA_5VX1 $T=324360 -62720 1 180 $X=307130 $Y=-63360
X45156 5 4 5329 1156 7474 5272 1255 FA_5VX1 $T=324360 -8960 1 180 $X=307130 $Y=-9600
X45157 5 4 5327 1168 5279 5239 5289 FA_5VX1 $T=324920 -98560 0 180 $X=307690 $Y=-103680
X45158 5 4 7506 1165 7475 5276 5294 FA_5VX1 $T=324920 -80640 1 180 $X=307690 $Y=-81280
X45159 5 4 5277 7498 7506 1154 5312 FA_5VX1 $T=309800 -71680 0 0 $X=309370 $Y=-72320
X45160 5 4 5345 1168 5308 5285 5304 FA_5VX1 $T=327160 -44800 1 180 $X=309930 $Y=-45440
X45161 5 4 7515 1515 7477 5326 7487 FA_5VX1 $T=328280 -179200 1 180 $X=311050 $Y=-179840
X45162 5 4 1253 1170 5323 1509 1264 FA_5VX1 $T=312040 8960 0 0 $X=311610 $Y=8320
X45163 5 4 7518 4762 5286 5296 5316 FA_5VX1 $T=329960 -206080 0 180 $X=312730 $Y=-211200
X45164 5 4 5333 1157 5304 5325 5272 FA_5VX1 $T=329960 -8960 0 180 $X=312730 $Y=-14080
X45165 5 4 5292 1515 5321 7518 5324 FA_5VX1 $T=314280 -197120 1 0 $X=313850 $Y=-202240
X45166 5 4 7521 4754 5305 5302 7492 FA_5VX1 $T=331080 -197120 1 180 $X=313850 $Y=-197760
X45167 5 4 5358 1109 5275 5301 5321 FA_5VX1 $T=331640 -215040 1 180 $X=314410 $Y=-215680
X45168 5 4 5303 1504 7484 7480 5279 FA_5VX1 $T=331640 -125440 1 180 $X=314410 $Y=-126080
X45169 5 4 7519 4769 5293 5303 5322 FA_5VX1 $T=331640 -116480 0 180 $X=314410 $Y=-121600
X45170 5 4 5375 7497 7487 1506 5331 FA_5VX1 $T=334440 -152320 0 180 $X=317210 $Y=-157440
X45171 5 4 7529 7515 7492 1523 7501 FA_5VX1 $T=335000 -170240 0 180 $X=317770 $Y=-175360
X45172 5 4 5386 4762 5274 5241 5343 FA_5VX1 $T=335560 -232960 0 180 $X=318330 $Y=-238080
X45173 5 4 7527 7502 5317 1506 7510 FA_5VX1 $T=335560 -134400 1 180 $X=318330 $Y=-135040
X45174 5 4 5377 5313 5311 5314 5414 FA_5VX1 $T=336120 -259840 1 180 $X=318890 $Y=-260480
X45175 5 4 8101 1109 1262 7491 5338 FA_5VX1 $T=336680 -241920 0 180 $X=319450 $Y=-247040
X45176 5 4 8102 7504 1268 1263 5341 FA_5VX1 $T=337240 -268800 0 180 $X=320010 $Y=-273920
X45177 5 4 5390 5373 7493 5320 5342 FA_5VX1 $T=337240 -259840 0 180 $X=320010 $Y=-264960
X45178 5 4 5313 1515 5273 4762 5351 FA_5VX1 $T=320440 -250880 0 0 $X=320010 $Y=-251520
X45179 5 4 7526 1523 7499 7495 7517 FA_5VX1 $T=337800 -161280 1 180 $X=320570 $Y=-161920
X45180 5 4 5401 7526 5287 4769 5348 FA_5VX1 $T=338360 -143360 0 180 $X=321130 $Y=-148480
X45181 5 4 7535 1504 5282 4754 5383 FA_5VX1 $T=338920 -232960 1 180 $X=321690 $Y=-233600
X45182 5 4 7532 1193 5333 7485 5335 FA_5VX1 $T=338920 0 0 180 $X=321690 $Y=-5120
X45183 5 4 7533 5358 5283 4754 7520 FA_5VX1 $T=339480 -224000 1 180 $X=322250 $Y=-224640
X45184 5 4 5371 7519 7510 1165 5337 FA_5VX1 $T=340600 -107520 0 180 $X=323370 $Y=-112640
X45185 5 4 7530 1186 5336 1267 1274 FA_5VX1 $T=340600 0 1 180 $X=323370 $Y=-640
X45186 5 4 7540 7527 7517 1168 5349 FA_5VX1 $T=341160 -125440 0 180 $X=323930 $Y=-130560
X45187 5 4 5417 7534 7508 5312 5364 FA_5VX1 $T=341160 -62720 1 180 $X=323930 $Y=-63360
X45188 5 4 7534 1162 7511 5334 5365 FA_5VX1 $T=341160 -53760 0 180 $X=323930 $Y=-58880
X45189 5 4 5413 7530 5329 5335 1275 FA_5VX1 $T=341160 -8960 1 180 $X=323930 $Y=-9600
X45190 5 4 5389 5347 5412 1156 5382 FA_5VX1 $T=326040 -35840 0 0 $X=325610 $Y=-36480
X45191 5 4 5404 5389 5340 5365 5376 FA_5VX1 $T=343960 -44800 1 180 $X=326730 $Y=-45440
X45192 5 4 7538 7532 5357 5382 5387 FA_5VX1 $T=345640 -17920 0 180 $X=328410 $Y=-23040
X45193 5 4 5412 1170 5360 5345 1277 FA_5VX1 $T=346200 -35840 0 180 $X=328970 $Y=-40960
X45194 5 4 7546 1506 5343 1504 5361 FA_5VX1 $T=346760 -206080 0 180 $X=329530 $Y=-211200
X45195 5 4 5452 5354 7520 5361 5395 FA_5VX1 $T=347880 -206080 1 180 $X=330650 $Y=-206720
X45196 5 4 5400 7521 5316 1504 5374 FA_5VX1 $T=347880 -197120 1 180 $X=330650 $Y=-197760
X45197 5 4 5403 5277 5368 7522 5399 FA_5VX1 $T=347880 -71680 1 180 $X=330650 $Y=-72320
X45198 5 4 7549 5362 5348 5366 5402 FA_5VX1 $T=348440 -125440 1 180 $X=331210 $Y=-126080
X45199 5 4 5362 1157 1159 7540 5367 FA_5VX1 $T=331640 -116480 1 0 $X=331210 $Y=-121600
X45200 5 4 7541 7528 5371 5367 5407 FA_5VX1 $T=348440 -107520 1 180 $X=331210 $Y=-108160
X45201 5 4 7556 1168 5324 1506 7531 FA_5VX1 $T=349000 -188160 0 180 $X=331770 $Y=-193280
X45202 5 4 7557 1165 5374 4769 5384 FA_5VX1 $T=349000 -170240 1 180 $X=331770 $Y=-170880
X45203 5 4 7548 1170 5331 1165 5366 FA_5VX1 $T=349000 -134400 0 180 $X=331770 $Y=-139520
X45204 5 4 6058 5420 5431 7551 1281 FA_5VX1 $T=332200 8960 1 0 $X=331770 $Y=3840
X45205 5 4 5427 5363 5381 7523 5419 FA_5VX1 $T=349560 -89600 1 180 $X=332330 $Y=-90240
X45206 5 4 5381 5327 5322 1159 5368 FA_5VX1 $T=350120 -98560 1 180 $X=332890 $Y=-99200
X45207 5 4 5429 7548 5401 5332 7536 FA_5VX1 $T=350680 -143360 1 180 $X=333450 $Y=-144000
X45208 5 4 5396 5379 5375 5384 5411 FA_5VX1 $T=351240 -152320 0 180 $X=334010 $Y=-157440
X45209 5 4 5451 5438 1523 5383 5370 FA_5VX1 $T=351800 -224000 0 180 $X=334570 $Y=-229120
X45210 5 4 5438 5386 5338 1515 7537 FA_5VX1 $T=352920 -232960 0 180 $X=335690 $Y=-238080
X45211 5 4 5421 7535 8101 5351 5415 FA_5VX1 $T=353480 -241920 0 180 $X=336250 $Y=-247040
X45212 5 4 5442 7556 5400 5392 5405 FA_5VX1 $T=353480 -188160 1 180 $X=336250 $Y=-188800
X45213 5 4 1294 1285 1282 8102 7539 FA_5VX1 $T=354040 -268800 0 180 $X=336810 $Y=-273920
X45214 5 4 5426 7557 7529 7531 5422 FA_5VX1 $T=354600 -170240 0 180 $X=337370 $Y=-175360
X45215 5 4 5435 7546 7533 7537 7554 FA_5VX1 $T=357960 -215040 0 180 $X=340730 $Y=-220160
X45216 5 4 6047 7565 5453 7574 5420 FA_5VX1 $T=341720 -17920 0 0 $X=341290 $Y=-18560
X45217 5 4 5423 5448 5461 5475 7565 FA_5VX1 $T=343960 -44800 0 0 $X=343530 $Y=-45440
X45218 5 4 5425 7569 7578 7580 5448 FA_5VX1 $T=344520 -53760 1 0 $X=344090 $Y=-58880
X45219 5 4 5987 7573 5474 7593 7569 FA_5VX1 $T=347320 -71680 1 0 $X=346890 $Y=-76800
X45220 5 4 1287 5489 7587 1306 7571 FA_5VX1 $T=347880 -259840 1 0 $X=347450 $Y=-264960
X45221 5 4 5440 7579 5506 5500 7573 FA_5VX1 $T=347880 -80640 1 0 $X=347450 $Y=-85760
X45222 5 4 5439 5482 5473 7592 7577 FA_5VX1 $T=348440 -116480 1 0 $X=348010 $Y=-121600
X45223 5 4 1289 7585 5469 5498 5482 FA_5VX1 $T=349000 -143360 1 0 $X=348570 $Y=-148480
X45224 5 4 5447 7577 5515 7597 7579 FA_5VX1 $T=349560 -107520 0 0 $X=349130 $Y=-108160
X45225 5 4 1292 5493 5530 7602 7581 FA_5VX1 $T=350120 -188160 1 0 $X=349690 $Y=-193280
X45226 5 4 1296 7589 5497 5505 7585 FA_5VX1 $T=351800 -152320 1 0 $X=351370 $Y=-157440
X45227 5 4 5457 7571 5503 5522 5496 FA_5VX1 $T=352360 -250880 1 0 $X=351930 $Y=-256000
X45228 5 4 4706 5496 5491 5535 7583 FA_5VX1 $T=352360 -241920 0 0 $X=351930 $Y=-242560
X45229 5 4 1299 7583 7607 5526 7584 FA_5VX1 $T=353480 -232960 0 0 $X=353050 $Y=-233600
X45230 5 4 1293 7581 5537 7606 7589 FA_5VX1 $T=353480 -179200 0 0 $X=353050 $Y=-179840
X45231 5 4 1301 7584 5492 7609 5493 FA_5VX1 $T=354600 -206080 0 0 $X=354170 $Y=-206720
X45232 5 4 5544 7614 5624 7646 5528 FA_5VX1 $T=369160 -8960 0 0 $X=368730 $Y=-9600
X45233 5 4 7614 7623 5629 7643 1320 FA_5VX1 $T=371400 8960 1 0 $X=370970 $Y=3840
X45234 5 4 5634 7672 7979 7681 7670 FA_5VX1 $T=401640 -188160 0 0 $X=401210 $Y=-188800
X45235 5 4 5636 7665 5693 5699 5662 FA_5VX1 $T=401640 -107520 0 0 $X=401210 $Y=-108160
X45236 5 4 5637 7664 7679 1512 5664 FA_5VX1 $T=401640 -53760 1 0 $X=401210 $Y=-58880
X45237 5 4 5615 7656 5682 1332 5628 FA_5VX1 $T=401640 -26880 0 0 $X=401210 $Y=-27520
X45238 5 4 7643 1156 5696 1154 1329 FA_5VX1 $T=401640 0 0 0 $X=401210 $Y=-640
X45239 5 4 7646 1193 1331 5672 1328 FA_5VX1 $T=401640 8960 0 0 $X=401210 $Y=8320
X45240 5 4 5640 7663 5675 7680 5641 FA_5VX1 $T=402200 -206080 0 0 $X=401770 $Y=-206720
X45241 5 4 7651 7667 5687 5686 5666 FA_5VX1 $T=402760 -125440 0 0 $X=402330 $Y=-126080
X45242 5 4 5646 5655 5654 7655 5627 FA_5VX1 $T=419560 -35840 0 180 $X=402330 $Y=-40960
X45243 5 4 5690 1327 5656 7654 5624 FA_5VX1 $T=419560 -8960 1 180 $X=402330 $Y=-9600
X45244 5 4 5655 7678 5701 7682 5682 FA_5VX1 $T=403320 -35840 0 0 $X=402890 $Y=-36480
X45245 5 4 5585 5690 1334 5684 5623 FA_5VX1 $T=403320 -8960 1 0 $X=402890 $Y=-14080
X45246 5 4 7654 1161 5702 1335 5629 FA_5VX1 $T=403320 0 1 0 $X=402890 $Y=-5120
X45247 5 4 5639 7675 5673 1336 5648 FA_5VX1 $T=403880 -259840 0 0 $X=403450 $Y=-260480
X45248 5 4 7659 7677 5685 7686 5642 FA_5VX1 $T=404440 -170240 1 0 $X=404010 $Y=-175360
X45249 5 4 7657 5697 5692 7683 5643 FA_5VX1 $T=404440 -143360 1 0 $X=404010 $Y=-148480
X45250 5 4 7656 5695 5704 7685 5684 FA_5VX1 $T=404440 -17920 0 0 $X=404010 $Y=-18560
X45251 5 4 7658 7671 5715 5703 5676 FA_5VX1 $T=405000 -89600 0 0 $X=404570 $Y=-90240
X45252 5 4 7661 7674 7687 7695 5663 FA_5VX1 $T=406120 -71680 1 0 $X=405690 $Y=-76800
X45253 5 4 7662 7676 5680 5740 5674 FA_5VX1 $T=406680 -232960 1 0 $X=406250 $Y=-238080
X45254 5 4 5670 1504 5698 5720 7680 FA_5VX1 $T=407240 -215040 1 0 $X=406810 $Y=-220160
X45255 5 4 7663 5706 5716 1523 7681 FA_5VX1 $T=407240 -197120 0 0 $X=406810 $Y=-197760
X45256 5 4 5697 1165 7666 5668 5686 FA_5VX1 $T=424040 -134400 1 180 $X=406810 $Y=-135040
X45257 5 4 7664 5708 5717 5723 5654 FA_5VX1 $T=407240 -53760 0 0 $X=406810 $Y=-54400
X45258 5 4 7660 5705 5719 7689 5645 FA_5VX1 $T=407800 -241920 1 0 $X=407370 $Y=-247040
X45259 5 4 5660 7673 7669 5671 5661 FA_5VX1 $T=424600 -161280 0 180 $X=407370 $Y=-166400
X45260 5 4 5672 1157 5727 1173 1333 FA_5VX1 $T=408360 8960 1 0 $X=407930 $Y=3840
X45261 5 4 5673 1109 7699 1343 5709 FA_5VX1 $T=408920 -259840 1 0 $X=408490 $Y=-264960
X45262 5 4 5658 5670 7690 5712 5659 FA_5VX1 $T=408920 -224000 0 0 $X=408490 $Y=-224640
X45263 5 4 7695 5722 5678 1173 7679 FA_5VX1 $T=425720 -62720 0 180 $X=408490 $Y=-67840
X45264 5 4 7669 4769 1523 7693 5668 FA_5VX1 $T=409480 -161280 0 0 $X=409050 $Y=-161920
X45265 5 4 7673 1168 7691 5735 7683 FA_5VX1 $T=409480 -152320 0 0 $X=409050 $Y=-152960
X45266 5 4 7665 1170 5688 5721 5703 FA_5VX1 $T=409480 -89600 1 0 $X=409050 $Y=-94720
X45267 5 4 5680 4754 5760 1109 5720 FA_5VX1 $T=410600 -232960 0 0 $X=410170 $Y=-233600
X45268 5 4 5675 1504 5700 7697 5710 FA_5VX1 $T=410600 -206080 1 0 $X=410170 $Y=-211200
X45269 5 4 7667 1159 5683 5732 5699 FA_5VX1 $T=410600 -116480 0 0 $X=410170 $Y=-117120
X45270 5 4 5693 1159 8103 5725 5707 FA_5VX1 $T=410600 -98560 1 0 $X=410170 $Y=-103680
X45271 5 4 7666 1506 7694 5742 5714 FA_5VX1 $T=411160 -125440 1 0 $X=410730 $Y=-130560
X45272 5 4 7671 1157 7701 5707 7687 FA_5VX1 $T=411720 -80640 0 0 $X=411290 $Y=-81280
X45273 5 4 7672 5734 5710 1506 7686 FA_5VX1 $T=412280 -179200 0 0 $X=411850 $Y=-179840
X45274 5 4 1330 5736 1346 1123 1341 FA_5VX1 $T=413960 -268800 0 0 $X=413530 $Y=-269440
X45275 5 4 7675 4762 5731 1347 7689 FA_5VX1 $T=413960 -250880 1 0 $X=413530 $Y=-256000
X45276 5 4 7676 1515 5733 5751 7690 FA_5VX1 $T=413960 -224000 1 0 $X=413530 $Y=-229120
X45277 5 4 7677 7696 5689 4769 5671 FA_5VX1 $T=413960 -170240 0 0 $X=413530 $Y=-170880
X45278 5 4 5685 1506 7700 5752 5735 FA_5VX1 $T=413960 -152320 1 0 $X=413530 $Y=-157440
X45279 5 4 5687 1165 5729 5714 5721 FA_5VX1 $T=413960 -116480 1 0 $X=413530 $Y=-121600
X45280 5 4 5683 4769 5750 7703 5725 FA_5VX1 $T=413960 -107520 1 0 $X=413530 $Y=-112640
X45281 5 4 5688 1168 5757 7698 5726 FA_5VX1 $T=413960 -98560 0 0 $X=413530 $Y=-99200
X45282 5 4 7674 1157 7716 5753 5708 FA_5VX1 $T=413960 -71680 0 0 $X=413530 $Y=-72320
X45283 5 4 5723 1170 5737 5797 5701 FA_5VX1 $T=413960 -44800 1 0 $X=413530 $Y=-49920
X45284 5 4 5689 1504 7702 5754 7693 FA_5VX1 $T=414520 -179200 1 0 $X=414090 $Y=-184320
X45285 5 4 5692 1168 5728 5755 5732 FA_5VX1 $T=414520 -134400 1 0 $X=414090 $Y=-139520
X45286 5 4 5678 1159 7980 5780 5717 FA_5VX1 $T=414520 -62720 0 0 $X=414090 $Y=-63360
X45287 5 4 5715 1170 1165 5726 5722 FA_5VX1 $T=415080 -80640 1 0 $X=414650 $Y=-85760
X45288 5 4 7979 1523 1514 7704 7696 FA_5VX1 $T=416200 -188160 1 0 $X=415770 $Y=-193280
X45289 5 4 7682 1157 5724 7705 5704 FA_5VX1 $T=416760 -26880 1 0 $X=416330 $Y=-32000
X45290 5 4 5719 4762 5738 7706 5751 FA_5VX1 $T=417320 -241920 0 0 $X=416890 $Y=-242560
X45291 5 4 5698 4762 5766 7708 7697 FA_5VX1 $T=417320 -215040 0 0 $X=416890 $Y=-215680
X45292 5 4 5705 4754 5711 5709 5740 FA_5VX1 $T=436360 -250880 1 180 $X=419130 $Y=-251520
X45293 5 4 7685 1173 5745 7710 5656 FA_5VX1 $T=419560 -8960 0 0 $X=419130 $Y=-9600
X45294 5 4 5712 1515 7714 7711 5706 FA_5VX1 $T=420120 -206080 0 0 $X=419690 $Y=-206720
X45295 5 4 5702 1165 5785 5781 5727 FA_5VX1 $T=421800 -8960 1 0 $X=421370 $Y=-14080
X45296 5 4 5731 1133 5790 1357 7706 FA_5VX1 $T=423480 -259840 0 0 $X=423050 $Y=-260480
X45297 5 4 5733 5792 5801 7723 7711 FA_5VX1 $T=425720 -224000 0 0 $X=425290 $Y=-224640
X45298 5 4 5711 1123 8104 7725 5760 FA_5VX1 $T=426280 -241920 1 0 $X=425850 $Y=-247040
X45299 5 4 7691 7721 7724 5796 5755 FA_5VX1 $T=426840 -143360 1 0 $X=426410 $Y=-148480
X45300 5 4 7701 5808 5798 5818 5753 FA_5VX1 $T=430200 -80640 0 0 $X=429770 $Y=-81280
X45301 5 4 5734 1515 4762 7735 5752 FA_5VX1 $T=430760 -170240 0 0 $X=430330 $Y=-170880
X45302 5 4 1514 1109 5821 5837 5754 FA_5VX1 $T=433000 -197120 0 0 $X=432570 $Y=-197760
X45303 5 4 5716 4754 5778 5838 7704 FA_5VX1 $T=433000 -188160 1 0 $X=432570 $Y=-193280
X45304 5 4 5778 1117 1371 5817 5821 FA_5VX1 $T=435800 -197120 1 0 $X=435370 $Y=-202240
X45305 5 4 7713 1123 7746 5841 5823 FA_5VX1 $T=436360 -241920 0 0 $X=435930 $Y=-242560
X45306 5 4 5896 1170 5825 7729 1374 FA_5VX1 $T=461000 -17920 1 180 $X=443770 $Y=-18560
X45307 5 4 5908 1504 7737 5833 5842 FA_5VX1 $T=462680 -107520 1 180 $X=445450 $Y=-108160
X45308 5 4 5910 5895 7743 1168 5869 FA_5VX1 $T=463240 -44800 1 180 $X=446010 $Y=-45440
X45309 5 4 5916 5850 5842 1506 5856 FA_5VX1 $T=463800 -80640 0 180 $X=446570 $Y=-85760
X45310 5 4 1369 7762 5896 5898 1380 FA_5VX1 $T=447560 8960 0 0 $X=447130 $Y=8320
X45311 5 4 5907 5791 5823 5847 7758 FA_5VX1 $T=466040 -232960 1 180 $X=448810 $Y=-233600
X45312 5 4 5876 4754 7774 1109 5854 FA_5VX1 $T=449800 -188160 1 0 $X=449370 $Y=-193280
X45313 5 4 5847 1109 7780 5899 5861 FA_5VX1 $T=452040 -224000 0 0 $X=451610 $Y=-224640
X45314 5 4 5937 7758 5861 7753 5865 FA_5VX1 $T=468840 -215040 1 180 $X=451610 $Y=-215680
X45315 5 4 5855 1504 7777 5900 5901 FA_5VX1 $T=452040 -152320 1 0 $X=451610 $Y=-157440
X45316 5 4 8104 1192 1396 7787 5756 FA_5VX1 $T=455400 -241920 1 0 $X=454970 $Y=-247040
X45317 5 4 7753 4762 1123 7786 5879 FA_5VX1 $T=455400 -206080 1 0 $X=454970 $Y=-211200
X45318 5 4 5877 1515 7784 5887 7761 FA_5VX1 $T=455400 -179200 0 0 $X=454970 $Y=-179840
X45319 5 4 5868 7772 5909 4769 5921 FA_5VX1 $T=455400 -71680 0 0 $X=454970 $Y=-72320
X45320 5 4 5980 1159 5883 7731 1388 FA_5VX1 $T=472760 -8960 0 180 $X=455530 $Y=-14080
X45321 5 4 5965 5882 5868 5892 5927 FA_5VX1 $T=475560 -53760 1 180 $X=458330 $Y=-54400
X45322 5 4 6038 7783 5897 8105 5930 FA_5VX1 $T=475560 -8960 1 180 $X=458330 $Y=-9600
X45323 5 4 5986 1506 5914 7771 5936 FA_5VX1 $T=478360 -116480 0 180 $X=461130 $Y=-121600
X45324 5 4 5984 5912 5906 5941 1395 FA_5VX1 $T=478920 8960 0 180 $X=461690 $Y=3840
X45325 5 4 5912 1154 5955 5980 1399 FA_5VX1 $T=462680 0 1 0 $X=462250 $Y=-5120
X45326 5 4 5920 4762 5981 5973 5974 FA_5VX1 $T=463800 -143360 0 0 $X=463370 $Y=-144000
X45327 5 4 5995 7785 5910 5922 5944 FA_5VX1 $T=480600 -35840 0 180 $X=463370 $Y=-40960
X45328 5 4 5948 7794 5886 1165 7789 FA_5VX1 $T=480600 -26880 0 180 $X=463370 $Y=-32000
X45329 5 4 5897 5966 5962 1159 5955 FA_5VX1 $T=463800 -17920 1 0 $X=463370 $Y=-23040
X45330 5 4 5925 1109 5971 7806 5932 FA_5VX1 $T=464920 -170240 1 0 $X=464490 $Y=-175360
X45331 5 4 7985 5920 5932 4754 5951 FA_5VX1 $T=482280 -134400 0 180 $X=465050 $Y=-139520
X45332 5 4 7814 1180 1394 7782 5958 FA_5VX1 $T=483960 -232960 1 180 $X=466730 $Y=-233600
X45333 5 4 6015 5905 5948 5940 5977 FA_5VX1 $T=486760 -17920 1 180 $X=469530 $Y=-18560
X45334 5 4 6022 1133 5960 7790 7800 FA_5VX1 $T=489000 -206080 0 180 $X=471770 $Y=-211200
X45335 5 4 6012 1210 1401 7983 5968 FA_5VX1 $T=489560 -259840 1 180 $X=472330 $Y=-260480
X45336 5 4 6009 5925 5972 4762 5975 FA_5VX1 $T=492360 -152320 0 180 $X=475130 $Y=-157440
X45337 5 4 6001 5933 5974 1515 5982 FA_5VX1 $T=492360 -125440 0 180 $X=475130 $Y=-130560
X45338 5 4 7828 6031 1123 7800 5874 FA_5VX1 $T=494040 -188160 0 180 $X=476810 $Y=-193280
X45339 5 4 7827 1165 5908 5961 5979 FA_5VX1 $T=494040 -89600 0 180 $X=476810 $Y=-94720
X45340 5 4 6021 7810 5916 5979 6004 FA_5VX1 $T=494040 -71680 0 180 $X=476810 $Y=-76800
X45341 5 4 7829 1168 7802 5982 5989 FA_5VX1 $T=494600 -107520 1 180 $X=477370 $Y=-108160
X45342 5 4 6044 4769 1523 5917 6061 FA_5VX1 $T=494600 -89600 1 180 $X=477370 $Y=-90240
X45343 5 4 6085 7827 5976 5989 6014 FA_5VX1 $T=496280 -98560 0 180 $X=479050 $Y=-103680
X45344 5 4 6051 1165 7809 7808 6056 FA_5VX1 $T=496280 -53760 0 180 $X=479050 $Y=-58880
X45345 5 4 6078 1168 5938 7792 6017 FA_5VX1 $T=496840 -80640 0 180 $X=479610 $Y=-85760
X45346 5 4 7839 7818 7985 5994 6099 FA_5VX1 $T=497400 -125440 1 180 $X=480170 $Y=-126080
X45347 5 4 6048 1119 1524 5991 7821 FA_5VX1 $T=497960 -224000 1 180 $X=480730 $Y=-224640
X45348 5 4 6070 5970 6001 7801 6082 FA_5VX1 $T=497960 -116480 1 180 $X=480730 $Y=-117120
X45349 5 4 6066 1170 7986 7811 6019 FA_5VX1 $T=497960 -35840 1 180 $X=480730 $Y=-36480
X45350 5 4 7832 1523 7812 5996 6020 FA_5VX1 $T=498520 -143360 1 180 $X=481290 $Y=-144000
X45351 5 4 6076 7831 6009 5884 6065 FA_5VX1 $T=499080 -134400 1 180 $X=481850 $Y=-135040
X45352 5 4 6077 1159 1168 6005 6028 FA_5VX1 $T=500200 -53760 1 180 $X=482970 $Y=-54400
X45353 5 4 7837 1133 6012 7817 6030 FA_5VX1 $T=500760 -250880 1 180 $X=483530 $Y=-251520
X45354 5 4 6094 7829 7793 5990 6032 FA_5VX1 $T=500760 -107520 0 180 $X=483530 $Y=-112640
X45355 5 4 7846 1109 7814 5969 6042 FA_5VX1 $T=504120 -215040 0 180 $X=486890 $Y=-220160
X45356 5 4 6083 5928 6027 6043 6049 FA_5VX1 $T=505240 -161280 1 180 $X=488010 $Y=-161920
X45357 5 4 6052 1157 6029 7823 1412 FA_5VX1 $T=505240 0 0 180 $X=488010 $Y=-5120
X45358 5 4 6059 6022 1117 7821 6060 FA_5VX1 $T=507480 -197120 0 180 $X=490250 $Y=-202240
X45359 5 4 6105 6039 7820 6033 6068 FA_5VX1 $T=508040 -250880 0 180 $X=490810 $Y=-256000
X45360 5 4 6073 6035 7828 7826 7834 FA_5VX1 $T=508040 -179200 1 180 $X=490810 $Y=-179840
X45361 5 4 7739 6091 1419 7987 1417 FA_5VX1 $T=491800 8960 1 0 $X=491370 $Y=3840
X45362 5 4 6039 1117 1422 1421 7838 FA_5VX1 $T=492360 -259840 0 0 $X=491930 $Y=-260480
X45363 5 4 7871 4762 6048 6018 6054 FA_5VX1 $T=510280 -206080 0 180 $X=493050 $Y=-211200
X45364 5 4 6075 5993 6059 6054 6046 FA_5VX1 $T=511960 -188160 0 180 $X=494730 $Y=-193280
X45365 5 4 6045 7854 6102 6116 6091 FA_5VX1 $T=496280 -8960 0 0 $X=495850 $Y=-9600
X45366 5 4 1423 7841 1415 7833 6096 FA_5VX1 $T=514200 -268800 1 180 $X=496970 $Y=-269440
X45367 5 4 5863 7862 6115 6111 7854 FA_5VX1 $T=499080 -35840 0 0 $X=498650 $Y=-36480
X45368 5 4 7732 7869 6124 6122 7862 FA_5VX1 $T=500760 -53760 0 0 $X=500330 $Y=-54400
X45369 5 4 6112 6100 6023 6030 7851 FA_5VX1 $T=518120 -232960 0 180 $X=500890 $Y=-238080
X45370 5 4 6100 1123 6034 6053 6086 FA_5VX1 $T=518120 -232960 1 180 $X=500890 $Y=-233600
X45371 5 4 6147 7846 7805 6086 7855 FA_5VX1 $T=518680 -224000 1 180 $X=501450 $Y=-224640
X45372 5 4 6117 7837 7842 7838 6106 FA_5VX1 $T=519800 -250880 1 180 $X=502570 $Y=-251520
X45373 5 4 7890 7871 6097 6042 6062 FA_5VX1 $T=519800 -215040 1 180 $X=502570 $Y=-215680
X45374 5 4 7756 7876 7883 6139 7869 FA_5VX1 $T=503000 -62720 1 0 $X=502570 $Y=-67840
X45375 5 4 5891 7878 7894 6149 7876 FA_5VX1 $T=506920 -80640 1 0 $X=506490 $Y=-85760
X45376 5 4 6107 7887 1526 6165 7879 FA_5VX1 $T=508040 -161280 0 0 $X=507610 $Y=-161920
X45377 5 4 7765 7880 7898 6157 7881 FA_5VX1 $T=508040 -116480 1 0 $X=507610 $Y=-121600
X45378 5 4 5848 7881 6167 7901 7878 FA_5VX1 $T=508040 -98560 1 0 $X=507610 $Y=-103680
X45379 5 4 6113 7891 7899 7900 7887 FA_5VX1 $T=508600 -179200 0 0 $X=508170 $Y=-179840
X45380 5 4 7857 7889 8106 6148 7880 FA_5VX1 $T=508600 -134400 0 0 $X=508170 $Y=-135040
X45381 5 4 7866 7879 6153 6143 7889 FA_5VX1 $T=510280 -143360 0 0 $X=509850 $Y=-144000
X45382 5 4 6282 1704 1698 1708 CAG_5VX1 $T=-459640 -26880 0 180 $X=-466790 $Y=-32000
X45383 5 4 1708 1685 1718 1707 CAG_5VX1 $T=-464120 -35840 1 0 $X=-464550 $Y=-40960
X45384 5 4 1707 6278 1729 1721 CAG_5VX1 $T=-463000 -62720 1 0 $X=-463430 $Y=-67840
X45385 5 4 43 1678 1709 6282 CAG_5VX1 $T=-455720 -17920 1 180 $X=-462870 $Y=-18565
X45386 5 4 1721 1720 1800 1728 CAG_5VX1 $T=-461880 -80640 0 0 $X=-462310 $Y=-81285
X45387 5 4 6285 1687 1705 1723 CAG_5VX1 $T=-454040 0 1 180 $X=-461190 $Y=-645
X45388 5 4 1770 1727 1733 1743 CAG_5VX1 $T=-453480 -116480 0 180 $X=-460630 $Y=-121600
X45389 5 4 1723 1734 1760 1745 CAG_5VX1 $T=-460200 0 1 0 $X=-460630 $Y=-5120
X45390 5 4 42 1710 1749 6285 CAG_5VX1 $T=-459080 8960 0 0 $X=-459510 $Y=8315
X45391 5 4 1745 1748 1759 1740 CAG_5VX1 $T=-458520 -17920 1 0 $X=-458950 $Y=-23040
X45392 5 4 1740 1758 1768 1753 CAG_5VX1 $T=-457400 -53760 0 0 $X=-457830 $Y=-54405
X45393 5 4 1743 1762 1775 1766 CAG_5VX1 $T=-456280 -134400 1 0 $X=-456710 $Y=-139520
X45394 5 4 1728 1744 1777 1770 CAG_5VX1 $T=-455720 -98560 1 0 $X=-456150 $Y=-103680
X45395 5 4 1753 1763 1779 1773 CAG_5VX1 $T=-455720 -62720 0 0 $X=-456150 $Y=-63365
X45396 5 4 1773 1772 1785 1778 CAG_5VX1 $T=-454600 -71680 1 0 $X=-455030 $Y=-76800
X45397 5 4 1766 1769 1804 1791 CAG_5VX1 $T=-452360 -152320 1 0 $X=-452790 $Y=-157440
X45398 5 4 1778 1789 1798 1792 CAG_5VX1 $T=-452360 -80640 1 0 $X=-452790 $Y=-85760
X45399 5 4 1792 1805 1822 1794 CAG_5VX1 $T=-449000 -98560 1 0 $X=-449430 $Y=-103680
X45400 5 4 1794 1793 1814 1811 CAG_5VX1 $T=-447880 -116480 1 0 $X=-448310 $Y=-121600
X45401 5 4 1811 1796 1825 6301 CAG_5VX1 $T=-445080 -143360 1 0 $X=-445510 $Y=-148480
X45402 5 4 1445 1810 1828 1829 CAG_5VX1 $T=-437240 -170240 1 180 $X=-444390 $Y=-170885
X45403 5 4 6301 1808 1834 1445 CAG_5VX1 $T=-441720 -161280 0 0 $X=-442150 $Y=-161925
X45404 5 4 1791 1817 1848 1858 CAG_5VX1 $T=-440040 -179200 1 0 $X=-440470 $Y=-184320
X45405 5 4 1862 1914 1826 1850 CAG_5VX1 $T=-434440 -107520 0 0 $X=-434870 $Y=-108165
X45406 5 4 71 1877 1908 69 CAG_5VX1 $T=-427160 8960 0 180 $X=-434310 $Y=3840
X45407 5 4 1866 1836 1901 1888 CAG_5VX1 $T=-433320 -215040 0 0 $X=-433750 $Y=-215685
X45408 5 4 1829 1867 1899 1889 CAG_5VX1 $T=-432760 -179200 1 0 $X=-433190 $Y=-184320
X45409 5 4 7995 1886 1881 1870 CAG_5VX1 $T=-432760 -26880 1 0 $X=-433190 $Y=-32000
X45410 5 4 6336 6330 1891 58 CAG_5VX1 $T=-422120 -116480 1 180 $X=-429270 $Y=-117125
X45411 5 4 1858 1855 1884 1866 CAG_5VX1 $T=-427720 -197120 1 0 $X=-428150 $Y=-202240
X45412 5 4 1888 1864 1918 1913 CAG_5VX1 $T=-427160 -224000 1 0 $X=-427590 $Y=-229120
X45413 5 4 1913 1898 1927 1924 CAG_5VX1 $T=-424920 -241920 0 0 $X=-425350 $Y=-242565
X45414 5 4 1924 1912 1950 1953 CAG_5VX1 $T=-421560 -250880 1 0 $X=-421990 $Y=-256000
X45415 5 4 1826 1944 1941 1951 CAG_5VX1 $T=-420440 -107520 1 0 $X=-420870 $Y=-112640
X45416 5 4 1953 75 91 93 CAG_5VX1 $T=-417640 -268800 1 0 $X=-418070 $Y=-273920
X45417 5 4 6348 1961 1979 1983 CAG_5VX1 $T=-414840 -98560 1 0 $X=-415270 $Y=-103680
X45418 5 4 1889 1939 1981 1969 CAG_5VX1 $T=-414280 -197120 0 0 $X=-414710 $Y=-197765
X45419 5 4 6367 1958 1917 6376 CAG_5VX1 $T=-407000 -26880 0 180 $X=-414150 $Y=-32000
X45420 5 4 1969 1985 2005 1989 CAG_5VX1 $T=-410920 -206080 1 0 $X=-411350 $Y=-211200
X45421 5 4 1981 1999 6378 6372 CAG_5VX1 $T=-407560 -197120 1 0 $X=-407990 $Y=-202240
X45422 5 4 6369 1982 2011 2009 CAG_5VX1 $T=-407000 -107520 1 0 $X=-407430 $Y=-112640
X45423 5 4 2023 107 106 105 CAG_5VX1 $T=-399160 -268800 1 180 $X=-406310 $Y=-269445
X45424 5 4 6362 6374 1450 6379 CAG_5VX1 $T=-405880 -143360 0 0 $X=-406310 $Y=-144005
X45425 5 4 2043 1987 2022 2023 CAG_5VX1 $T=-396920 -250880 1 180 $X=-404070 $Y=-251525
X45426 5 4 1947 2018 2026 1451 CAG_5VX1 $T=-403640 -161280 1 0 $X=-404070 $Y=-166400
X45427 5 4 1989 2056 2030 2043 CAG_5VX1 $T=-395240 -224000 1 0 $X=-395670 $Y=-229120
X45428 5 4 2081 2033 2092 2058 CAG_5VX1 $T=-388520 -125440 0 180 $X=-395670 $Y=-130560
X45429 5 4 2050 2068 2079 2067 CAG_5VX1 $T=-393000 -62720 0 0 $X=-393430 $Y=-63365
X45430 5 4 2067 2084 6404 2078 CAG_5VX1 $T=-390200 -71680 1 0 $X=-390630 $Y=-76800
X45431 5 4 2110 2028 2069 2050 CAG_5VX1 $T=-383480 -44800 1 180 $X=-390630 $Y=-45445
X45432 5 4 2109 2048 2082 2081 CAG_5VX1 $T=-386280 -107520 1 0 $X=-386710 $Y=-112640
X45433 5 4 2078 2060 2093 2109 CAG_5VX1 $T=-385720 -89600 1 0 $X=-386150 $Y=-94720
X45434 5 4 2119 2129 2070 2110 CAG_5VX1 $T=-376200 -26880 0 180 $X=-383350 $Y=-32000
X45435 5 4 146 2055 2099 2132 CAG_5VX1 $T=-374520 8960 1 180 $X=-381670 $Y=8315
X45436 5 4 2117 2130 2143 6418 CAG_5VX1 $T=-380120 -170240 1 0 $X=-380550 $Y=-175360
X45437 5 4 2058 2131 2106 2114 CAG_5VX1 $T=-380120 -143360 0 0 $X=-380550 $Y=-144005
X45438 5 4 2114 2144 2133 2117 CAG_5VX1 $T=-377880 -161280 0 0 $X=-378310 $Y=-161925
X45439 5 4 148 150 122 146 CAG_5VX1 $T=-374520 8960 0 0 $X=-374950 $Y=8315
X45440 5 4 2132 2113 2137 2150 CAG_5VX1 $T=-373960 0 0 0 $X=-374390 $Y=-645
X45441 5 4 2150 2178 2136 2119 CAG_5VX1 $T=-371160 -8960 1 0 $X=-371590 $Y=-14080
X45442 5 4 6418 2179 2168 2194 CAG_5VX1 $T=-370600 -179200 1 0 $X=-371030 $Y=-184320
X45443 5 4 2222 2115 6444 2244 CAG_5VX1 $T=-341480 -259840 1 180 $X=-348630 $Y=-260485
X45444 5 4 2194 2127 2228 2212 CAG_5VX1 $T=-348200 -188160 1 0 $X=-348630 $Y=-193280
X45445 5 4 2237 2183 6447 2222 CAG_5VX1 $T=-340920 -250880 0 180 $X=-348070 $Y=-256000
X45446 5 4 2212 2233 2245 6449 CAG_5VX1 $T=-344840 -215040 0 0 $X=-345270 $Y=-215685
X45447 5 4 6449 2227 2211 2248 CAG_5VX1 $T=-342040 -232960 1 0 $X=-342470 $Y=-238080
X45448 5 4 2244 2217 170 2254 CAG_5VX1 $T=-341480 -259840 0 0 $X=-341910 $Y=-260485
X45449 5 4 2254 6458 169 2259 CAG_5VX1 $T=-333640 -250880 0 180 $X=-340790 $Y=-256000
X45450 5 4 6478 6468 2258 2237 CAG_5VX1 $T=-328600 -250880 1 180 $X=-335750 $Y=-251525
X45451 5 4 2270 2208 177 6473 CAG_5VX1 $T=-333640 -259840 1 0 $X=-334070 $Y=-264960
X45452 5 4 2259 2270 179 2209 CAG_5VX1 $T=-333080 -259840 0 0 $X=-333510 $Y=-260485
X45453 5 4 6473 178 181 2291 CAG_5VX1 $T=-331400 -268800 1 0 $X=-331830 $Y=-273920
X45454 5 4 2248 2279 2238 6478 CAG_5VX1 $T=-331400 -241920 0 0 $X=-331830 $Y=-242565
X45455 5 4 2306 2300 2322 2289 CAG_5VX1 $T=-324120 -80640 1 180 $X=-331270 $Y=-81285
X45456 5 4 2308 6487 2340 2296 CAG_5VX1 $T=-324120 -35840 1 180 $X=-331270 $Y=-36485
X45457 5 4 2289 2288 1457 2299 CAG_5VX1 $T=-329720 -89600 1 0 $X=-330150 $Y=-94720
X45458 5 4 2296 2325 2312 2307 CAG_5VX1 $T=-328040 -44800 0 0 $X=-328470 $Y=-45445
X45459 5 4 2307 2301 2324 2306 CAG_5VX1 $T=-325800 -62720 1 0 $X=-326230 $Y=-67840
X45460 5 4 2299 6489 2345 2352 CAG_5VX1 $T=-323000 -107520 1 0 $X=-323430 $Y=-112640
X45461 5 4 2372 2302 2333 2308 CAG_5VX1 $T=-316280 -17920 0 180 $X=-323430 $Y=-23040
X45462 5 4 1457 2370 2331 2348 CAG_5VX1 $T=-321320 -98560 0 0 $X=-321750 $Y=-99205
X45463 5 4 193 186 2293 2353 CAG_5VX1 $T=-314040 8960 1 180 $X=-321190 $Y=8315
X45464 5 4 2352 6497 2367 2355 CAG_5VX1 $T=-317960 -125440 0 0 $X=-318390 $Y=-126085
X45465 5 4 2355 2344 2369 2365 CAG_5VX1 $T=-317400 -143360 1 0 $X=-317830 $Y=-148480
X45466 5 4 2322 2332 54 2319 CAG_5VX1 $T=-317400 -80640 1 0 $X=-317830 $Y=-85760
X45467 5 4 2365 2376 2390 2383 CAG_5VX1 $T=-314600 -161280 0 0 $X=-315030 $Y=-161925
X45468 5 4 2367 2391 2394 6505 CAG_5VX1 $T=-312360 -134400 1 0 $X=-312790 $Y=-139520
X45469 5 4 2345 2392 6504 2399 CAG_5VX1 $T=-312360 -116480 0 0 $X=-312790 $Y=-117125
X45470 5 4 2353 2264 2359 2372 CAG_5VX1 $T=-312360 -8960 0 0 $X=-312790 $Y=-9605
X45471 5 4 2369 2415 6506 2405 CAG_5VX1 $T=-310120 -152320 0 0 $X=-310550 $Y=-152965
X45472 5 4 2429 2384 2412 2343 CAG_5VX1 $T=-300600 -224000 0 180 $X=-307750 $Y=-229120
X45473 5 4 7997 210 214 2384 CAG_5VX1 $T=-303400 -241920 0 0 $X=-303830 $Y=-242565
X45474 5 4 2529 2480 2476 6541 CAG_5VX1 $T=-281560 -179200 1 180 $X=-288710 $Y=-179845
X45475 5 4 2511 2516 2523 2510 CAG_5VX1 $T=-284920 -134400 0 0 $X=-285350 $Y=-135045
X45476 5 4 240 2532 2512 2549 CAG_5VX1 $T=-273720 -8960 0 180 $X=-280870 $Y=-14080
X45477 5 4 233 2530 2531 6554 CAG_5VX1 $T=-279320 -44800 1 0 $X=-279750 $Y=-49920
X45478 5 4 2542 2565 2509 7922 CAG_5VX1 $T=-270920 -89600 1 180 $X=-278070 $Y=-90245
X45479 5 4 2586 2573 2567 2603 CAG_5VX1 $T=-269800 -224000 0 180 $X=-276950 $Y=-229120
X45480 5 4 2551 2562 2561 2535 CAG_5VX1 $T=-267000 -80640 1 180 $X=-274150 $Y=-81285
X45481 5 4 2616 2588 2504 6561 CAG_5VX1 $T=-264760 -125440 1 180 $X=-271910 $Y=-126085
X45482 5 4 2602 2609 2591 6569 CAG_5VX1 $T=-263080 -250880 1 180 $X=-270230 $Y=-251525
X45483 5 4 2579 2598 2615 6565 CAG_5VX1 $T=-269800 -107520 0 0 $X=-270230 $Y=-108165
X45484 5 4 2592 2613 2600 2607 CAG_5VX1 $T=-262520 -188160 1 180 $X=-269670 $Y=-188805
X45485 5 4 2607 2610 2568 2594 CAG_5VX1 $T=-261960 -197120 0 180 $X=-269110 $Y=-202240
X45486 5 4 6569 2507 2545 2560 CAG_5VX1 $T=-267560 -259840 0 0 $X=-267990 $Y=-260485
X45487 5 4 2594 2630 2538 2586 CAG_5VX1 $T=-267000 -215040 0 0 $X=-267430 $Y=-215685
X45488 5 4 2560 2593 245 241 CAG_5VX1 $T=-266440 -268800 0 0 $X=-266870 $Y=-269445
X45489 5 4 2603 2622 2554 2602 CAG_5VX1 $T=-265880 -232960 1 0 $X=-266310 $Y=-238080
X45490 5 4 6591 2617 2631 2592 CAG_5VX1 $T=-256920 -161280 1 180 $X=-264070 $Y=-161925
X45491 5 4 2624 2646 2642 2627 CAG_5VX1 $T=-263640 -8960 1 0 $X=-264070 $Y=-14080
X45492 5 4 6605 2672 2569 6591 CAG_5VX1 $T=-250200 -143360 1 180 $X=-257350 $Y=-144005
X45493 5 4 1464 2721 2669 2664 CAG_5VX1 $T=-250200 -35840 1 180 $X=-257350 $Y=-36485
X45494 5 4 2474 2652 92 2678 CAG_5VX1 $T=-256360 -206080 0 0 $X=-256790 $Y=-206725
X45495 5 4 2390 6598 2614 6601 CAG_5VX1 $T=-255800 -161280 0 0 $X=-256230 $Y=-161925
X45496 5 4 6606 2680 2663 6599 CAG_5VX1 $T=-248520 -80640 0 180 $X=-255670 $Y=-85760
X45497 5 4 6599 6603 2662 2685 CAG_5VX1 $T=-253000 -98560 0 0 $X=-253430 $Y=-99205
X45498 5 4 2696 2724 2676 1464 CAG_5VX1 $T=-244600 -17920 1 180 $X=-251750 $Y=-18565
X45499 5 4 2685 2645 2674 6605 CAG_5VX1 $T=-250760 -116480 1 0 $X=-251190 $Y=-121600
X45500 5 4 2664 2693 2703 6606 CAG_5VX1 $T=-250200 -53760 0 0 $X=-250630 $Y=-54405
X45501 5 4 2714 2640 2679 2699 CAG_5VX1 $T=-242920 -170240 1 180 $X=-250070 $Y=-170885
X45502 5 4 1465 2649 2691 84 CAG_5VX1 $T=-247400 -206080 1 0 $X=-247830 $Y=-211200
X45503 5 4 2701 2684 2720 2726 CAG_5VX1 $T=-246280 -197120 0 0 $X=-246710 $Y=-197765
X45504 5 4 294 2608 2686 2696 CAG_5VX1 $T=-237320 0 0 180 $X=-244470 $Y=-5120
X45505 5 4 2383 2667 2714 2707 CAG_5VX1 $T=-242360 -161280 1 0 $X=-242790 $Y=-166400
X45506 5 4 2697 2754 6621 2716 CAG_5VX1 $T=-233960 -206080 0 180 $X=-241110 $Y=-211200
X45507 5 4 2484 100 141 286 CAG_5VX1 $T=-240120 -232960 0 0 $X=-240550 $Y=-233605
X45508 5 4 2707 2727 2701 2697 CAG_5VX1 $T=-239560 -179200 1 0 $X=-239990 $Y=-184320
X45509 5 4 6621 2740 2731 6626 CAG_5VX1 $T=-238440 -224000 0 0 $X=-238870 $Y=-224645
X45510 5 4 2716 2769 2725 2730 CAG_5VX1 $T=-236760 -241920 1 0 $X=-237190 $Y=-247040
X45511 5 4 2806 2776 298 2772 CAG_5VX1 $T=-227800 -17920 1 180 $X=-234950 $Y=-18565
X45512 5 4 2786 2835 1469 2773 CAG_5VX1 $T=-221080 -71680 1 180 $X=-228230 $Y=-72325
X45513 5 4 2772 2873 327 6641 CAG_5VX1 $T=-221080 -44800 1 180 $X=-228230 $Y=-45445
X45514 5 4 338 2788 309 2806 CAG_5VX1 $T=-221080 -17920 1 180 $X=-228230 $Y=-18565
X45515 5 4 2826 6646 2802 84 CAG_5VX1 $T=-220520 -224000 0 180 $X=-227670 $Y=-229120
X45516 5 4 6641 2787 314 2786 CAG_5VX1 $T=-224440 -53760 1 0 $X=-224870 $Y=-58880
X45517 5 4 2845 2739 325 339 CAG_5VX1 $T=-216600 -268800 0 180 $X=-223750 $Y=-273920
X45518 5 4 2784 2821 2083 2790 CAG_5VX1 $T=-222200 -107520 0 0 $X=-222630 $Y=-108165
X45519 5 4 2881 1447 2826 2855 CAG_5VX1 $T=-211000 -197120 1 180 $X=-218150 $Y=-197765
X45520 5 4 2837 2860 6666 89 CAG_5VX1 $T=-216040 -232960 0 0 $X=-216470 $Y=-233605
X45521 5 4 2893 1447 349 2923 CAG_5VX1 $T=-206520 -250880 0 180 $X=-213670 $Y=-256000
X45522 5 4 2884 2890 2837 80 CAG_5VX1 $T=-204840 -215040 0 180 $X=-211990 $Y=-220160
X45523 5 4 2912 1462 2828 2900 CAG_5VX1 $T=-203720 -152320 1 180 $X=-210870 $Y=-152965
X45524 5 4 2899 6672 1470 79 CAG_5VX1 $T=-202600 -232960 1 180 $X=-209750 $Y=-233605
X45525 5 4 2919 1462 2884 2914 CAG_5VX1 $T=-199800 -188160 0 180 $X=-206950 $Y=-193280
X45526 5 4 6677 1452 6674 2774 CAG_5VX1 $T=-198680 -179200 0 180 $X=-205830 $Y=-184320
X45527 5 4 2924 2905 346 79 CAG_5VX1 $T=-197000 -259840 0 180 $X=-204150 $Y=-264960
X45528 5 4 2953 80 2928 1452 CAG_5VX1 $T=-195320 -224000 1 180 $X=-202470 $Y=-224645
X45529 5 4 2956 2919 2931 2938 CAG_5VX1 $T=-194760 -170240 1 180 $X=-201910 $Y=-170885
X45530 5 4 2954 1447 2922 1462 CAG_5VX1 $T=-194200 -215040 1 180 $X=-201350 $Y=-215685
X45531 5 4 2730 2780 368 2947 CAG_5VX1 $T=-199800 -259840 0 0 $X=-200230 $Y=-260485
X45532 5 4 3004 2924 2943 6681 CAG_5VX1 $T=-193080 -241920 1 180 $X=-200230 $Y=-242565
X45533 5 4 6683 1452 2899 1900 CAG_5VX1 $T=-193080 -197120 0 180 $X=-200230 $Y=-202240
X45534 5 4 2984 1900 2881 58 CAG_5VX1 $T=-193080 -161280 1 180 $X=-200230 $Y=-161925
X45535 5 4 2962 58 2912 48 CAG_5VX1 $T=-192520 -125440 0 180 $X=-199670 $Y=-130560
X45536 5 4 2952 2957 2893 2964 CAG_5VX1 $T=-191960 -250880 1 180 $X=-199110 $Y=-251525
X45537 5 4 2975 48 2939 2944 CAG_5VX1 $T=-190840 -98560 1 180 $X=-197990 $Y=-99205
X45538 5 4 2964 2951 364 363 CAG_5VX1 $T=-190280 -259840 0 180 $X=-197430 $Y=-264960
X45539 5 4 2976 54 2940 51 CAG_5VX1 $T=-189720 -62720 1 180 $X=-196870 $Y=-63365
X45540 5 4 377 2942 2959 369 CAG_5VX1 $T=-189720 8960 1 180 $X=-196870 $Y=8315
X45541 5 4 6684 2953 2946 2936 CAG_5VX1 $T=-189160 -224000 0 180 $X=-196310 $Y=-229120
X45542 5 4 3023 59 2933 47 CAG_5VX1 $T=-189160 -116480 1 180 $X=-196310 $Y=-117125
X45543 5 4 6686 2954 2911 2960 CAG_5VX1 $T=-188040 -206080 0 180 $X=-195190 $Y=-211200
X45544 5 4 2966 2937 1841 6683 CAG_5VX1 $T=-188040 -188160 1 180 $X=-195190 $Y=-188805
X45545 5 4 2958 2971 2966 2955 CAG_5VX1 $T=-186920 -170240 0 180 $X=-194070 $Y=-175360
X45546 5 4 2990 47 2916 49 CAG_5VX1 $T=-186360 -71680 0 180 $X=-193510 $Y=-76800
X45547 5 4 2955 3005 6686 2965 CAG_5VX1 $T=-192520 -197120 1 0 $X=-192950 $Y=-202240
X45548 5 4 2968 2920 2950 2932 CAG_5VX1 $T=-192520 -134400 0 0 $X=-192950 $Y=-135045
X45549 5 4 2988 3035 2968 2980 CAG_5VX1 $T=-185800 -125440 0 180 $X=-192950 $Y=-130560
X45550 5 4 2965 2999 6684 2978 CAG_5VX1 $T=-185240 -215040 0 180 $X=-192390 $Y=-220160
X45551 5 4 3006 2984 2967 7916 CAG_5VX1 $T=-185240 -152320 0 180 $X=-192390 $Y=-157440
X45552 5 4 2985 2996 2956 2958 CAG_5VX1 $T=-184120 -161280 0 180 $X=-191270 $Y=-166400
X45553 5 4 6688 49 2929 45 CAG_5VX1 $T=-184120 -35840 0 180 $X=-191270 $Y=-40960
X45554 5 4 6690 2935 2992 2995 CAG_5VX1 $T=-183560 -8960 1 180 $X=-190710 $Y=-9605
X45555 5 4 2978 2986 3004 2952 CAG_5VX1 $T=-189720 -232960 1 0 $X=-190150 $Y=-238080
X45556 5 4 6692 2976 2973 2998 CAG_5VX1 $T=-183000 -44800 0 180 $X=-190150 $Y=-49920
X45557 5 4 2981 3011 3007 2988 CAG_5VX1 $T=-181880 -107520 0 180 $X=-189030 $Y=-112640
X45558 5 4 3013 3019 6687 2981 CAG_5VX1 $T=-181880 -89600 0 180 $X=-189030 $Y=-94720
X45559 5 4 374 3015 6690 3008 CAG_5VX1 $T=-188600 0 0 0 $X=-189030 $Y=-645
X45560 5 4 3007 2962 3002 2993 CAG_5VX1 $T=-188040 -116480 1 0 $X=-188470 $Y=-121600
X45561 5 4 3012 2975 2972 2994 CAG_5VX1 $T=-181320 -80640 0 180 $X=-188470 $Y=-85760
X45562 5 4 3025 6688 2991 6689 CAG_5VX1 $T=-180760 -26880 0 180 $X=-187910 $Y=-32000
X45563 5 4 2947 383 385 386 CAG_5VX1 $T=-186920 -268800 1 0 $X=-187350 $Y=-273920
X45564 5 4 2980 3009 3006 2985 CAG_5VX1 $T=-186920 -143360 0 0 $X=-187350 $Y=-144005
X45565 5 4 2983 3021 3012 3013 CAG_5VX1 $T=-179640 -80640 1 180 $X=-186790 $Y=-81285
X45566 5 4 2997 2990 2982 3003 CAG_5VX1 $T=-185800 -62720 1 0 $X=-186230 $Y=-67840
X45567 5 4 3024 6693 2997 2983 CAG_5VX1 $T=-178520 -53760 0 180 $X=-185670 $Y=-58880
X45568 5 4 3032 3031 6692 3024 CAG_5VX1 $T=-177400 -35840 0 180 $X=-184550 $Y=-40960
X45569 5 4 6687 2989 54 3023 CAG_5VX1 $T=-182440 -98560 1 0 $X=-182870 $Y=-103680
X45570 5 4 3008 3042 3025 3032 CAG_5VX1 $T=-179080 -17920 1 0 $X=-179510 $Y=-23040
X45571 5 4 3151 3140 3129 3128 CAG_5VX1 $T=-153880 -17920 1 180 $X=-161030 $Y=-18565
X45572 5 4 3156 3117 3132 3053 CAG_5VX1 $T=-153320 -53760 1 180 $X=-160470 $Y=-54405
X45573 5 4 3128 3143 3133 3137 CAG_5VX1 $T=-153320 -26880 1 180 $X=-160470 $Y=-27525
X45574 5 4 3150 3106 3136 3142 CAG_5VX1 $T=-152200 -89600 1 180 $X=-159350 $Y=-90245
X45575 5 4 3137 6734 3147 3156 CAG_5VX1 $T=-158360 -35840 0 0 $X=-158790 $Y=-36485
X45576 5 4 3053 3123 3155 3150 CAG_5VX1 $T=-157800 -62720 1 0 $X=-158230 $Y=-67840
X45577 5 4 448 3102 3130 3151 CAG_5VX1 $T=-149400 8960 1 180 $X=-156550 $Y=8315
X45578 5 4 6761 3181 3170 3171 CAG_5VX1 $T=-143240 -170240 0 180 $X=-150390 $Y=-175360
X45579 5 4 483 3224 3209 3215 CAG_5VX1 $T=-134280 8960 0 180 $X=-141430 $Y=3840
X45580 5 4 3224 3275 3239 3236 CAG_5VX1 $T=-137080 -8960 1 0 $X=-137510 $Y=-14080
X45581 5 4 3185 3220 3234 6786 CAG_5VX1 $T=-134280 -53760 0 0 $X=-134710 $Y=-54405
X45582 5 4 6784 6778 3233 3252 CAG_5VX1 $T=-133160 -89600 0 0 $X=-133590 $Y=-90245
X45583 5 4 6780 3185 3214 3253 CAG_5VX1 $T=-133160 -35840 1 0 $X=-133590 $Y=-40960
X45584 5 4 3220 6784 3203 3259 CAG_5VX1 $T=-132600 -71680 0 0 $X=-133030 $Y=-72325
X45585 5 4 1480 3351 2906 3346 CAG_5VX1 $T=-91160 -35840 1 180 $X=-98310 $Y=-36485
X45586 5 4 562 3355 3334 544 CAG_5VX1 $T=-91160 0 0 180 $X=-98310 $Y=-5120
X45587 5 4 6839 3354 547 3348 CAG_5VX1 $T=-90600 -143360 1 180 $X=-97750 $Y=-144005
X45588 5 4 7951 3369 3328 3337 CAG_5VX1 $T=-90600 -107520 1 180 $X=-97750 $Y=-108165
X45589 5 4 3371 3350 3338 563 CAG_5VX1 $T=-85560 -44800 0 180 $X=-92710 $Y=-49920
X45590 5 4 3400 3378 3374 3398 CAG_5VX1 $T=-85000 -241920 0 180 $X=-92150 $Y=-247040
X45591 5 4 6849 1480 3372 3377 CAG_5VX1 $T=-85000 -17920 0 180 $X=-92150 $Y=-23040
X45592 5 4 6851 3383 3380 569 CAG_5VX1 $T=-82760 -107520 1 180 $X=-89910 $Y=-108165
X45593 5 4 6857 3388 3390 6850 CAG_5VX1 $T=-80520 -206080 0 180 $X=-87670 $Y=-211200
X45594 5 4 3418 3405 3434 3400 CAG_5VX1 $T=-79960 -224000 1 180 $X=-87110 $Y=-224645
X45595 5 4 3361 570 583 571 CAG_5VX1 $T=-86120 -268800 1 0 $X=-86550 $Y=-273920
X45596 5 4 3422 3415 3403 3440 CAG_5VX1 $T=-78840 -17920 1 180 $X=-85990 $Y=-18565
X45597 5 4 7952 3412 3431 3481 CAG_5VX1 $T=-85000 -62720 1 0 $X=-85430 $Y=-67840
X45598 5 4 3398 3381 574 579 CAG_5VX1 $T=-83880 -259840 1 0 $X=-84310 $Y=-264960
X45599 5 4 3348 3359 3396 3425 CAG_5VX1 $T=-75480 -170240 1 180 $X=-82630 $Y=-170885
X45600 5 4 3420 3432 3416 7926 CAG_5VX1 $T=-80520 -44800 1 0 $X=-80950 $Y=-49920
X45601 5 4 8001 3464 3419 3476 CAG_5VX1 $T=-71000 -98560 1 180 $X=-78150 $Y=-99205
X45602 5 4 3410 3519 3448 3495 CAG_5VX1 $T=-76600 -188160 1 0 $X=-77030 $Y=-193280
X45603 5 4 6872 3442 3474 6876 CAG_5VX1 $T=-75480 -170240 0 0 $X=-75910 $Y=-170885
X45604 5 4 3478 3477 3465 7927 CAG_5VX1 $T=-68760 -80640 0 180 $X=-75910 $Y=-85760
X45605 5 4 6880 3482 6892 7918 CAG_5VX1 $T=-70440 -26880 0 0 $X=-70870 $Y=-27525
X45606 5 4 7999 603 3517 3486 CAG_5VX1 $T=-70440 0 0 0 $X=-70870 $Y=-645
X45607 5 4 3487 3456 3493 3418 CAG_5VX1 $T=-69880 -206080 0 0 $X=-70310 $Y=-206725
X45608 5 4 3442 3497 3504 607 CAG_5VX1 $T=-69880 -179200 0 0 $X=-70310 $Y=-179845
X45609 5 4 3432 604 3459 608 CAG_5VX1 $T=-69880 -44800 1 0 $X=-70310 $Y=-49920
X45610 5 4 6884 3494 3507 6891 CAG_5VX1 $T=-69320 -152320 0 0 $X=-69750 $Y=-152965
X45611 5 4 8000 3501 3508 3480 CAG_5VX1 $T=-69320 -125440 1 0 $X=-69750 $Y=-130560
X45612 5 4 6898 3435 3473 3487 CAG_5VX1 $T=-62040 -188160 1 180 $X=-69190 $Y=-188805
X45613 5 4 3494 3498 3512 611 CAG_5VX1 $T=-68760 -161280 0 0 $X=-69190 $Y=-161925
X45614 5 4 6882 3509 3463 6896 CAG_5VX1 $T=-67080 -116480 0 0 $X=-67510 $Y=-117125
X45615 5 4 3477 3535 623 604 CAG_5VX1 $T=-66520 -89600 0 0 $X=-66950 $Y=-90245
X45616 5 4 3548 3527 3520 6898 CAG_5VX1 $T=-58680 -170240 1 180 $X=-65830 $Y=-170885
X45617 5 4 3509 3539 611 623 CAG_5VX1 $T=-60920 -107520 1 0 $X=-61350 $Y=-112640
X45618 5 4 3612 3543 3567 3548 CAG_5VX1 $T=-43560 -152320 1 180 $X=-50710 $Y=-152965
X45619 5 4 3632 3639 3609 3612 CAG_5VX1 $T=-35160 -134400 1 180 $X=-42310 $Y=-135045
X45620 5 4 3642 3618 3626 3632 CAG_5VX1 $T=-34040 -116480 1 180 $X=-41190 $Y=-117125
X45621 5 4 3657 6945 3674 3642 CAG_5VX1 $T=-32360 -89600 0 180 $X=-39510 $Y=-94720
X45622 5 4 3620 6943 668 3645 CAG_5VX1 $T=-38520 -250880 1 0 $X=-38950 $Y=-256000
X45623 5 4 674 3654 3644 3649 CAG_5VX1 $T=-31240 0 0 180 $X=-38390 $Y=-5120
X45624 5 4 3679 6951 3653 3657 CAG_5VX1 $T=-29000 -71680 0 180 $X=-36150 $Y=-76800
X45625 5 4 3680 3685 3665 3669 CAG_5VX1 $T=-27320 -26880 0 180 $X=-34470 $Y=-32000
X45626 5 4 3691 3684 3664 3679 CAG_5VX1 $T=-25080 -62720 1 180 $X=-32230 $Y=-63365
X45627 5 4 3649 3675 3686 3680 CAG_5VX1 $T=-31800 -17920 1 0 $X=-32230 $Y=-23040
X45628 5 4 3669 3668 3694 3691 CAG_5VX1 $T=-29560 -53760 0 0 $X=-29990 $Y=-54405
X45629 5 4 3693 3673 684 6962 CAG_5VX1 $T=-22280 -224000 0 180 $X=-29430 $Y=-229120
X45630 5 4 3701 3708 3714 6966 CAG_5VX1 $T=-24520 -197120 1 0 $X=-24950 $Y=-202240
X45631 5 4 3737 3725 3624 3710 CAG_5VX1 $T=-15560 -134400 1 180 $X=-22710 $Y=-135045
X45632 5 4 3753 3736 3800 6976 CAG_5VX1 $T=-12760 -170240 0 180 $X=-19910 $Y=-175360
X45633 5 4 3754 6980 3711 3764 CAG_5VX1 $T=-11080 -152320 0 180 $X=-18230 $Y=-157440
X45634 5 4 3775 3762 3724 3723 CAG_5VX1 $T=-8280 -188160 1 180 $X=-15430 $Y=-188805
X45635 5 4 3781 3729 702 3757 CAG_5VX1 $T=-7160 -259840 0 180 $X=-14310 $Y=-264960
X45636 5 4 712 3781 3748 3646 CAG_5VX1 $T=-3800 -259840 1 180 $X=-10950 $Y=-260485
X45637 5 4 3811 3803 1487 3797 CAG_5VX1 $T=120 -134400 0 180 $X=-7030 $Y=-139520
X45638 5 4 3777 3792 3782 3812 CAG_5VX1 $T=-4360 -107520 1 0 $X=-4790 $Y=-112640
X45639 5 4 3796 3827 3678 3795 CAG_5VX1 $T=4600 -179200 1 180 $X=-2550 $Y=-179845
X45640 5 4 723 7016 3805 3829 CAG_5VX1 $T=120 8960 1 0 $X=-310 $Y=3840
X45641 5 4 3859 7021 3783 7017 CAG_5VX1 $T=7960 -89600 0 180 $X=810 $Y=-94720
X45642 5 4 3824 3823 1490 3832 CAG_5VX1 $T=7960 -80640 1 180 $X=810 $Y=-81285
X45643 5 4 3846 3739 3830 3796 CAG_5VX1 $T=8520 -152320 0 180 $X=1370 $Y=-157440
X45644 5 4 3834 732 730 3835 CAG_5VX1 $T=9080 -259840 0 180 $X=1930 $Y=-264960
X45645 5 4 731 3842 3867 722 CAG_5VX1 $T=3480 -8960 0 0 $X=3050 $Y=-9605
X45646 5 4 3849 3856 3836 3846 CAG_5VX1 $T=10760 -134400 0 180 $X=3610 $Y=-139520
X45647 5 4 739 3839 3742 3833 CAG_5VX1 $T=6280 -35840 0 0 $X=5850 $Y=-36485
X45648 5 4 7032 3871 3841 3849 CAG_5VX1 $T=14120 -116480 0 180 $X=6970 $Y=-121600
X45649 5 4 777 3897 3886 761 CAG_5VX1 $T=19720 -17920 0 180 $X=12570 $Y=-23040
X45650 5 4 3918 3928 3935 7056 CAG_5VX1 $T=21400 -98560 0 0 $X=20970 $Y=-99205
X45651 5 4 785 3906 1493 7060 CAG_5VX1 $T=21960 0 1 0 $X=21530 $Y=-5120
X45652 5 4 7066 3932 3939 3940 CAG_5VX1 $T=30360 -188160 1 180 $X=23210 $Y=-188805
X45653 5 4 3937 3954 3934 3944 CAG_5VX1 $T=30920 -107520 0 180 $X=23770 $Y=-112640
X45654 5 4 3982 3959 3938 3948 CAG_5VX1 $T=31480 -224000 0 180 $X=24330 $Y=-229120
X45655 5 4 7058 3979 3961 3953 CAG_5VX1 $T=24760 -125440 1 0 $X=24330 $Y=-130560
X45656 5 4 3974 3963 3857 3892 CAG_5VX1 $T=32040 -80640 0 180 $X=24890 $Y=-85760
X45657 5 4 3986 3920 3960 7066 CAG_5VX1 $T=33720 -179200 1 180 $X=26570 $Y=-179845
X45658 5 4 3948 3931 3968 7070 CAG_5VX1 $T=28680 -241920 0 0 $X=28250 $Y=-242565
X45659 5 4 3977 7073 7069 3957 CAG_5VX1 $T=36520 -26880 1 180 $X=29370 $Y=-27525
X45660 5 4 3940 3901 3949 3982 CAG_5VX1 $T=30360 -206080 1 0 $X=29930 $Y=-211200
X45661 5 4 804 3926 3945 3977 CAG_5VX1 $T=37080 0 0 180 $X=29930 $Y=-5120
X45662 5 4 7070 3924 792 793 CAG_5VX1 $T=32040 -250880 1 0 $X=31610 $Y=-256000
X45663 5 4 3957 4019 3942 4002 CAG_5VX1 $T=35400 -44800 0 0 $X=34970 $Y=-45445
X45664 5 4 4033 4022 3978 3986 CAG_5VX1 $T=43240 -161280 0 180 $X=36090 $Y=-166400
X45665 5 4 4002 7082 3996 3981 CAG_5VX1 $T=36520 -80640 0 0 $X=36090 $Y=-81285
X45666 5 4 803 4015 4023 4018 CAG_5VX1 $T=36520 -62720 0 0 $X=36090 $Y=-63365
X45667 5 4 3981 4046 4034 4010 CAG_5VX1 $T=39320 -98560 1 0 $X=38890 $Y=-103680
X45668 5 4 812 3922 4028 4027 CAG_5VX1 $T=46040 -8960 1 180 $X=38890 $Y=-9605
X45669 5 4 4010 4031 4037 7088 CAG_5VX1 $T=39880 -116480 1 0 $X=39450 $Y=-121600
X45670 5 4 4016 4012 4041 677 CAG_5VX1 $T=40440 -259840 1 0 $X=40010 $Y=-264960
X45671 5 4 4027 4075 7095 7091 CAG_5VX1 $T=42120 -35840 0 0 $X=41690 $Y=-36485
X45672 5 4 3999 4021 4006 4049 CAG_5VX1 $T=43240 -206080 0 0 $X=42810 $Y=-206725
X45673 5 4 7091 4009 4063 4057 CAG_5VX1 $T=43800 -53760 1 0 $X=43370 $Y=-58880
X45674 5 4 7088 4030 4059 4033 CAG_5VX1 $T=44360 -143360 0 0 $X=43930 $Y=-144005
X45675 5 4 4045 4061 4065 7103 CAG_5VX1 $T=47160 -215040 1 0 $X=46730 $Y=-220160
X45676 5 4 4055 4058 4079 3987 CAG_5VX1 $T=48280 -152320 1 0 $X=47850 $Y=-157440
X45677 5 4 3998 4072 813 4078 CAG_5VX1 $T=48840 -232960 0 0 $X=48410 $Y=-233605
X45678 5 4 4011 4135 4099 4150 CAG_5VX1 $T=51080 -152320 0 0 $X=50650 $Y=-152965
X45679 5 4 4120 4109 4095 4085 CAG_5VX1 $T=59480 -197120 0 180 $X=52330 $Y=-202240
X45680 5 4 4057 4097 4111 4102 CAG_5VX1 $T=52760 -89600 0 0 $X=52330 $Y=-90245
X45681 5 4 4102 4143 4151 4131 CAG_5VX1 $T=63400 -107520 1 0 $X=62970 $Y=-112640
X45682 5 4 4131 4147 4155 7130 CAG_5VX1 $T=64520 -143360 0 0 $X=64090 $Y=-144005
X45683 5 4 4192 4159 4173 7142 CAG_5VX1 $T=78520 -206080 1 180 $X=71370 $Y=-206725
X45684 5 4 7130 4154 4186 7143 CAG_5VX1 $T=71800 -161280 0 0 $X=71370 $Y=-161925
X45685 5 4 4197 4196 4158 885 CAG_5VX1 $T=80760 -250880 0 180 $X=73610 $Y=-256000
X45686 5 4 7143 4172 4199 4192 CAG_5VX1 $T=74600 -179200 1 0 $X=74170 $Y=-184320
X45687 5 4 7142 4149 4185 4197 CAG_5VX1 $T=75160 -232960 1 0 $X=74730 $Y=-238080
X45688 5 4 7145 4190 4203 4184 CAG_5VX1 $T=75160 -53760 1 0 $X=74730 $Y=-58880
X45689 5 4 4184 4194 4214 3974 CAG_5VX1 $T=75720 -71680 0 0 $X=75290 $Y=-72325
X45690 5 4 4188 883 893 889 CAG_5VX1 $T=76840 -268800 1 0 $X=76410 $Y=-273920
X45691 5 4 4230 4217 4206 4188 CAG_5VX1 $T=85800 -259840 0 180 $X=78650 $Y=-264960
X45692 5 4 4266 4242 4248 4223 CAG_5VX1 $T=93640 -215040 0 180 $X=86490 $Y=-220160
X45693 5 4 4253 4264 4274 4230 CAG_5VX1 $T=90280 -241920 1 0 $X=89850 $Y=-247040
X45694 5 4 4223 4287 7163 4253 CAG_5VX1 $T=90840 -232960 0 0 $X=90410 $Y=-233605
X45695 5 4 947 4325 4333 7963 CAG_5VX1 $T=111000 -8960 0 0 $X=110570 $Y=-9605
X45696 5 4 4401 4392 4456 4388 CAG_5VX1 $T=120520 -125440 0 180 $X=113370 $Y=-130560
X45697 5 4 7963 4377 4331 4394 CAG_5VX1 $T=113800 -8960 1 0 $X=113370 $Y=-14080
X45698 5 4 4394 4381 4348 4387 CAG_5VX1 $T=121640 -35840 0 180 $X=114490 $Y=-40960
X45699 5 4 4429 4399 7193 4386 CAG_5VX1 $T=122200 -161280 0 180 $X=115050 $Y=-166400
X45700 5 4 4386 4427 4413 4433 CAG_5VX1 $T=118280 -197120 0 0 $X=117850 $Y=-197765
X45701 5 4 4387 4402 4366 4417 CAG_5VX1 $T=118280 -62720 0 0 $X=117850 $Y=-63365
X45702 5 4 4414 4422 4384 4401 CAG_5VX1 $T=125560 -98560 0 180 $X=118410 $Y=-103680
X45703 5 4 4415 4345 4407 4414 CAG_5VX1 $T=125560 -98560 1 180 $X=118410 $Y=-99205
X45704 5 4 4437 4408 4347 4415 CAG_5VX1 $T=129480 -89600 1 180 $X=122330 $Y=-90245
X45705 5 4 4417 4431 4362 4437 CAG_5VX1 $T=122760 -71680 0 0 $X=122330 $Y=-72325
X45706 5 4 4433 4470 4461 4465 CAG_5VX1 $T=129480 -215040 0 0 $X=129050 $Y=-215685
X45707 5 4 4474 4478 4451 4438 CAG_5VX1 $T=136760 -134400 0 180 $X=129610 $Y=-139520
X45708 5 4 4484 4479 4458 4445 CAG_5VX1 $T=136760 -62720 0 180 $X=129610 $Y=-67840
X45709 5 4 7214 4481 4404 4442 CAG_5VX1 $T=137320 -170240 1 180 $X=130170 $Y=-170885
X45710 5 4 4388 4426 4450 4429 CAG_5VX1 $T=130600 -143360 1 0 $X=130170 $Y=-148480
X45711 5 4 4444 7210 4457 4474 CAG_5VX1 $T=137320 -116480 0 180 $X=130170 $Y=-121600
X45712 5 4 4445 4482 4452 4444 CAG_5VX1 $T=137320 -89600 1 180 $X=130170 $Y=-90245
X45713 5 4 4435 4483 4459 4484 CAG_5VX1 $T=137320 -44800 1 180 $X=130170 $Y=-45445
X45714 5 4 4436 4398 4463 4435 CAG_5VX1 $T=130600 -26880 0 0 $X=130170 $Y=-27525
X45715 5 4 4432 4476 4464 4480 CAG_5VX1 $T=131160 -250880 0 0 $X=130730 $Y=-251525
X45716 5 4 4465 4472 4449 4432 CAG_5VX1 $T=131160 -232960 0 0 $X=130730 $Y=-233605
X45717 5 4 4442 7209 4454 4441 CAG_5VX1 $T=131160 -188160 0 0 $X=130730 $Y=-188805
X45718 5 4 4438 4473 4455 7214 CAG_5VX1 $T=131160 -161280 0 0 $X=130730 $Y=-161925
X45719 5 4 4448 7213 4453 4436 CAG_5VX1 $T=137880 -8960 1 180 $X=130730 $Y=-9605
X45720 5 4 4441 4477 4283 4266 CAG_5VX1 $T=131720 -197120 1 0 $X=131290 $Y=-202240
X45721 5 4 974 972 4439 4448 CAG_5VX1 $T=138440 8960 0 180 $X=131290 $Y=3840
X45722 5 4 4480 4507 4460 983 CAG_5VX1 $T=151880 -259840 1 0 $X=151450 $Y=-264960
X45723 5 4 4801 4740 4796 4773 CAG_5VX1 $T=216280 -241920 0 180 $X=209130 $Y=-247040
X45724 5 4 4789 4772 4804 4771 CAG_5VX1 $T=217960 -259840 0 180 $X=210810 $Y=-264960
X45725 5 4 4773 4781 4795 4789 CAG_5VX1 $T=211800 -250880 1 0 $X=211370 $Y=-256000
X45726 5 4 4771 1135 1140 1139 CAG_5VX1 $T=212360 -268800 1 0 $X=211930 $Y=-273920
X45727 5 4 4812 4748 4802 4801 CAG_5VX1 $T=221320 -232960 1 180 $X=214170 $Y=-233605
X45728 5 4 4815 4814 4810 4805 CAG_5VX1 $T=221320 -197120 0 180 $X=214170 $Y=-202240
X45729 5 4 4833 7967 4813 4815 CAG_5VX1 $T=221880 -179200 0 180 $X=214730 $Y=-184320
X45730 5 4 4805 4766 4809 4812 CAG_5VX1 $T=227480 -215040 0 180 $X=220330 $Y=-220160
X45731 5 4 4876 4850 4855 4833 CAG_5VX1 $T=230280 -170240 0 180 $X=223130 $Y=-175360
X45732 5 4 4879 4852 4859 4865 CAG_5VX1 $T=230280 -89600 1 180 $X=223130 $Y=-90245
X45733 5 4 4853 4845 4873 4879 CAG_5VX1 $T=224120 -71680 0 0 $X=223690 $Y=-72325
X45734 5 4 4910 4856 4869 4872 CAG_5VX1 $T=231960 -125440 1 180 $X=224810 $Y=-126085
X45735 5 4 4865 4870 4878 4874 CAG_5VX1 $T=225800 -98560 1 0 $X=225370 $Y=-103680
X45736 5 4 4898 4890 4880 7337 CAG_5VX1 $T=234200 -35840 1 180 $X=227050 $Y=-36485
X45737 5 4 4872 4834 4877 7339 CAG_5VX1 $T=228600 -134400 1 0 $X=228170 $Y=-139520
X45738 5 4 1155 4896 1151 4892 CAG_5VX1 $T=235320 8960 1 180 $X=228170 $Y=8315
X45739 5 4 7337 4826 4866 4853 CAG_5VX1 $T=230280 -44800 1 0 $X=229850 $Y=-49920
X45740 5 4 7338 7340 4886 4891 CAG_5VX1 $T=230840 -8960 1 0 $X=230410 $Y=-14080
X45741 5 4 4891 4840 4912 4898 CAG_5VX1 $T=231400 -26880 0 0 $X=230970 $Y=-27525
X45742 5 4 4892 4846 4881 7338 CAG_5VX1 $T=238680 0 0 180 $X=231530 $Y=-5120
X45743 5 4 7339 4861 4885 4876 CAG_5VX1 $T=232520 -143360 0 0 $X=232090 $Y=-144005
X45744 5 4 4874 4883 4919 4910 CAG_5VX1 $T=233080 -116480 0 0 $X=232650 $Y=-117125
X45745 5 4 4977 4963 1193 1186 CAG_5VX1 $T=250440 -17920 0 0 $X=250010 $Y=-18565
X45746 5 4 5134 5064 5097 7972 CAG_5VX1 $T=279000 -259840 0 180 $X=271850 $Y=-264960
X45747 5 4 7972 5108 5063 1217 CAG_5VX1 $T=275640 -268800 0 0 $X=275210 $Y=-269445
X45748 5 4 7425 5128 5124 5136 CAG_5VX1 $T=284040 -179200 0 180 $X=276890 $Y=-184320
X45749 5 4 5136 5127 5147 5166 CAG_5VX1 $T=277880 -188160 1 0 $X=277450 $Y=-193280
X45750 5 4 5160 5187 5131 5140 CAG_5VX1 $T=284600 -98560 1 180 $X=277450 $Y=-99205
X45751 5 4 5158 5119 5137 5145 CAG_5VX1 $T=285160 -161280 1 180 $X=278010 $Y=-161925
X45752 5 4 5145 5103 5144 7425 CAG_5VX1 $T=286280 -170240 1 180 $X=279130 $Y=-170885
X45753 5 4 5159 5149 5146 5162 CAG_5VX1 $T=286280 -134400 0 180 $X=279130 $Y=-139520
X45754 5 4 5166 7409 5143 7423 CAG_5VX1 $T=286840 -197120 0 180 $X=279690 $Y=-202240
X45755 5 4 5175 5154 5150 5160 CAG_5VX1 $T=286840 -80640 0 180 $X=279690 $Y=-85760
X45756 5 4 7423 5079 5165 5157 CAG_5VX1 $T=280680 -215040 1 0 $X=280250 $Y=-220160
X45757 5 4 5138 7422 5186 5159 CAG_5VX1 $T=280680 -125440 1 0 $X=280250 $Y=-130560
X45758 5 4 7432 5112 5155 5164 CAG_5VX1 $T=287960 -62720 0 180 $X=280810 $Y=-67840
X45759 5 4 7438 5134 5118 7428 CAG_5VX1 $T=288520 -259840 0 180 $X=281370 $Y=-264960
X45760 5 4 7436 5174 5163 5138 CAG_5VX1 $T=289080 -116480 1 180 $X=281930 $Y=-117125
X45761 5 4 5164 5167 5180 5175 CAG_5VX1 $T=282920 -71680 1 0 $X=282490 $Y=-76800
X45762 5 4 5162 5130 5148 5158 CAG_5VX1 $T=284600 -152320 0 0 $X=284170 $Y=-152965
X45763 5 4 5140 5139 5179 7436 CAG_5VX1 $T=285720 -107520 0 0 $X=285290 $Y=-108165
X45764 5 4 1230 5172 5190 5177 CAG_5VX1 $T=287960 8960 1 0 $X=287530 $Y=3840
X45765 5 4 5217 5216 5207 7438 CAG_5VX1 $T=297480 -259840 0 180 $X=290330 $Y=-264960
X45766 5 4 5157 5210 7443 5214 CAG_5VX1 $T=291320 -224000 0 0 $X=290890 $Y=-224645
X45767 5 4 7449 5219 7441 5217 CAG_5VX1 $T=298600 -250880 1 180 $X=291450 $Y=-251525
X45768 5 4 5214 5222 5135 5201 CAG_5VX1 $T=299160 -232960 0 180 $X=292010 $Y=-238080
X45769 5 4 5201 5197 5196 7449 CAG_5VX1 $T=293000 -241920 0 0 $X=292570 $Y=-242565
X45770 5 4 5209 5204 1173 1162 CAG_5VX1 $T=293560 -35840 1 0 $X=293130 $Y=-40960
X45771 5 4 7473 5192 1170 1161 CAG_5VX1 $T=305320 -44800 1 180 $X=298170 $Y=-45445
X45772 5 4 5262 1157 5213 1154 CAG_5VX1 $T=307560 -62720 1 180 $X=300410 $Y=-63365
X45773 5 4 5394 5377 5342 5369 CAG_5VX1 $T=337240 -250880 0 180 $X=330090 $Y=-256000
X45774 5 4 5408 5435 5370 5378 CAG_5VX1 $T=338360 -215040 0 180 $X=331210 $Y=-220160
X45775 5 4 5410 5419 5403 5409 CAG_5VX1 $T=343400 -71680 0 180 $X=336250 $Y=-76800
X45776 5 4 5385 5364 5404 5416 CAG_5VX1 $T=338920 -44800 1 0 $X=338490 $Y=-49920
X45777 5 4 5391 5421 5414 5394 CAG_5VX1 $T=346760 -250880 1 180 $X=339610 $Y=-251525
X45778 5 4 5372 7538 5376 5385 CAG_5VX1 $T=346760 -26880 1 180 $X=339610 $Y=-27525
X45779 5 4 5369 5390 5341 7539 CAG_5VX1 $T=340600 -259840 1 0 $X=340170 $Y=-264960
X45780 5 4 5416 5417 5399 5410 CAG_5VX1 $T=341160 -62720 0 0 $X=340730 $Y=-63365
X45781 5 4 1272 5413 5387 5372 CAG_5VX1 $T=341160 -8960 0 0 $X=340730 $Y=-9605
X45782 5 4 7547 5426 5405 5424 CAG_5VX1 $T=348440 -179200 1 180 $X=341290 $Y=-179845
X45783 5 4 5398 7541 5402 5397 CAG_5VX1 $T=348440 -107520 0 180 $X=341290 $Y=-112640
X45784 5 4 5436 5429 5411 5393 CAG_5VX1 $T=349000 -143360 0 180 $X=341850 $Y=-148480
X45785 5 4 5409 5427 5407 5398 CAG_5VX1 $T=343400 -89600 1 0 $X=342970 $Y=-94720
X45786 5 4 5378 5451 5415 5391 CAG_5VX1 $T=343960 -232960 0 0 $X=343530 $Y=-233605
X45787 5 4 5393 5396 5422 7547 CAG_5VX1 $T=343960 -161280 0 0 $X=343530 $Y=-161925
X45788 5 4 5397 7549 7536 5436 CAG_5VX1 $T=346200 -125440 1 0 $X=345770 $Y=-130560
X45789 5 4 5418 5452 7554 5408 CAG_5VX1 $T=354600 -206080 0 180 $X=347450 $Y=-211200
X45790 5 4 5424 5442 5395 5418 CAG_5VX1 $T=347880 -197120 0 0 $X=347450 $Y=-197765
X45791 5 4 1315 1313 5528 5536 CAG_5VX1 $T=371400 8960 0 180 $X=364250 $Y=3840
X45792 5 4 7623 1162 1317 1156 CAG_5VX1 $T=377000 8960 1 180 $X=369850 $Y=8315
X45793 5 4 5612 5615 5627 5631 CAG_5VX1 $T=381480 -26880 1 0 $X=381050 $Y=-32000
X45794 5 4 5613 5585 5628 5612 CAG_5VX1 $T=381480 -17920 1 0 $X=381050 $Y=-23040
X45795 5 4 5536 5544 5623 5613 CAG_5VX1 $T=381480 -8960 1 0 $X=381050 $Y=-14080
X45796 5 4 5647 1326 5639 1325 CAG_5VX1 $T=408360 -259840 0 180 $X=401210 $Y=-264960
X45797 5 4 5667 7660 5648 5647 CAG_5VX1 $T=408360 -250880 1 180 $X=401210 $Y=-251525
X45798 5 4 5650 5658 5674 5649 CAG_5VX1 $T=408360 -224000 1 180 $X=401210 $Y=-224645
X45799 5 4 5633 5640 5659 5650 CAG_5VX1 $T=401640 -206080 1 0 $X=401210 $Y=-211200
X45800 5 4 5651 5634 5641 5633 CAG_5VX1 $T=408360 -188160 0 180 $X=401210 $Y=-193280
X45801 5 4 5652 7659 7670 5651 CAG_5VX1 $T=408360 -179200 1 180 $X=401210 $Y=-179845
X45802 5 4 5657 5660 5642 5652 CAG_5VX1 $T=408360 -161280 1 180 $X=401210 $Y=-161925
X45803 5 4 5681 7651 5643 5635 CAG_5VX1 $T=408360 -125440 0 180 $X=401210 $Y=-130560
X45804 5 4 1513 7661 5676 5653 CAG_5VX1 $T=408360 -80640 1 180 $X=401210 $Y=-81285
X45805 5 4 5649 7662 5645 5667 CAG_5VX1 $T=408920 -232960 1 180 $X=401770 $Y=-233605
X45806 5 4 5635 7657 5661 5657 CAG_5VX1 $T=402200 -152320 0 0 $X=401770 $Y=-152965
X45807 5 4 5653 7658 5662 5644 CAG_5VX1 $T=402200 -89600 1 0 $X=401770 $Y=-94720
X45808 5 4 5638 5637 5663 1513 CAG_5VX1 $T=402200 -62720 0 0 $X=401770 $Y=-63365
X45809 5 4 5631 5646 5664 5638 CAG_5VX1 $T=402200 -44800 0 0 $X=401770 $Y=-45445
X45810 5 4 5644 5636 5666 5681 CAG_5VX1 $T=403320 -107520 1 0 $X=402890 $Y=-112640
X45811 5 4 5748 5744 5768 1516 CAG_5VX1 $T=427960 -53760 1 0 $X=427530 $Y=-58880
X45812 5 4 5730 5771 5779 7709 CAG_5VX1 $T=430760 -71680 0 0 $X=430330 $Y=-72325
X45813 5 4 1351 5739 5763 5775 CAG_5VX1 $T=430760 -44800 1 0 $X=430330 $Y=-49920
X45814 5 4 5791 7713 1352 1355 CAG_5VX1 $T=438040 -250880 0 180 $X=430890 $Y=-256000
X45815 5 4 5772 5769 5786 5783 CAG_5VX1 $T=433000 -170240 1 0 $X=432570 $Y=-175360
X45816 5 4 1349 7712 5743 5787 CAG_5VX1 $T=433560 -35840 1 0 $X=433130 $Y=-40960
X45817 5 4 1353 5805 5794 5788 CAG_5VX1 $T=434120 0 1 0 $X=433690 $Y=-5120
X45818 5 4 5764 5770 5765 7717 CAG_5VX1 $T=435240 -125440 0 0 $X=434810 $Y=-126085
X45819 5 4 5793 5795 5762 5802 CAG_5VX1 $T=437480 -143360 0 0 $X=437050 $Y=-144005
X45820 5 4 5777 5834 5800 5820 CAG_5VX1 $T=441400 -206080 1 0 $X=440970 $Y=-211200
X45821 5 4 5774 5822 5812 7736 CAG_5VX1 $T=443080 -107520 1 0 $X=442650 $Y=-112640
X45822 5 4 5809 5806 5807 5828 CAG_5VX1 $T=443080 -98560 0 0 $X=442650 $Y=-99205
X45823 5 4 5803 5813 5804 5832 CAG_5VX1 $T=444200 -143360 0 0 $X=443770 $Y=-144005
X45824 5 4 5746 7734 1372 5836 CAG_5VX1 $T=445320 -224000 0 0 $X=444890 $Y=-224645
X45825 5 4 5890 5877 5854 7749 CAG_5VX1 $T=455400 -179200 1 180 $X=448250 $Y=-179845
X45826 5 4 7752 5889 5875 7748 CAG_5VX1 $T=451480 -44800 1 0 $X=451050 $Y=-49920
X45827 5 4 7747 5867 5858 5851 CAG_5VX1 $T=452600 -71680 1 0 $X=452170 $Y=-76800
X45828 5 4 7749 5876 5879 5865 CAG_5VX1 $T=454280 -197120 1 0 $X=453850 $Y=-202240
X45829 5 4 5827 5860 7764 5831 CAG_5VX1 $T=455960 -241920 0 0 $X=455530 $Y=-242565
X45830 5 4 5919 5855 7761 5890 CAG_5VX1 $T=463240 -161280 0 180 $X=456090 $Y=-166400
X45831 5 4 5885 5893 5881 7767 CAG_5VX1 $T=458200 -134400 1 0 $X=457770 $Y=-139520
X45832 5 4 5767 1381 1392 5864 CAG_5VX1 $T=461000 -250880 1 0 $X=460570 $Y=-256000
X45833 5 4 5878 5924 5929 7741 CAG_5VX1 $T=462680 -26880 0 0 $X=462250 $Y=-27525
X45834 5 4 7778 5935 5945 5902 CAG_5VX1 $T=466600 -125440 1 0 $X=466170 $Y=-130560
X45835 5 4 5911 5942 5953 5950 CAG_5VX1 $T=468840 -152320 1 0 $X=468410 $Y=-157440
X45836 5 4 7982 5947 5946 1521 CAG_5VX1 $T=469400 -53760 1 0 $X=468970 $Y=-58880
X45837 5 4 1407 5930 5984 5983 CAG_5VX1 $T=478920 8960 0 0 $X=478490 $Y=8315
X45838 5 4 5983 6038 5977 6003 CAG_5VX1 $T=480600 -8960 0 0 $X=480170 $Y=-9605
X45839 5 4 1525 6002 6000 6007 CAG_5VX1 $T=481720 -161280 1 0 $X=481290 $Y=-166400
X45840 5 4 6000 5934 5999 6010 CAG_5VX1 $T=482280 -197120 1 0 $X=481850 $Y=-202240
X45841 5 4 6003 6015 5944 7813 CAG_5VX1 $T=489000 -17920 0 180 $X=481850 $Y=-23040
X45842 5 4 5972 7819 7822 1123 CAG_5VX1 $T=483960 -179200 0 0 $X=483530 $Y=-179845
X45843 5 4 7824 5965 6004 6011 CAG_5VX1 $T=490680 -62720 1 180 $X=483530 $Y=-63365
X45844 5 4 6006 6013 1404 5988 CAG_5VX1 $T=485080 -232960 0 0 $X=484650 $Y=-233605
X45845 5 4 7813 5995 5927 7824 CAG_5VX1 $T=485080 -44800 0 0 $X=484650 $Y=-45445
X45846 5 4 6011 6021 6014 6074 CAG_5VX1 $T=486760 -80640 0 0 $X=486330 $Y=-81285
X45847 5 4 1409 6052 6019 6025 CAG_5VX1 $T=497960 -17920 1 180 $X=490810 $Y=-18565
X45848 5 4 6055 5986 6020 6037 CAG_5VX1 $T=499640 -116480 0 180 $X=492490 $Y=-121600
X45849 5 4 6025 6066 6028 6041 CAG_5VX1 $T=492920 -35840 1 0 $X=492490 $Y=-40960
X45850 5 4 6037 7832 5901 5919 CAG_5VX1 $T=494600 -143360 1 0 $X=494170 $Y=-148480
X45851 5 4 6087 6075 6062 6069 CAG_5VX1 $T=501880 -197120 1 180 $X=494730 $Y=-197765
X45852 5 4 6050 6044 5936 6055 CAG_5VX1 $T=501880 -89600 0 180 $X=494730 $Y=-94720
X45853 5 4 6063 6087 6046 6073 CAG_5VX1 $T=502440 -179200 0 180 $X=495290 $Y=-184320
X45854 5 4 6079 6051 6017 6071 CAG_5VX1 $T=503000 -71680 1 180 $X=495850 $Y=-72325
X45855 5 4 6041 6077 6056 6079 CAG_5VX1 $T=497400 -53760 1 0 $X=496970 $Y=-58880
X45856 5 4 6064 6083 7834 6063 CAG_5VX1 $T=504680 -170240 1 180 $X=497530 $Y=-170885
X45857 5 4 6071 6078 6061 6050 CAG_5VX1 $T=497960 -80640 1 0 $X=497530 $Y=-85760
X45858 5 4 6074 6085 6032 7840 CAG_5VX1 $T=499640 -98560 0 0 $X=499210 $Y=-99205
X45859 5 4 6093 7839 6065 6088 CAG_5VX1 $T=506920 -134400 1 180 $X=499770 $Y=-135045
X45860 5 4 6081 6070 6099 6093 CAG_5VX1 $T=500200 -116480 1 0 $X=499770 $Y=-121600
X45861 5 4 6088 6076 6049 6064 CAG_5VX1 $T=502440 -152320 0 0 $X=502010 $Y=-152965
X45862 5 4 7840 6094 6082 6081 CAG_5VX1 $T=504120 -107520 1 0 $X=503690 $Y=-112640
X45863 5 4 6118 6112 6106 7850 CAG_5VX1 $T=511400 -241920 1 180 $X=504250 $Y=-242565
X45864 5 4 6114 6147 7851 6118 CAG_5VX1 $T=511960 -224000 0 180 $X=504810 $Y=-229120
X45865 5 4 7867 6105 6096 1420 CAG_5VX1 $T=513080 -259840 0 180 $X=505930 $Y=-264960
X45866 5 4 6069 7890 7855 6114 CAG_5VX1 $T=513080 -215040 0 180 $X=505930 $Y=-220160
X45867 5 4 7850 6117 6068 7867 CAG_5VX1 $T=508600 -250880 1 0 $X=508170 $Y=-256000
X45868 5 4 1909 1824 6326 6323 OA21_5VX1 $T=-424360 -53760 0 180 $X=-429830 $Y=-58880
X45869 5 4 2492 2526 79 2513 OA21_5VX1 $T=-288840 -125440 0 0 $X=-289270 $Y=-126080
X45870 5 4 2589 2566 1447 2550 OA21_5VX1 $T=-272600 -98560 0 180 $X=-278070 $Y=-103680
X45871 5 4 2827 6662 2830 6657 OA21_5VX1 $T=-208200 -188160 0 180 $X=-213670 $Y=-193280
X45872 5 4 6668 2880 6673 2856 OA21_5VX1 $T=-209320 -170240 0 0 $X=-209750 $Y=-170880
X45873 5 4 3499 3505 3514 3522 OA21_5VX1 $T=-67640 -62720 0 0 $X=-68070 $Y=-63360
X45874 5 4 6902 3537 3516 612 OA21_5VX1 $T=-60360 -8960 0 180 $X=-65830 $Y=-14080
X45875 5 4 752 3864 747 3848 OA21_5VX1 $T=11880 8960 0 180 $X=6410 $Y=3840
X45876 5 4 1383 5856 5904 5922 OA21_5VX1 $T=458760 -35840 1 0 $X=458330 $Y=-40960
X45877 5 4 1723 1705 1687 6254 EN3_5VX1 $T=-460760 0 0 180 $X=-473510 $Y=-5120
X45878 5 4 6282 1709 1678 1669 EN3_5VX1 $T=-460200 -17920 0 180 $X=-472950 $Y=-23040
X45879 5 4 1707 1718 1685 1691 EN3_5VX1 $T=-458520 -44800 1 180 $X=-471270 $Y=-45440
X45880 5 4 1708 1698 1704 8005 EN3_5VX1 $T=-454600 -35840 1 180 $X=-467350 $Y=-36480
X45881 5 4 6285 1749 1710 38 EN3_5VX1 $T=-454040 8960 0 180 $X=-466790 $Y=3840
X45882 5 4 1728 1800 1720 7936 EN3_5VX1 $T=-453480 -89600 1 180 $X=-466230 $Y=-90240
X45883 5 4 1721 1729 6278 8006 EN3_5VX1 $T=-452920 -71680 1 180 $X=-465670 $Y=-72320
X45884 5 4 1743 1733 1727 6276 EN3_5VX1 $T=-450120 -125440 1 180 $X=-462870 $Y=-126080
X45885 5 4 1770 1777 1744 6277 EN3_5VX1 $T=-450120 -107520 1 180 $X=-462870 $Y=-108160
X45886 5 4 1745 1760 1734 6262 EN3_5VX1 $T=-450120 -8960 0 180 $X=-462870 $Y=-14080
X45887 5 4 1740 1759 1748 1662 EN3_5VX1 $T=-447320 -26880 1 180 $X=-460070 $Y=-27520
X45888 5 4 1753 1768 1758 1701 EN3_5VX1 $T=-445640 -53760 0 180 $X=-458390 $Y=-58880
X45889 5 4 1766 1775 1762 8007 EN3_5VX1 $T=-445080 -143360 1 180 $X=-457830 $Y=-144000
X45890 5 4 1791 1804 1769 6286 EN3_5VX1 $T=-443960 -161280 1 180 $X=-456710 $Y=-161920
X45891 5 4 1773 1779 1763 1670 EN3_5VX1 $T=-443400 -62720 0 180 $X=-456150 $Y=-67840
X45892 5 4 1778 1785 1772 6261 EN3_5VX1 $T=-442840 -80640 1 180 $X=-455590 $Y=-81280
X45893 5 4 1792 1798 1789 1697 EN3_5VX1 $T=-441160 -89600 1 180 $X=-453910 $Y=-90240
X45894 5 4 1811 1814 1793 1703 EN3_5VX1 $T=-440040 -125440 0 180 $X=-452790 $Y=-130560
X45895 5 4 6301 1825 1796 8008 EN3_5VX1 $T=-439480 -152320 1 180 $X=-452230 $Y=-152960
X45896 5 4 1794 1822 1805 1695 EN3_5VX1 $T=-437800 -107520 1 180 $X=-450550 $Y=-108160
X45897 5 4 1445 1834 1808 6294 EN3_5VX1 $T=-436680 -161280 0 180 $X=-449430 $Y=-166400
X45898 5 4 1829 1828 1810 6291 EN3_5VX1 $T=-436120 -170240 0 180 $X=-448870 $Y=-175360
X45899 5 4 1858 1848 1817 6288 EN3_5VX1 $T=-434440 -188160 1 180 $X=-447190 $Y=-188800
X45900 5 4 1862 54 51 6299 EN3_5VX1 $T=-432760 -53760 0 180 $X=-445510 $Y=-58880
X45901 5 4 1866 1884 1855 8009 EN3_5VX1 $T=-427720 -197120 0 180 $X=-440470 $Y=-202240
X45902 5 4 1880 1902 58 1850 EN3_5VX1 $T=-426040 -116480 0 180 $X=-438790 $Y=-121600
X45903 5 4 1888 1901 1836 6311 EN3_5VX1 $T=-423800 -215040 0 180 $X=-436550 $Y=-220160
X45904 5 4 1908 69 1877 6309 EN3_5VX1 $T=-423240 0 1 180 $X=-435990 $Y=-640
X45905 5 4 1899 1867 1889 1847 EN3_5VX1 $T=-421560 -188160 1 180 $X=-434310 $Y=-188800
X45906 5 4 1913 1918 1864 6318 EN3_5VX1 $T=-420440 -232960 1 180 $X=-433190 $Y=-233600
X45907 5 4 1947 1452 1900 1878 EN3_5VX1 $T=-419880 -161280 1 180 $X=-432630 $Y=-161920
X45908 5 4 1924 1927 1898 6327 EN3_5VX1 $T=-417080 -241920 0 180 $X=-429830 $Y=-247040
X45909 5 4 1953 1950 1912 1915 EN3_5VX1 $T=-415960 -259840 1 180 $X=-428710 $Y=-260480
X45910 5 4 1981 1939 1969 6354 EN3_5VX1 $T=-421000 -197120 1 0 $X=-421430 $Y=-202240
X45911 5 4 1977 1447 1462 1929 EN3_5VX1 $T=-404760 -161280 1 180 $X=-417510 $Y=-161920
X45912 5 4 6367 45 90 1860 EN3_5VX1 $T=-404200 0 0 180 $X=-416950 $Y=-5120
X45913 5 4 2011 2009 1982 1978 EN3_5VX1 $T=-399160 -125440 1 180 $X=-411910 $Y=-126080
X45914 5 4 1993 6378 1999 1985 EN3_5VX1 $T=-398600 -206080 1 180 $X=-411350 $Y=-206720
X45915 5 4 1450 6379 6374 6347 EN3_5VX1 $T=-395800 -143360 0 180 $X=-408550 $Y=-148480
X45916 5 4 1979 1983 1961 6368 EN3_5VX1 $T=-395800 -98560 0 180 $X=-408550 $Y=-103680
X45917 5 4 2005 1985 1989 2031 EN3_5VX1 $T=-405320 -215040 0 0 $X=-405750 $Y=-215680
X45918 5 4 2022 1987 2023 2096 EN3_5VX1 $T=-400840 -259840 0 0 $X=-401270 $Y=-260480
X45919 5 4 2025 92 84 2044 EN3_5VX1 $T=-400280 -188160 0 0 $X=-400710 $Y=-188800
X45920 5 4 2030 2056 2043 6370 EN3_5VX1 $T=-386840 -232960 1 180 $X=-399590 $Y=-233600
X45921 5 4 6398 89 79 2000 EN3_5VX1 $T=-384600 -161280 1 180 $X=-397350 $Y=-161920
X45922 5 4 2050 2069 2028 2112 EN3_5VX1 $T=-394680 -44800 1 0 $X=-395110 $Y=-49920
X45923 5 4 2067 2079 2068 2196 EN3_5VX1 $T=-390760 -62720 1 0 $X=-391190 $Y=-67840
X45924 5 4 2078 6404 2084 2145 EN3_5VX1 $T=-389080 -80640 0 0 $X=-389510 $Y=-81280
X45925 5 4 2058 2092 2033 2140 EN3_5VX1 $T=-388520 -125440 1 0 $X=-388950 $Y=-130560
X45926 5 4 2109 2093 2060 8011 EN3_5VX1 $T=-386840 -98560 0 0 $X=-387270 $Y=-99200
X45927 5 4 2150 2137 2113 6420 EN3_5VX1 $T=-373400 0 0 180 $X=-386150 $Y=-5120
X45928 5 4 2114 2106 2131 8012 EN3_5VX1 $T=-382920 -143360 1 0 $X=-383350 $Y=-148480
X45929 5 4 2132 2099 2055 8013 EN3_5VX1 $T=-382920 8960 1 0 $X=-383350 $Y=3840
X45930 5 4 2110 2070 2129 6424 EN3_5VX1 $T=-382360 -35840 0 0 $X=-382790 $Y=-36480
X45931 5 4 2081 2082 2048 2149 EN3_5VX1 $T=-381800 -116480 0 0 $X=-382230 $Y=-117120
X45932 5 4 2117 2133 2144 6426 EN3_5VX1 $T=-381240 -161280 1 0 $X=-381670 $Y=-166400
X45933 5 4 2119 2136 2178 6428 EN3_5VX1 $T=-381240 -17920 0 0 $X=-381670 $Y=-18560
X45934 5 4 6418 2143 2130 2164 EN3_5VX1 $T=-373960 -179200 0 0 $X=-374390 $Y=-179840
X45935 5 4 2211 2227 2248 2262 EN3_5VX1 $T=-348200 -224000 0 0 $X=-348630 $Y=-224640
X45936 5 4 2212 2228 2127 6456 EN3_5VX1 $T=-348200 -197120 0 0 $X=-348630 $Y=-197760
X45937 5 4 2194 2168 2179 6459 EN3_5VX1 $T=-345960 -179200 1 0 $X=-346390 $Y=-184320
X45938 5 4 6449 2245 2233 8016 EN3_5VX1 $T=-345400 -215040 1 0 $X=-345830 $Y=-220160
X45939 5 4 2299 1457 2288 6471 EN3_5VX1 $T=-321320 -98560 0 180 $X=-334070 $Y=-103680
X45940 5 4 2289 2322 2300 6474 EN3_5VX1 $T=-317960 -80640 0 180 $X=-330710 $Y=-85760
X45941 5 4 2306 2324 2301 6469 EN3_5VX1 $T=-317960 -71680 1 180 $X=-330710 $Y=-72320
X45942 5 4 2307 2312 2325 2284 EN3_5VX1 $T=-317960 -44800 0 180 $X=-330710 $Y=-49920
X45943 5 4 2296 2340 6487 2257 EN3_5VX1 $T=-315160 -35840 0 180 $X=-327910 $Y=-40960
X45944 5 4 2315 141 100 6498 EN3_5VX1 $T=-326920 -232960 1 0 $X=-327350 $Y=-238080
X45945 5 4 2352 2345 6489 2283 EN3_5VX1 $T=-312360 -116480 1 180 $X=-325110 $Y=-117120
X45946 5 4 2372 2359 2264 8014 EN3_5VX1 $T=-312360 -8960 1 180 $X=-325110 $Y=-9600
X45947 5 4 2353 2293 186 8015 EN3_5VX1 $T=-312360 8960 0 180 $X=-325110 $Y=3840
X45948 5 4 2308 2333 2302 6486 EN3_5VX1 $T=-311240 -26880 0 180 $X=-323990 $Y=-32000
X45949 5 4 2365 2369 2344 2313 EN3_5VX1 $T=-308440 -152320 0 180 $X=-321190 $Y=-157440
X45950 5 4 2394 2391 2357 2344 EN3_5VX1 $T=-307880 -143360 1 180 $X=-320630 $Y=-144000
X45951 5 4 2355 2367 6497 6493 EN3_5VX1 $T=-307880 -134400 1 180 $X=-320630 $Y=-135040
X45952 5 4 2383 2390 2376 2364 EN3_5VX1 $T=-303400 -161280 0 180 $X=-316150 $Y=-166400
X45953 5 4 2409 58 59 2357 EN3_5VX1 $T=-295560 -143360 0 180 $X=-308310 $Y=-148480
X45954 5 4 6506 2415 2451 2376 EN3_5VX1 $T=-306760 -152320 1 0 $X=-307190 $Y=-157440
X45955 5 4 2429 79 80 6513 EN3_5VX1 $T=-293880 -197120 0 180 $X=-306630 $Y=-202240
X45956 5 4 79 2427 1452 6529 EN3_5VX1 $T=-304520 -107520 0 0 $X=-304950 $Y=-108160
X45957 5 4 1841 2483 48 2421 EN3_5VX1 $T=-291080 -17920 0 180 $X=-303830 $Y=-23040
X45958 5 4 80 2456 1462 2515 EN3_5VX1 $T=-298360 -98560 0 0 $X=-298790 $Y=-99200
X45959 5 4 1447 2477 1900 2498 EN3_5VX1 $T=-294440 -89600 0 0 $X=-294870 $Y=-90240
X45960 5 4 2519 1841 58 2451 EN3_5VX1 $T=-281560 -143360 0 180 $X=-294310 $Y=-148480
X45961 5 4 1462 2447 58 6552 EN3_5VX1 $T=-288280 -53760 1 0 $X=-288710 $Y=-58880
X45962 5 4 2511 1841 58 2570 EN3_5VX1 $T=-286040 -62720 1 0 $X=-286470 $Y=-67840
X45963 5 4 2529 1452 1462 2571 EN3_5VX1 $T=-283800 -125440 1 0 $X=-284230 $Y=-130560
X45964 5 4 2542 58 59 2605 EN3_5VX1 $T=-281000 -53760 0 0 $X=-281430 $Y=-54400
X45965 5 4 58 48 47 232 EN3_5VX1 $T=-267000 8960 1 180 $X=-279750 $Y=8320
X45966 5 4 2551 59 48 6574 EN3_5VX1 $T=-277640 -26880 1 0 $X=-278070 $Y=-32000
X45967 5 4 233 48 47 6575 EN3_5VX1 $T=-277640 -8960 0 0 $X=-278070 $Y=-9600
X45968 5 4 2560 2545 2507 8017 EN3_5VX1 $T=-275400 -259840 1 0 $X=-275830 $Y=-264960
X45969 5 4 2561 2535 2562 2601 EN3_5VX1 $T=-275400 -71680 0 0 $X=-275830 $Y=-72320
X45970 5 4 241 245 2593 8018 EN3_5VX1 $T=-272040 -268800 1 0 $X=-272470 $Y=-273920
X45971 5 4 2616 1462 1900 6567 EN3_5VX1 $T=-259720 -98560 0 180 $X=-272470 $Y=-103680
X45972 5 4 2504 6561 2588 2576 EN3_5VX1 $T=-271480 -125440 1 0 $X=-271910 $Y=-130560
X45973 5 4 2603 2567 2573 2625 EN3_5VX1 $T=-269800 -224000 1 0 $X=-270230 $Y=-229120
X45974 5 4 2586 2538 2630 6583 EN3_5VX1 $T=-269800 -224000 0 0 $X=-270230 $Y=-224640
X45975 5 4 2592 2631 2617 2651 EN3_5VX1 $T=-269240 -161280 1 0 $X=-269670 $Y=-166400
X45976 5 4 2594 2568 2610 2633 EN3_5VX1 $T=-268680 -206080 0 0 $X=-269110 $Y=-206720
X45977 5 4 6569 2591 2609 6596 EN3_5VX1 $T=-267560 -250880 1 0 $X=-267990 $Y=-256000
X45978 5 4 2607 2600 2613 6592 EN3_5VX1 $T=-267000 -188160 1 0 $X=-267430 $Y=-193280
X45979 5 4 2579 1900 1841 6594 EN3_5VX1 $T=-267000 -80640 0 0 $X=-267430 $Y=-81280
X45980 5 4 2602 2554 2622 2628 EN3_5VX1 $T=-266440 -241920 0 0 $X=-266870 $Y=-242560
X45981 5 4 2611 1462 1900 2709 EN3_5VX1 $T=-264200 -170240 0 0 $X=-264630 $Y=-170880
X45982 5 4 6605 2674 2645 6582 EN3_5VX1 $T=-247960 -125440 1 180 $X=-260710 $Y=-126080
X45983 5 4 2614 2587 6601 2667 EN3_5VX1 $T=-258040 -152320 1 0 $X=-258470 $Y=-157440
X45984 5 4 2685 2662 6603 6608 EN3_5VX1 $T=-258040 -98560 1 0 $X=-258470 $Y=-103680
X45985 5 4 2707 2714 2667 6587 EN3_5VX1 $T=-244600 -161280 0 180 $X=-257350 $Y=-166400
X45986 5 4 6591 2569 2672 2694 EN3_5VX1 $T=-255240 -143360 1 0 $X=-255670 $Y=-148480
X45987 5 4 240 47 54 2648 EN3_5VX1 $T=-242920 8960 1 180 $X=-255670 $Y=8320
X45988 5 4 6599 2663 2680 2692 EN3_5VX1 $T=-253000 -89600 0 0 $X=-253430 $Y=-90240
X45989 5 4 2653 1447 1452 2735 EN3_5VX1 $T=-252440 -232960 0 0 $X=-252870 $Y=-233600
X45990 5 4 2679 2640 2709 2727 EN3_5VX1 $T=-251880 -170240 1 0 $X=-252310 $Y=-175360
X45991 5 4 2664 2669 2721 2718 EN3_5VX1 $T=-250200 -35840 0 0 $X=-250630 $Y=-36480
X45992 5 4 2720 2641 2726 2754 EN3_5VX1 $T=-249080 -197120 1 0 $X=-249510 $Y=-202240
X45993 5 4 2696 2686 2608 8019 EN3_5VX1 $T=-248520 -8960 0 0 $X=-248950 $Y=-9600
X45994 5 4 2697 2701 2727 6624 EN3_5VX1 $T=-247960 -188160 0 0 $X=-248390 $Y=-188800
X45995 5 4 1464 2676 2724 6625 EN3_5VX1 $T=-247960 -17920 1 0 $X=-248390 $Y=-23040
X45996 5 4 6606 2703 2693 6629 EN3_5VX1 $T=-245160 -53760 1 0 $X=-245590 $Y=-58880
X45997 5 4 2716 6621 2754 6630 EN3_5VX1 $T=-242920 -215040 0 0 $X=-243350 $Y=-215680
X45998 5 4 294 284 313 319 EN3_5VX1 $T=-241800 0 0 0 $X=-242230 $Y=-640
X45999 5 4 2730 2725 2769 2793 EN3_5VX1 $T=-239560 -250880 0 0 $X=-239990 $Y=-251520
X46000 5 4 2731 2740 2735 2769 EN3_5VX1 $T=-238440 -232960 1 0 $X=-238870 $Y=-238080
X46001 5 4 332 141 137 2733 EN3_5VX1 $T=-223880 -268800 0 180 $X=-236630 $Y=-273920
X46002 5 4 325 2739 339 6654 EN3_5VX1 $T=-227240 -268800 0 0 $X=-227670 $Y=-269440
X46003 5 4 100 2804 89 6660 EN3_5VX1 $T=-227240 -188160 1 0 $X=-227670 $Y=-193280
X46004 5 4 1841 59 2869 6667 EN3_5VX1 $T=-223320 -8960 1 0 $X=-223750 $Y=-14080
X46005 5 4 2802 2841 84 2890 EN3_5VX1 $T=-220520 -224000 1 0 $X=-220950 $Y=-229120
X46006 5 4 343 100 89 2913 EN3_5VX1 $T=-218280 -259840 1 0 $X=-218710 $Y=-264960
X46007 5 4 2845 2860 89 6672 EN3_5VX1 $T=-217720 -241920 0 0 $X=-218150 $Y=-242560
X46008 5 4 2870 92 84 6652 EN3_5VX1 $T=-204840 -161280 0 180 $X=-217590 $Y=-166400
X46009 5 4 346 79 2913 2923 EN3_5VX1 $T=-212120 -268800 0 0 $X=-212550 $Y=-269440
X46010 5 4 2864 80 1452 6681 EN3_5VX1 $T=-208200 -224000 1 0 $X=-208630 $Y=-229120
X46011 5 4 2888 2924 6681 2957 EN3_5VX1 $T=-204840 -232960 1 0 $X=-205270 $Y=-238080
X46012 5 4 2879 1447 1462 2936 EN3_5VX1 $T=-204840 -215040 1 0 $X=-205270 $Y=-220160
X46013 5 4 2926 51 55 6685 EN3_5VX1 $T=-201480 -26880 1 0 $X=-201910 $Y=-32000
X46014 5 4 363 364 2951 379 EN3_5VX1 $T=-199800 -268800 0 0 $X=-200230 $Y=-269440
X46015 5 4 6677 1841 59 2987 EN3_5VX1 $T=-199240 -143360 0 0 $X=-199670 $Y=-144000
X46016 5 4 2930 45 90 3014 EN3_5VX1 $T=-198680 -17920 0 0 $X=-199110 $Y=-18560
X46017 5 4 2955 2966 2971 6695 EN3_5VX1 $T=-195880 -179200 1 0 $X=-196310 $Y=-184320
X46018 5 4 2958 2956 2996 8021 EN3_5VX1 $T=-194760 -170240 0 0 $X=-195190 $Y=-170880
X46019 5 4 2978 6684 2999 8023 EN3_5VX1 $T=-194200 -224000 0 0 $X=-194630 $Y=-224640
X46020 5 4 2952 3004 2986 8026 EN3_5VX1 $T=-193080 -241920 0 0 $X=-193510 $Y=-242560
X46021 5 4 2965 6686 3005 3022 EN3_5VX1 $T=-193080 -206080 0 0 $X=-193510 $Y=-206720
X46022 5 4 2964 2893 2957 6697 EN3_5VX1 $T=-191960 -250880 0 0 $X=-192390 $Y=-251520
X46023 5 4 2967 2984 2987 2996 EN3_5VX1 $T=-191960 -161280 0 0 $X=-192390 $Y=-161920
X46024 5 4 2981 6687 3019 6696 EN3_5VX1 $T=-190840 -98560 0 0 $X=-191270 $Y=-99200
X46025 5 4 3032 3025 3042 2977 EN3_5VX1 $T=-178520 -26880 1 180 $X=-191270 $Y=-27520
X46026 5 4 2947 368 2780 3029 EN3_5VX1 $T=-190280 -259840 1 0 $X=-190710 $Y=-264960
X46027 5 4 2983 2997 6693 6703 EN3_5VX1 $T=-189720 -62720 0 0 $X=-190150 $Y=-63360
X46028 5 4 374 377 392 6708 EN3_5VX1 $T=-189720 8960 0 0 $X=-190150 $Y=8320
X46029 5 4 2985 3006 3009 6694 EN3_5VX1 $T=-189160 -143360 1 0 $X=-189590 $Y=-148480
X46030 5 4 2988 3007 3011 3027 EN3_5VX1 $T=-187480 -116480 0 0 $X=-187910 $Y=-117120
X46031 5 4 2991 6688 6685 3031 EN3_5VX1 $T=-187480 -35840 0 0 $X=-187910 $Y=-36480
X46032 5 4 3024 6692 3031 6706 EN3_5VX1 $T=-186920 -44800 0 0 $X=-187350 $Y=-45440
X46033 5 4 3013 3012 3021 6710 EN3_5VX1 $T=-186360 -71680 1 0 $X=-186790 $Y=-76800
X46034 5 4 2980 2968 3035 6713 EN3_5VX1 $T=-185800 -134400 0 0 $X=-186230 $Y=-135040
X46035 5 4 2992 2935 3014 3042 EN3_5VX1 $T=-185800 -17920 0 0 $X=-186230 $Y=-18560
X46036 5 4 3008 6690 3015 6714 EN3_5VX1 $T=-185800 0 1 0 $X=-186230 $Y=-5120
X46037 5 4 1476 3265 3232 3124 EN3_5VX1 $T=-130920 -232960 1 180 $X=-143670 $Y=-233600
X46038 5 4 1475 3212 3207 6739 EN3_5VX1 $T=-130360 -125440 1 180 $X=-143110 $Y=-126080
X46039 5 4 3268 3242 3206 6766 EN3_5VX1 $T=-129800 -134400 1 180 $X=-142550 $Y=-135040
X46040 5 4 3252 3233 6774 3173 EN3_5VX1 $T=-129800 -98560 1 180 $X=-142550 $Y=-99200
X46041 5 4 3251 6782 3213 8079 EN3_5VX1 $T=-129240 -107520 1 180 $X=-141990 $Y=-108160
X46042 5 4 3198 3210 3217 6768 EN3_5VX1 $T=-128680 -179200 1 180 $X=-141430 $Y=-179840
X46043 5 4 3284 6794 3241 6746 EN3_5VX1 $T=-123640 -206080 0 180 $X=-136390 $Y=-211200
X46044 5 4 3285 3282 3250 8080 EN3_5VX1 $T=-121400 -188160 0 180 $X=-134150 $Y=-193280
X46045 5 4 3238 3236 3239 3221 EN3_5VX1 $T=-118600 -26880 0 180 $X=-131350 $Y=-32000
X46046 5 4 3328 3337 3369 3387 EN3_5VX1 $T=-97880 -116480 0 0 $X=-98310 $Y=-117120
X46047 5 4 3376 6827 3371 3413 EN3_5VX1 $T=-93960 -26880 1 0 $X=-94390 $Y=-32000
X46048 5 4 579 574 3381 6840 EN3_5VX1 $T=-78280 -268800 1 180 $X=-91030 $Y=-269440
X46049 5 4 3398 3374 3378 3326 EN3_5VX1 $T=-76040 -250880 1 180 $X=-88790 $Y=-251520
X46050 5 4 3400 3434 3405 8036 EN3_5VX1 $T=-72680 -224000 0 180 $X=-85430 $Y=-229120
X46051 5 4 3396 3359 3425 6886 EN3_5VX1 $T=-85000 -170240 1 0 $X=-85430 $Y=-175360
X46052 5 4 3418 3493 3456 6854 EN3_5VX1 $T=-70440 -206080 1 180 $X=-83190 $Y=-206720
X46053 5 4 577 3354 3348 3429 EN3_5VX1 $T=-81640 -152320 0 0 $X=-82070 $Y=-152960
X46054 5 4 3487 3473 3435 6856 EN3_5VX1 $T=-68760 -188160 1 180 $X=-81510 $Y=-188800
X46055 5 4 6876 3474 3442 3462 EN3_5VX1 $T=-67640 -179200 0 180 $X=-80390 $Y=-184320
X46056 5 4 3419 3464 3476 6889 EN3_5VX1 $T=-79400 -107520 0 0 $X=-79830 $Y=-108160
X46057 5 4 3431 3444 6883 3466 EN3_5VX1 $T=-78840 -71680 1 0 $X=-79270 $Y=-76800
X46058 5 4 6892 3454 3510 3437 EN3_5VX1 $T=-66520 -35840 1 180 $X=-79270 $Y=-36480
X46059 5 4 3403 3438 3445 3467 EN3_5VX1 $T=-63720 -17920 0 180 $X=-76470 $Y=-23040
X46060 5 4 3517 603 3486 3446 EN3_5VX1 $T=-63720 -8960 1 180 $X=-76470 $Y=-9600
X46061 5 4 6898 3520 3527 3391 EN3_5VX1 $T=-61480 -161280 0 180 $X=-74230 $Y=-166400
X46062 5 4 3448 3519 3495 8083 EN3_5VX1 $T=-58680 -197120 1 180 $X=-71430 $Y=-197760
X46063 5 4 3512 3542 611 6876 EN3_5VX1 $T=-56440 -170240 0 180 $X=-69190 $Y=-175360
X46064 5 4 3548 3567 3543 622 EN3_5VX1 $T=-50280 -152320 1 180 $X=-63030 $Y=-152960
X46065 5 4 1496 3547 625 3428 EN3_5VX1 $T=-49720 -206080 1 180 $X=-62470 $Y=-206720
X46066 5 4 3620 595 586 3566 EN3_5VX1 $T=-43000 -224000 1 180 $X=-55750 $Y=-224640
X46067 5 4 656 632 592 1481 EN3_5VX1 $T=-39640 -250880 0 180 $X=-52390 $Y=-256000
X46068 5 4 658 592 595 3588 EN3_5VX1 $T=-39080 -241920 1 180 $X=-51830 $Y=-242560
X46069 5 4 3570 1496 625 3542 EN3_5VX1 $T=-39080 -179200 0 180 $X=-51830 $Y=-184320
X46070 5 4 607 620 3589 3658 EN3_5VX1 $T=-46920 -35840 1 0 $X=-47350 $Y=-40960
X46071 5 4 3612 3639 3609 3452 EN3_5VX1 $T=-32360 -134400 0 180 $X=-45110 $Y=-139520
X46072 5 4 3632 3626 3618 3430 EN3_5VX1 $T=-31800 -116480 0 180 $X=-44550 $Y=-121600
X46073 5 4 668 3645 6943 6939 EN3_5VX1 $T=-27880 -250880 1 180 $X=-40630 $Y=-251520
X46074 5 4 3642 3674 6945 6864 EN3_5VX1 $T=-25640 -98560 1 180 $X=-38390 $Y=-99200
X46075 5 4 3693 586 624 6935 EN3_5VX1 $T=-24520 -197120 0 180 $X=-37270 $Y=-202240
X46076 5 4 3701 624 584 3641 EN3_5VX1 $T=-22840 -179200 0 180 $X=-35590 $Y=-184320
X46077 5 4 3657 3653 6951 3643 EN3_5VX1 $T=-22840 -80640 1 180 $X=-35590 $Y=-81280
X46078 5 4 3679 3684 3664 3384 EN3_5VX1 $T=-22840 -62720 0 180 $X=-35590 $Y=-67840
X46079 5 4 3691 3694 3668 3370 EN3_5VX1 $T=-22280 -53760 0 180 $X=-35030 $Y=-58880
X46080 5 4 3649 3644 3654 3373 EN3_5VX1 $T=-21160 -8960 1 180 $X=-33910 $Y=-9600
X46081 5 4 3680 3686 3675 3433 EN3_5VX1 $T=-16120 -26880 1 180 $X=-28870 $Y=-27520
X46082 5 4 3669 3665 3685 3421 EN3_5VX1 $T=-14440 -35840 1 180 $X=-27190 $Y=-36480
X46083 5 4 3724 3723 3762 3770 EN3_5VX1 $T=-18360 -179200 1 0 $X=-18790 $Y=-184320
X46084 5 4 3737 3504 625 6972 EN3_5VX1 $T=-3800 -98560 0 180 $X=-16550 $Y=-103680
X46085 5 4 3754 1496 3504 3741 EN3_5VX1 $T=-2680 -116480 0 180 $X=-15430 $Y=-121600
X46086 5 4 3800 6976 3736 3744 EN3_5VX1 $T=-2120 -179200 1 180 $X=-14870 $Y=-179840
X46087 5 4 3753 1489 1496 3731 EN3_5VX1 $T=-1560 -143360 1 180 $X=-14310 $Y=-144000
X46088 5 4 3775 584 1489 6987 EN3_5VX1 $T=-1000 -161280 0 180 $X=-13750 $Y=-166400
X46089 5 4 3777 607 611 3746 EN3_5VX1 $T=-440 -71680 1 180 $X=-13190 $Y=-72320
X46090 5 4 3811 625 607 3767 EN3_5VX1 $T=680 -80640 0 180 $X=-12070 $Y=-85760
X46091 5 4 723 604 609 706 EN3_5VX1 $T=3480 8960 1 180 $X=-9270 $Y=8320
X46092 5 4 3782 3812 3792 6999 EN3_5VX1 $T=4600 -116480 1 180 $X=-8150 $Y=-117120
X46093 5 4 739 623 614 3791 EN3_5VX1 $T=6840 -17920 1 180 $X=-5910 $Y=-18560
X46094 5 4 3824 620 623 3755 EN3_5VX1 $T=9080 -44800 0 180 $X=-3670 $Y=-49920
X46095 5 4 3805 3829 7016 7010 EN3_5VX1 $T=9640 0 1 180 $X=-3110 $Y=-640
X46096 5 4 3859 611 620 7013 EN3_5VX1 $T=13560 -62720 1 180 $X=810 $Y=-63360
X46097 5 4 3886 761 3897 7040 EN3_5VX1 $T=29240 -17920 1 180 $X=16490 $Y=-18560
X46098 5 4 3982 3949 3901 3907 EN3_5VX1 $T=30360 -206080 0 180 $X=17610 $Y=-211200
X46099 5 4 7066 3960 3920 7045 EN3_5VX1 $T=30920 -179200 0 180 $X=18170 $Y=-184320
X46100 5 4 3977 3945 3926 3914 EN3_5VX1 $T=31480 -8960 0 180 $X=18730 $Y=-14080
X46101 5 4 793 792 3924 7044 EN3_5VX1 $T=32040 -250880 0 180 $X=19290 $Y=-256000
X46102 5 4 3940 3939 3932 7043 EN3_5VX1 $T=33720 -188160 0 180 $X=20970 $Y=-193280
X46103 5 4 3986 3978 4022 3916 EN3_5VX1 $T=34840 -161280 0 180 $X=22090 $Y=-166400
X46104 5 4 3937 3504 607 7959 EN3_5VX1 $T=34840 -62720 0 180 $X=22090 $Y=-67840
X46105 5 4 3934 3944 3954 3990 EN3_5VX1 $T=24760 -116480 0 0 $X=24330 $Y=-117120
X46106 5 4 3935 7056 3928 3975 EN3_5VX1 $T=24760 -107520 0 0 $X=24330 $Y=-108160
X46107 5 4 7058 1496 625 3980 EN3_5VX1 $T=24760 -89600 0 0 $X=24330 $Y=-90240
X46108 5 4 3948 3938 3959 7048 EN3_5VX1 $T=37640 -232960 1 180 $X=24890 $Y=-233600
X46109 5 4 803 611 623 3869 EN3_5VX1 $T=38760 0 1 180 $X=26010 $Y=-640
X46110 5 4 3968 3931 7070 8038 EN3_5VX1 $T=39320 -241920 0 180 $X=26570 $Y=-247040
X46111 5 4 3957 7069 7073 7083 EN3_5VX1 $T=27560 -26880 1 0 $X=27130 $Y=-32000
X46112 5 4 3961 3953 3979 3970 EN3_5VX1 $T=42680 -134400 1 180 $X=29930 $Y=-135040
X46113 5 4 4027 4028 3922 7071 EN3_5VX1 $T=43800 -8960 0 180 $X=31050 $Y=-14080
X46114 5 4 3981 3996 7082 7929 EN3_5VX1 $T=32040 -80640 1 0 $X=31610 $Y=-85760
X46115 5 4 4002 3942 4019 4040 EN3_5VX1 $T=32040 -44800 1 0 $X=31610 $Y=-49920
X46116 5 4 3998 595 624 7068 EN3_5VX1 $T=48280 -224000 1 180 $X=35530 $Y=-224640
X46117 5 4 3999 586 584 7097 EN3_5VX1 $T=35960 -179200 1 0 $X=35530 $Y=-184320
X46118 5 4 4023 4018 4015 7075 EN3_5VX1 $T=48840 -62720 0 180 $X=36090 $Y=-67840
X46119 5 4 4010 4034 4046 7101 EN3_5VX1 $T=37640 -107520 0 0 $X=37210 $Y=-108160
X46120 5 4 4033 4059 4030 7079 EN3_5VX1 $T=50520 -143360 0 180 $X=37770 $Y=-148480
X46121 5 4 802 677 809 7103 EN3_5VX1 $T=38760 -268800 0 0 $X=38330 $Y=-269440
X46122 5 4 4045 586 584 3967 EN3_5VX1 $T=52200 -206080 0 180 $X=39450 $Y=-211200
X46123 5 4 7088 4037 4031 4066 EN3_5VX1 $T=41560 -125440 1 0 $X=41130 $Y=-130560
X46124 5 4 7091 7095 4075 4007 EN3_5VX1 $T=43240 -35840 1 0 $X=42810 $Y=-40960
X46125 5 4 4079 3987 4058 4050 EN3_5VX1 $T=57800 -161280 1 180 $X=45050 $Y=-161920
X46126 5 4 4057 4063 4009 8039 EN3_5VX1 $T=47160 -62720 0 0 $X=46730 $Y=-63360
X46127 5 4 4065 4061 7103 3985 EN3_5VX1 $T=60600 -224000 1 180 $X=47850 $Y=-224640
X46128 5 4 4011 1489 3504 4080 EN3_5VX1 $T=48840 -116480 1 0 $X=48410 $Y=-121600
X46129 5 4 4102 4111 4097 4132 EN3_5VX1 $T=50520 -89600 1 0 $X=50090 $Y=-94720
X46130 5 4 4120 624 1489 4073 EN3_5VX1 $T=63400 -170240 0 180 $X=50650 $Y=-175360
X46131 5 4 584 4055 1496 7115 EN3_5VX1 $T=51640 -143360 0 0 $X=51210 $Y=-144000
X46132 5 4 4095 4085 4109 7122 EN3_5VX1 $T=52200 -206080 1 0 $X=51770 $Y=-211200
X46133 5 4 4099 4135 4150 4166 EN3_5VX1 $T=60600 -152320 0 0 $X=60170 $Y=-152960
X46134 5 4 4131 4151 4143 4169 EN3_5VX1 $T=60600 -116480 0 0 $X=60170 $Y=-117120
X46135 5 4 7130 4155 4147 4181 EN3_5VX1 $T=70120 -143360 1 0 $X=69690 $Y=-148480
X46136 5 4 4197 4185 4149 7141 EN3_5VX1 $T=85240 -241920 1 180 $X=72490 $Y=-242560
X46137 5 4 4192 4199 4172 4180 EN3_5VX1 $T=86920 -188160 1 180 $X=74170 $Y=-188800
X46138 5 4 7143 4186 4154 898 EN3_5VX1 $T=74600 -161280 1 0 $X=74170 $Y=-166400
X46139 5 4 7142 4173 4159 7156 EN3_5VX1 $T=75160 -206080 1 0 $X=74730 $Y=-211200
X46140 5 4 885 4158 4196 4170 EN3_5VX1 $T=75720 -259840 0 0 $X=75290 $Y=-260480
X46141 5 4 624 4232 1496 4269 EN3_5VX1 $T=82440 -143360 0 0 $X=82010 $Y=-144000
X46142 5 4 1489 4237 625 4271 EN3_5VX1 $T=83000 -53760 1 0 $X=82570 $Y=-58880
X46143 5 4 4223 4248 4242 1499 EN3_5VX1 $T=83560 -224000 0 0 $X=83130 $Y=-224640
X46144 5 4 592 4243 624 4376 EN3_5VX1 $T=83560 -188160 1 0 $X=83130 $Y=-193280
X46145 5 4 906 4261 1489 4244 EN3_5VX1 $T=96440 -143360 0 180 $X=83690 $Y=-148480
X46146 5 4 584 4228 3504 4224 EN3_5VX1 $T=98120 -125440 1 180 $X=85370 $Y=-126080
X46147 5 4 637 908 592 4288 EN3_5VX1 $T=86360 -250880 0 0 $X=85930 $Y=-251520
X46148 5 4 632 4305 586 4294 EN3_5VX1 $T=86360 -197120 1 0 $X=85930 $Y=-202240
X46149 5 4 1496 4236 607 4291 EN3_5VX1 $T=87480 -62720 1 0 $X=87050 $Y=-67840
X46150 5 4 4253 7163 4287 4302 EN3_5VX1 $T=89160 -232960 1 0 $X=88730 $Y=-238080
X46151 5 4 625 4241 620 4301 EN3_5VX1 $T=92520 -44800 0 0 $X=92090 $Y=-45440
X46152 5 4 677 4218 595 4340 EN3_5VX1 $T=95880 -224000 0 0 $X=95450 $Y=-224640
X46153 5 4 679 921 632 7189 EN3_5VX1 $T=98120 -232960 0 0 $X=97690 $Y=-233600
X46154 5 4 4230 4274 4264 4503 EN3_5VX1 $T=98680 -241920 1 0 $X=98250 $Y=-247040
X46155 5 4 595 4290 584 4379 EN3_5VX1 $T=102040 -170240 0 0 $X=101610 $Y=-170880
X46156 5 4 7963 4333 4325 965 EN3_5VX1 $T=111560 0 1 0 $X=111130 $Y=-5120
X46157 5 4 4437 4362 4431 4434 EN3_5VX1 $T=113800 -71680 1 0 $X=113370 $Y=-76800
X46158 5 4 4386 7193 4399 7208 EN3_5VX1 $T=114920 -170240 0 0 $X=114490 $Y=-170880
X46159 5 4 4387 4348 4381 4446 EN3_5VX1 $T=115480 -44800 0 0 $X=115050 $Y=-45440
X46160 5 4 4394 4331 4377 4467 EN3_5VX1 $T=117720 -8960 0 0 $X=117290 $Y=-9600
X46161 5 4 4415 4347 4408 4487 EN3_5VX1 $T=122200 -89600 1 0 $X=121770 $Y=-94720
X46162 5 4 4266 4283 4477 8040 EN3_5VX1 $T=124440 -206080 0 0 $X=124010 $Y=-206720
X46163 5 4 7214 4473 4455 7205 EN3_5VX1 $T=136760 -161280 0 180 $X=124010 $Y=-166400
X46164 5 4 4433 4413 4427 7220 EN3_5VX1 $T=125000 -197120 0 0 $X=124570 $Y=-197760
X46165 5 4 4484 4459 4483 4486 EN3_5VX1 $T=125000 -44800 1 0 $X=124570 $Y=-49920
X46166 5 4 4436 4453 7213 7218 EN3_5VX1 $T=125000 -8960 1 0 $X=124570 $Y=-14080
X46167 5 4 4432 4449 4472 4491 EN3_5VX1 $T=125560 -232960 1 0 $X=125130 $Y=-238080
X46168 5 4 4465 4461 4470 7215 EN3_5VX1 $T=125560 -215040 1 0 $X=125130 $Y=-220160
X46169 5 4 4429 4450 4426 7217 EN3_5VX1 $T=125560 -152320 0 0 $X=125130 $Y=-152960
X46170 5 4 4438 4451 4478 1498 EN3_5VX1 $T=125560 -143360 0 0 $X=125130 $Y=-144000
X46171 5 4 4474 4457 7210 8041 EN3_5VX1 $T=125560 -125440 0 0 $X=125130 $Y=-126080
X46172 5 4 4401 4384 4422 4493 EN3_5VX1 $T=125560 -107520 0 0 $X=125130 $Y=-108160
X46173 5 4 4414 4407 4345 4526 EN3_5VX1 $T=125560 -98560 1 0 $X=125130 $Y=-103680
X46174 5 4 4435 4463 4398 4489 EN3_5VX1 $T=125560 -26880 1 0 $X=125130 $Y=-32000
X46175 5 4 4441 4454 7209 8045 EN3_5VX1 $T=126120 -188160 1 0 $X=125690 $Y=-193280
X46176 5 4 4442 4404 4481 4488 EN3_5VX1 $T=126120 -179200 1 0 $X=125690 $Y=-184320
X46177 5 4 4388 4456 4392 4525 EN3_5VX1 $T=126120 -134400 0 0 $X=125690 $Y=-135040
X46178 5 4 4444 4452 4482 7216 EN3_5VX1 $T=126120 -98560 0 0 $X=125690 $Y=-99200
X46179 5 4 4445 4458 4479 4536 EN3_5VX1 $T=126120 -71680 1 0 $X=125690 $Y=-76800
X46180 5 4 4417 4366 4402 8046 EN3_5VX1 $T=126120 -62720 0 0 $X=125690 $Y=-63360
X46181 5 4 4448 4439 972 4495 EN3_5VX1 $T=126120 0 1 0 $X=125690 $Y=-5120
X46182 5 4 4480 4464 4476 7242 EN3_5VX1 $T=151880 -250880 1 0 $X=151450 $Y=-256000
X46183 5 4 983 4460 4507 7241 EN3_5VX1 $T=152440 -268800 0 0 $X=152010 $Y=-269440
X46184 5 4 974 987 1000 1014 EN3_5VX1 $T=152440 8960 0 0 $X=152010 $Y=8320
X46185 5 4 4789 4795 4781 8048 EN3_5VX1 $T=220200 -259840 1 180 $X=207450 $Y=-260480
X46186 5 4 4773 4796 4740 4727 EN3_5VX1 $T=220200 -250880 1 180 $X=207450 $Y=-251520
X46187 5 4 4812 4809 4766 4730 EN3_5VX1 $T=220200 -215040 1 180 $X=207450 $Y=-215680
X46188 5 4 4771 4804 4772 7311 EN3_5VX1 $T=221320 -268800 1 180 $X=208570 $Y=-269440
X46189 5 4 4801 4802 4748 7302 EN3_5VX1 $T=221320 -241920 1 180 $X=208570 $Y=-242560
X46190 5 4 4805 4810 4814 7312 EN3_5VX1 $T=227480 -206080 1 180 $X=214730 $Y=-206720
X46191 5 4 4815 4813 7967 7315 EN3_5VX1 $T=229160 -188160 0 180 $X=216410 $Y=-193280
X46192 5 4 4853 4866 4826 7323 EN3_5VX1 $T=229720 -53760 1 180 $X=216970 $Y=-54400
X46193 5 4 7338 4881 4846 4803 EN3_5VX1 $T=231960 0 0 180 $X=219210 $Y=-5120
X46194 5 4 7339 4877 4834 4782 EN3_5VX1 $T=232520 -143360 1 180 $X=219770 $Y=-144000
X46195 5 4 4833 4855 4850 4798 EN3_5VX1 $T=233640 -179200 1 180 $X=220890 $Y=-179840
X46196 5 4 4874 4878 4870 4831 EN3_5VX1 $T=233640 -107520 1 180 $X=220890 $Y=-108160
X46197 5 4 4865 4859 4852 7320 EN3_5VX1 $T=233640 -89600 0 180 $X=220890 $Y=-94720
X46198 5 4 4872 4869 4856 4783 EN3_5VX1 $T=234200 -125440 0 180 $X=221450 $Y=-130560
X46199 5 4 4876 4885 4861 4790 EN3_5VX1 $T=234760 -152320 1 180 $X=222010 $Y=-152960
X46200 5 4 4879 4873 4845 7321 EN3_5VX1 $T=235320 -71680 0 180 $X=222570 $Y=-76800
X46201 5 4 4910 4919 4883 4857 EN3_5VX1 $T=238120 -116480 0 180 $X=225370 $Y=-121600
X46202 5 4 4898 4912 4840 7326 EN3_5VX1 $T=239240 -26880 0 180 $X=226490 $Y=-32000
X46203 5 4 4891 4886 7340 7330 EN3_5VX1 $T=240920 -17920 1 180 $X=228170 $Y=-18560
X46204 5 4 4892 4896 1151 4848 EN3_5VX1 $T=240920 0 1 180 $X=228170 $Y=-640
X46205 5 4 7337 4880 4890 4843 EN3_5VX1 $T=230840 -35840 1 0 $X=230410 $Y=-40960
X46206 5 4 1119 1171 1123 5001 EN3_5VX1 $T=240360 -250880 0 0 $X=239930 $Y=-251520
X46207 5 4 1117 4948 1109 5002 EN3_5VX1 $T=241480 -232960 1 0 $X=241050 $Y=-238080
X46208 5 4 1123 4953 4754 7373 EN3_5VX1 $T=243160 -197120 0 0 $X=242730 $Y=-197760
X46209 5 4 1133 4960 4762 7381 EN3_5VX1 $T=245960 -188160 1 0 $X=245530 $Y=-193280
X46210 5 4 4762 4987 1504 5036 EN3_5VX1 $T=251560 -170240 0 0 $X=251130 $Y=-170880
X46211 5 4 5008 1165 1159 5065 EN3_5VX1 $T=252680 -125440 1 0 $X=252250 $Y=-130560
X46212 5 4 5000 1170 1173 5042 EN3_5VX1 $T=252680 -53760 0 0 $X=252250 $Y=-54400
X46213 5 4 5020 1170 1157 5053 EN3_5VX1 $T=255480 -62720 1 0 $X=255050 $Y=-67840
X46214 5 4 5039 1159 1170 7378 EN3_5VX1 $T=268360 -107520 1 180 $X=255610 $Y=-108160
X46215 5 4 1504 5028 4769 5076 EN3_5VX1 $T=256600 -89600 0 0 $X=256170 $Y=-90240
X46216 5 4 1180 1189 1133 5066 EN3_5VX1 $T=261640 -241920 1 0 $X=261210 $Y=-247040
X46217 5 4 5028 1168 1165 7406 EN3_5VX1 $T=262760 -80640 0 0 $X=262330 $Y=-81280
X46218 5 4 7425 5144 5103 5080 EN3_5VX1 $T=283480 -170240 0 180 $X=270730 $Y=-175360
X46219 5 4 5158 5148 5130 5088 EN3_5VX1 $T=284600 -152320 1 180 $X=271850 $Y=-152960
X46220 5 4 7423 5143 7409 7399 EN3_5VX1 $T=285160 -206080 1 180 $X=272410 $Y=-206720
X46221 5 4 5166 5147 5127 5092 EN3_5VX1 $T=285160 -197120 1 180 $X=272410 $Y=-197760
X46222 5 4 5145 5137 5119 7413 EN3_5VX1 $T=286840 -161280 0 180 $X=274090 $Y=-166400
X46223 5 4 5164 5155 5112 5115 EN3_5VX1 $T=287960 -71680 1 180 $X=275210 $Y=-72320
X46224 5 4 5136 5124 5128 7410 EN3_5VX1 $T=288520 -188160 1 180 $X=275770 $Y=-188800
X46225 5 4 7436 5179 5139 7419 EN3_5VX1 $T=289640 -107520 0 180 $X=276890 $Y=-112640
X46226 5 4 5162 5146 5149 5067 EN3_5VX1 $T=290760 -143360 1 180 $X=278010 $Y=-144000
X46227 5 4 5175 5180 5167 7416 EN3_5VX1 $T=290760 -80640 1 180 $X=278010 $Y=-81280
X46228 5 4 5138 5163 5174 7418 EN3_5VX1 $T=291320 -116480 0 180 $X=278570 $Y=-121600
X46229 5 4 5160 5150 5154 7394 EN3_5VX1 $T=291320 -89600 1 180 $X=278570 $Y=-90240
X46230 5 4 5159 5186 7422 8055 EN3_5VX1 $T=292440 -134400 1 180 $X=279690 $Y=-135040
X46231 5 4 5140 5131 5187 7420 EN3_5VX1 $T=280120 -98560 1 0 $X=279690 $Y=-103680
X46232 5 4 5177 5190 5172 1224 EN3_5VX1 $T=295240 8960 1 180 $X=282490 $Y=8320
X46233 5 4 1123 5254 4762 7464 EN3_5VX1 $T=319880 -161280 0 180 $X=307130 $Y=-166400
X46234 5 4 1272 1275 1280 1286 EN3_5VX1 $T=329960 8960 0 0 $X=329530 $Y=8320
X46235 5 4 5372 5387 5413 7542 EN3_5VX1 $T=333880 -8960 1 0 $X=333450 $Y=-14080
X46236 5 4 7547 5422 5396 7525 EN3_5VX1 $T=346760 -161280 0 180 $X=334010 $Y=-166400
X46237 5 4 5416 5404 5364 5428 EN3_5VX1 $T=335000 -53760 0 0 $X=334570 $Y=-54400
X46238 5 4 5385 5376 7538 7544 EN3_5VX1 $T=335000 -26880 1 0 $X=334570 $Y=-32000
X46239 5 4 5341 5390 7539 7545 EN3_5VX1 $T=335560 -268800 0 0 $X=335130 $Y=-269440
X46240 5 4 5424 5405 5426 7555 EN3_5VX1 $T=335560 -179200 1 0 $X=335130 $Y=-184320
X46241 5 4 5409 5403 5419 7543 EN3_5VX1 $T=335560 -80640 1 0 $X=335130 $Y=-85760
X46242 5 4 5342 5377 5369 7553 EN3_5VX1 $T=336680 -259840 0 0 $X=336250 $Y=-260480
X46243 5 4 5393 5411 5429 7558 EN3_5VX1 $T=336680 -152320 0 0 $X=336250 $Y=-152960
X46244 5 4 5398 5407 5427 5460 EN3_5VX1 $T=337240 -98560 1 0 $X=336810 $Y=-103680
X46245 5 4 5391 5415 5451 5450 EN3_5VX1 $T=337800 -241920 0 0 $X=337370 $Y=-242560
X46246 5 4 5394 5414 5421 5434 EN3_5VX1 $T=338920 -250880 1 0 $X=338490 $Y=-256000
X46247 5 4 5397 5402 7541 7560 EN3_5VX1 $T=338920 -116480 0 0 $X=338490 $Y=-117120
X46248 5 4 5436 7536 7549 5454 EN3_5VX1 $T=339480 -134400 0 0 $X=339050 $Y=-135040
X46249 5 4 5410 5399 5417 7566 EN3_5VX1 $T=339480 -62720 1 0 $X=339050 $Y=-67840
X46250 5 4 5378 5370 5435 7564 EN3_5VX1 $T=340040 -224000 0 0 $X=339610 $Y=-224640
X46251 5 4 5418 5395 5442 5472 EN3_5VX1 $T=343960 -197120 1 0 $X=343530 $Y=-202240
X46252 5 4 5408 7554 5452 5476 EN3_5VX1 $T=346200 -215040 0 0 $X=345770 $Y=-215680
X46253 5 4 5536 5528 1313 5557 EN3_5VX1 $T=385400 0 1 180 $X=372650 $Y=-640
X46254 5 4 5612 5628 5585 5571 EN3_5VX1 $T=386520 -26880 1 180 $X=373770 $Y=-27520
X46255 5 4 5613 5623 5544 7617 EN3_5VX1 $T=386520 -17920 1 180 $X=373770 $Y=-18560
X46256 5 4 5631 5627 5615 7625 EN3_5VX1 $T=388200 -35840 0 180 $X=375450 $Y=-40960
X46257 5 4 1325 5639 1326 5606 EN3_5VX1 $T=413960 -268800 1 180 $X=401210 $Y=-269440
X46258 5 4 5647 5648 7660 5593 EN3_5VX1 $T=413960 -250880 0 180 $X=401210 $Y=-256000
X46259 5 4 5649 5674 5658 8058 EN3_5VX1 $T=413960 -224000 0 180 $X=401210 $Y=-229120
X46260 5 4 5652 5642 5660 8060 EN3_5VX1 $T=413960 -170240 1 180 $X=401210 $Y=-170880
X46261 5 4 5657 5661 7657 7649 EN3_5VX1 $T=413960 -152320 0 180 $X=401210 $Y=-157440
X46262 5 4 5635 5643 7651 7647 EN3_5VX1 $T=413960 -134400 0 180 $X=401210 $Y=-139520
X46263 5 4 5681 5666 5636 7650 EN3_5VX1 $T=413960 -116480 0 180 $X=401210 $Y=-121600
X46264 5 4 5644 5662 7658 7631 EN3_5VX1 $T=413960 -98560 1 180 $X=401210 $Y=-99200
X46265 5 4 5653 5676 7661 8062 EN3_5VX1 $T=413960 -80640 0 180 $X=401210 $Y=-85760
X46266 5 4 1513 5663 5637 8064 EN3_5VX1 $T=413960 -71680 1 180 $X=401210 $Y=-72320
X46267 5 4 5638 5664 5646 7645 EN3_5VX1 $T=413960 -44800 0 180 $X=401210 $Y=-49920
X46268 5 4 5667 5645 7662 5594 EN3_5VX1 $T=414520 -241920 1 180 $X=401770 $Y=-242560
X46269 5 4 5651 7670 7659 8059 EN3_5VX1 $T=414520 -179200 0 180 $X=401770 $Y=-184320
X46270 5 4 5650 5659 5640 7639 EN3_5VX1 $T=415080 -215040 1 180 $X=402330 $Y=-215680
X46271 5 4 5694 1154 1161 7655 EN3_5VX1 $T=415080 -17920 0 180 $X=402330 $Y=-23040
X46272 5 4 5633 5641 5634 7653 EN3_5VX1 $T=416200 -197120 0 180 $X=403450 $Y=-202240
X46273 5 4 5746 1123 1109 5700 EN3_5VX1 $T=428520 -197120 0 180 $X=415770 $Y=-202240
X46274 5 4 5730 1168 1165 7684 EN3_5VX1 $T=431880 -35840 0 180 $X=419130 $Y=-40960
X46275 5 4 5763 5775 5739 5724 EN3_5VX1 $T=434680 -44800 1 180 $X=421930 $Y=-45440
X46276 5 4 5793 1515 1504 5728 EN3_5VX1 $T=435240 -143360 1 180 $X=422490 $Y=-144000
X46277 5 4 5764 1504 1523 5729 EN3_5VX1 $T=435240 -125440 1 180 $X=422490 $Y=-126080
X46278 5 4 5767 1119 1117 5738 EN3_5VX1 $T=437480 -232960 0 180 $X=424730 $Y=-238080
X46279 5 4 5777 4762 4754 7700 EN3_5VX1 $T=438040 -161280 0 180 $X=425290 $Y=-166400
X46280 5 4 5803 1523 1506 8103 EN3_5VX1 $T=439720 -98560 0 180 $X=426970 $Y=-103680
X46281 5 4 5786 5783 5769 7702 EN3_5VX1 $T=441400 -179200 1 180 $X=428650 $Y=-179840
X46282 5 4 5772 4754 1515 7721 EN3_5VX1 $T=429640 -161280 0 0 $X=429210 $Y=-161920
X46283 5 4 5774 1506 4769 5808 EN3_5VX1 $T=434120 -80640 1 0 $X=433690 $Y=-85760
X46284 5 4 5827 1133 1123 7714 EN3_5VX1 $T=447560 -215040 1 180 $X=434810 $Y=-215680
X46285 5 4 5809 4769 1168 7716 EN3_5VX1 $T=450360 -71680 1 180 $X=437610 $Y=-72320
X46286 5 4 5807 5828 5806 5798 EN3_5VX1 $T=450920 -89600 0 180 $X=438170 $Y=-94720
X46287 5 4 5804 5832 5813 5750 EN3_5VX1 $T=452040 -134400 0 180 $X=439290 $Y=-139520
X46288 5 4 5800 5820 5834 5837 EN3_5VX1 $T=441400 -206080 0 0 $X=440970 $Y=-206720
X46289 5 4 1372 5836 7734 5766 EN3_5VX1 $T=455400 -224000 0 180 $X=442650 $Y=-229120
X46290 5 4 7764 5831 5860 5801 EN3_5VX1 $T=462680 -232960 0 180 $X=449930 $Y=-238080
X46291 5 4 5878 1170 1173 5906 EN3_5VX1 $T=450360 0 1 0 $X=449930 $Y=-5120
X46292 5 4 7749 5854 5877 6138 EN3_5VX1 $T=452040 -179200 1 0 $X=451610 $Y=-184320
X46293 5 4 5858 5851 5867 7772 EN3_5VX1 $T=452040 -80640 0 0 $X=451610 $Y=-81280
X46294 5 4 5865 5879 5876 7776 EN3_5VX1 $T=453720 -206080 0 0 $X=453290 $Y=-206720
X46295 5 4 1392 5864 1381 5790 EN3_5VX1 $T=467160 -259840 0 180 $X=454410 $Y=-264960
X46296 5 4 5890 7761 5855 5949 EN3_5VX1 $T=457080 -170240 0 0 $X=456650 $Y=-170880
X46297 5 4 5875 7748 5889 5895 EN3_5VX1 $T=458200 -44800 1 0 $X=457770 $Y=-49920
X46298 5 4 5911 1504 1506 7793 EN3_5VX1 $T=462120 -107520 1 0 $X=461690 $Y=-112640
X46299 5 4 7778 1523 4769 5976 EN3_5VX1 $T=464920 -89600 1 0 $X=464490 $Y=-94720
X46300 5 4 5953 5950 5942 5933 EN3_5VX1 $T=479480 -161280 1 180 $X=466730 $Y=-161920
X46301 5 4 6006 1119 1133 7805 EN3_5VX1 $T=468840 -224000 0 0 $X=468410 $Y=-224640
X46302 5 4 5945 5902 5935 7802 EN3_5VX1 $T=469960 -134400 0 0 $X=469530 $Y=-135040
X46303 5 4 1404 5988 6013 6034 EN3_5VX1 $T=477800 -241920 0 0 $X=477370 $Y=-242560
X46304 5 4 5983 5984 5930 7825 EN3_5VX1 $T=478920 0 0 0 $X=478490 $Y=-640
X46305 5 4 5985 1123 6024 6007 EN3_5VX1 $T=481720 -188160 0 0 $X=481290 $Y=-188800
X46306 5 4 1168 5926 1159 7810 EN3_5VX1 $T=494040 -71680 1 180 $X=481290 $Y=-72320
X46307 5 4 5999 5934 6010 6031 EN3_5VX1 $T=482280 -197120 0 0 $X=481850 $Y=-197760
X46308 5 4 6000 6002 6007 6027 EN3_5VX1 $T=482280 -170240 1 0 $X=481850 $Y=-175360
X46309 5 4 1525 1515 1523 7831 EN3_5VX1 $T=482840 -134400 1 0 $X=482410 $Y=-139520
X46310 5 4 7813 5944 6015 7830 EN3_5VX1 $T=483400 -26880 0 0 $X=482970 $Y=-27520
X46311 5 4 6011 6004 5965 6126 EN3_5VX1 $T=484520 -62720 1 0 $X=484090 $Y=-67840
X46312 5 4 6003 5977 6038 6057 EN3_5VX1 $T=484520 -8960 1 0 $X=484090 $Y=-14080
X46313 5 4 1409 1412 1413 8066 EN3_5VX1 $T=486760 8960 0 0 $X=486330 $Y=8320
X46314 5 4 7824 5927 5995 7835 EN3_5VX1 $T=488440 -44800 1 0 $X=488010 $Y=-49920
X46315 5 4 6025 6019 6052 7836 EN3_5VX1 $T=489000 -17920 1 0 $X=488570 $Y=-23040
X46316 5 4 5919 5901 7832 7861 EN3_5VX1 $T=489560 -152320 0 0 $X=489130 $Y=-152960
X46317 5 4 6037 6020 5986 6098 EN3_5VX1 $T=492920 -125440 1 0 $X=492490 $Y=-130560
X46318 5 4 6041 6028 6066 6090 EN3_5VX1 $T=493480 -44800 0 0 $X=493050 $Y=-45440
X46319 5 4 6046 6073 6087 8068 EN3_5VX1 $T=494040 -188160 0 0 $X=493610 $Y=-188800
X46320 5 4 6079 6056 6077 7843 EN3_5VX1 $T=494040 -62720 0 0 $X=493610 $Y=-63360
X46321 5 4 6050 6061 6078 7847 EN3_5VX1 $T=494600 -89600 0 0 $X=494170 $Y=-90240
X46322 5 4 6071 6017 6051 7848 EN3_5VX1 $T=494600 -71680 1 0 $X=494170 $Y=-76800
X46323 5 4 6074 6014 6021 7852 EN3_5VX1 $T=495160 -80640 0 0 $X=494730 $Y=-81280
X46324 5 4 6088 6065 7839 7874 EN3_5VX1 $T=495720 -134400 1 0 $X=495290 $Y=-139520
X46325 5 4 6055 5936 6044 8069 EN3_5VX1 $T=495720 -107520 0 0 $X=495290 $Y=-108160
X46326 5 4 6063 7834 6083 7856 EN3_5VX1 $T=496840 -170240 1 0 $X=496410 $Y=-175360
X46327 5 4 6064 6049 6076 7860 EN3_5VX1 $T=497960 -152320 1 0 $X=497530 $Y=-157440
X46328 5 4 6081 6082 6094 6132 EN3_5VX1 $T=499080 -116480 0 0 $X=498650 $Y=-117120
X46329 5 4 6062 6075 6069 7873 EN3_5VX1 $T=503000 -197120 0 0 $X=502570 $Y=-197760
X46330 5 4 7840 6085 6032 6129 EN3_5VX1 $T=503000 -89600 1 0 $X=502570 $Y=-94720
X46331 5 4 6093 6099 6070 7877 EN3_5VX1 $T=503560 -125440 0 0 $X=503130 $Y=-126080
X46332 5 4 51 54 7948 AND2_5VX1 $T=-255240 8960 1 180 $X=-259590 $Y=8320
X46333 5 4 3212 1475 8107 AND2_5VX1 $T=-128680 -116480 1 180 $X=-133030 $Y=-117120
X46334 5 4 3247 3268 6788 AND2_5VX1 $T=-125880 -134400 0 180 $X=-130230 $Y=-139520
X46335 5 4 625 1496 3554 AND2_5VX1 $T=-47480 -170240 0 180 $X=-51830 $Y=-175360
X46336 5 4 8003 5923 5957 AND2_5VX1 $T=466040 -215040 1 0 $X=465610 $Y=-220160
X46337 5 4 1123 1117 7788 AND2_5VX1 $T=466600 -188160 1 0 $X=466170 $Y=-193280
X46338 5 4 1157 1159 7804 AND2_5VX1 $T=483960 0 0 180 $X=479610 $Y=-5120
X46339 5 4 1 7 10 NO2I1_5VX1 $T=-577800 -62720 1 0 $X=-578230 $Y=-67840
X46340 5 4 3 7 8 NO2I1_5VX1 $T=-577800 -53760 1 0 $X=-578230 $Y=-58880
X46341 5 4 6 7 9 NO2I1_5VX1 $T=-577800 -35840 0 0 $X=-578230 $Y=-36480
X46342 5 4 1671 7 1529 NO2I1_5VX1 $T=-484840 -44800 1 0 $X=-485270 $Y=-49920
X46343 5 4 1640 13 1544 NO2I1_5VX1 $T=-480920 -26880 1 180 $X=-485270 $Y=-27520
X46344 5 4 1629 13 1543 NO2I1_5VX1 $T=-480920 0 0 180 $X=-485270 $Y=-5120
X46345 5 4 1637 7 1606 NO2I1_5VX1 $T=-478680 -35840 1 180 $X=-483030 $Y=-36480
X46346 5 4 1619 13 1601 NO2I1_5VX1 $T=-478680 -8960 0 180 $X=-483030 $Y=-14080
X46347 5 4 1641 7 1546 NO2I1_5VX1 $T=-478120 -62720 0 180 $X=-482470 $Y=-67840
X46348 5 4 1614 7 6240 NO2I1_5VX1 $T=-478120 -35840 0 180 $X=-482470 $Y=-40960
X46349 5 4 1625 7 1560 NO2I1_5VX1 $T=-477560 -98560 0 180 $X=-481910 $Y=-103680
X46350 5 4 1633 7 1604 NO2I1_5VX1 $T=-476440 -71680 0 180 $X=-480790 $Y=-76800
X46351 5 4 1651 7 1551 NO2I1_5VX1 $T=-475880 -80640 0 180 $X=-480230 $Y=-85760
X46352 5 4 6250 7 1571 NO2I1_5VX1 $T=-473080 -134400 1 180 $X=-477430 $Y=-135040
X46353 5 4 1648 7 1568 NO2I1_5VX1 $T=-473080 -116480 0 180 $X=-477430 $Y=-121600
X46354 5 4 1660 7 1650 NO2I1_5VX1 $T=-471960 -98560 0 180 $X=-476310 $Y=-103680
X46355 5 4 1661 7 1598 NO2I1_5VX1 $T=-470280 -89600 0 180 $X=-474630 $Y=-94720
X46356 5 4 6267 7 6247 NO2I1_5VX1 $T=-469720 -152320 0 180 $X=-474070 $Y=-157440
X46357 5 4 1659 7 1612 NO2I1_5VX1 $T=-468040 -143360 1 180 $X=-472390 $Y=-144000
X46358 5 4 1737 7 6237 NO2I1_5VX1 $T=-465800 -125440 1 180 $X=-470150 $Y=-126080
X46359 5 4 1699 7 1611 NO2I1_5VX1 $T=-464120 -179200 1 180 $X=-468470 $Y=-179840
X46360 5 4 1693 7 6264 NO2I1_5VX1 $T=-464120 -161280 1 180 $X=-468470 $Y=-161920
X46361 5 4 6273 7 1675 NO2I1_5VX1 $T=-462440 -188160 0 180 $X=-466790 $Y=-193280
X46362 5 4 1717 7 1726 NO2I1_5VX1 $T=-461320 -197120 0 0 $X=-461750 $Y=-197760
X46363 5 4 6287 7 6275 NO2I1_5VX1 $T=-456840 -206080 1 180 $X=-461190 $Y=-206720
X46364 5 4 6290 7 1741 NO2I1_5VX1 $T=-450680 -215040 0 180 $X=-455030 $Y=-220160
X46365 5 4 1765 7 1657 NO2I1_5VX1 $T=-454040 -206080 1 0 $X=-454470 $Y=-211200
X46366 5 4 1782 7 1645 NO2I1_5VX1 $T=-451240 -224000 1 0 $X=-451670 $Y=-229120
X46367 5 4 6298 7 1813 NO2I1_5VX1 $T=-446200 -232960 0 0 $X=-446630 $Y=-233600
X46368 5 4 6297 7 6295 NO2I1_5VX1 $T=-441160 -241920 0 180 $X=-445510 $Y=-247040
X46369 5 4 1774 7 1714 NO2I1_5VX1 $T=-440600 -224000 0 180 $X=-444950 $Y=-229120
X46370 5 4 7939 7 1750 NO2I1_5VX1 $T=-442840 -259840 1 0 $X=-443270 $Y=-264960
X46371 5 4 1854 7 1764 NO2I1_5VX1 $T=-435560 -241920 0 180 $X=-439910 $Y=-247040
X46372 5 4 65 7 6310 NO2I1_5VX1 $T=-432760 -268800 0 180 $X=-437110 $Y=-273920
X46373 5 4 1853 7 1781 NO2I1_5VX1 $T=-436680 -259840 0 0 $X=-437110 $Y=-260480
X46374 5 4 1869 6315 1857 NO2I1_5VX1 $T=-432200 -35840 0 180 $X=-436550 $Y=-40960
X46375 5 4 55 69 6332 NO2I1_5VX1 $T=-426040 8960 1 0 $X=-426470 $Y=3840
X46376 5 4 102 100 1973 NO2I1_5VX1 $T=-404760 -268800 0 180 $X=-409110 $Y=-273920
X46377 5 4 47 6376 2003 NO2I1_5VX1 $T=-402520 -26880 0 180 $X=-406870 $Y=-32000
X46378 5 4 101 13 1528 NO2I1_5VX1 $T=-405880 -80640 1 0 $X=-406310 $Y=-85760
X46379 5 4 1634 13 2012 NO2I1_5VX1 $T=-405320 -71680 1 0 $X=-405750 $Y=-76800
X46380 5 4 1622 13 2039 NO2I1_5VX1 $T=-401400 -44800 0 0 $X=-401830 $Y=-45440
X46381 5 4 1652 13 2034 NO2I1_5VX1 $T=-400840 -62720 0 0 $X=-401270 $Y=-63360
X46382 5 4 113 13 6390 NO2I1_5VX1 $T=-399720 -71680 1 0 $X=-400150 $Y=-76800
X46383 5 4 115 13 2062 NO2I1_5VX1 $T=-399160 -62720 1 0 $X=-399590 $Y=-67840
X46384 5 4 116 13 2049 NO2I1_5VX1 $T=-398040 -53760 0 0 $X=-398470 $Y=-54400
X46385 5 4 1667 13 2230 NO2I1_5VX1 $T=-396920 -17920 1 0 $X=-397350 $Y=-23040
X46386 5 4 1833 13 2027 NO2I1_5VX1 $T=-392440 -80640 0 180 $X=-396790 $Y=-85760
X46387 5 4 6239 13 2066 NO2I1_5VX1 $T=-394120 -71680 1 0 $X=-394550 $Y=-76800
X46388 5 4 2001 7 2087 NO2I1_5VX1 $T=-392440 -107520 1 0 $X=-392870 $Y=-112640
X46389 5 4 7919 13 2090 NO2I1_5VX1 $T=-392440 0 1 0 $X=-392870 $Y=-5120
X46390 5 4 2073 7 2089 NO2I1_5VX1 $T=-390200 -125440 0 0 $X=-390630 $Y=-126080
X46391 5 4 1925 7 2104 NO2I1_5VX1 $T=-385720 -232960 0 0 $X=-386150 $Y=-233600
X46392 5 4 2184 138 6414 NO2I1_5VX1 $T=-381240 -232960 1 0 $X=-381670 $Y=-238080
X46393 5 4 2148 141 2098 NO2I1_5VX1 $T=-375640 -206080 0 180 $X=-379990 $Y=-211200
X46394 5 4 2094 7 2154 NO2I1_5VX1 $T=-379000 -224000 0 0 $X=-379430 $Y=-224640
X46395 5 4 6414 139 2148 NO2I1_5VX1 $T=-377880 -224000 1 0 $X=-378310 $Y=-229120
X46396 5 4 1453 13 6421 NO2I1_5VX1 $T=-377320 -62720 1 0 $X=-377750 $Y=-67840
X46397 5 4 6423 7 2294 NO2I1_5VX1 $T=-369480 -241920 1 0 $X=-369910 $Y=-247040
X46398 5 4 1455 13 2155 NO2I1_5VX1 $T=-365560 -89600 1 180 $X=-369910 $Y=-90240
X46399 5 4 2186 13 2159 NO2I1_5VX1 $T=-365560 -44800 1 180 $X=-369910 $Y=-45440
X46400 5 4 6429 7 2229 NO2I1_5VX1 $T=-367800 -143360 0 0 $X=-368230 $Y=-144000
X46401 5 4 155 143 2188 NO2I1_5VX1 $T=-366680 -268800 1 0 $X=-367110 $Y=-273920
X46402 5 4 2176 7 2203 NO2I1_5VX1 $T=-366680 -161280 1 0 $X=-367110 $Y=-166400
X46403 5 4 1615 13 2160 NO2I1_5VX1 $T=-362760 -35840 1 180 $X=-367110 $Y=-36480
X46404 5 4 1846 7 2198 NO2I1_5VX1 $T=-366120 -206080 1 0 $X=-366550 $Y=-211200
X46405 5 4 1682 7 2189 NO2I1_5VX1 $T=-366120 -134400 1 0 $X=-366550 $Y=-139520
X46406 5 4 2171 7 2256 NO2I1_5VX1 $T=-366120 -116480 0 0 $X=-366550 $Y=-117120
X46407 5 4 1620 157 2158 NO2I1_5VX1 $T=-362200 -71680 0 180 $X=-366550 $Y=-76800
X46408 5 4 1600 157 6436 NO2I1_5VX1 $T=-366120 -17920 0 0 $X=-366550 $Y=-18560
X46409 5 4 1591 157 2205 NO2I1_5VX1 $T=-366120 0 0 0 $X=-366550 $Y=-640
X46410 5 4 154 157 158 NO2I1_5VX1 $T=-366120 8960 0 0 $X=-366550 $Y=8320
X46411 5 4 2188 140 2184 NO2I1_5VX1 $T=-361640 -259840 1 180 $X=-365990 $Y=-260480
X46412 5 4 6439 2219 1539 NO2I1_5VX1 $T=-348200 -98560 0 0 $X=-348630 $Y=-99200
X46413 5 4 6443 157 2224 NO2I1_5VX1 $T=-348200 -71680 1 0 $X=-348630 $Y=-76800
X46414 5 4 2004 157 2729 NO2I1_5VX1 $T=-348200 -35840 1 0 $X=-348630 $Y=-40960
X46415 5 4 1859 2219 7943 NO2I1_5VX1 $T=-347640 -143360 0 0 $X=-348070 $Y=-144000
X46416 5 4 6438 157 1535 NO2I1_5VX1 $T=-347640 -62720 1 0 $X=-348070 $Y=-67840
X46417 5 4 6445 157 1531 NO2I1_5VX1 $T=-347640 -44800 0 0 $X=-348070 $Y=-45440
X46418 5 4 8108 157 1534 NO2I1_5VX1 $T=-347640 -26880 1 0 $X=-348070 $Y=-32000
X46419 5 4 6441 2219 1589 NO2I1_5VX1 $T=-346520 -161280 0 0 $X=-346950 $Y=-161920
X46420 5 4 1730 157 2246 NO2I1_5VX1 $T=-346520 -44800 1 0 $X=-346950 $Y=-49920
X46421 5 4 2220 2219 2742 NO2I1_5VX1 $T=-345960 -116480 1 0 $X=-346390 $Y=-121600
X46422 5 4 6446 2219 1552 NO2I1_5VX1 $T=-345960 -107520 0 0 $X=-346390 $Y=-108160
X46423 5 4 6440 2219 1573 NO2I1_5VX1 $T=-344840 -179200 0 0 $X=-345270 $Y=-179840
X46424 5 4 163 2219 2236 NO2I1_5VX1 $T=-344840 -170240 0 0 $X=-345270 $Y=-170880
X46425 5 4 2007 2219 2242 NO2I1_5VX1 $T=-344280 -98560 0 0 $X=-344710 $Y=-99200
X46426 5 4 1963 157 1456 NO2I1_5VX1 $T=-344280 -71680 1 0 $X=-344710 $Y=-76800
X46427 5 4 2251 157 1532 NO2I1_5VX1 $T=-339800 -8960 0 180 $X=-344150 $Y=-14080
X46428 5 4 2234 2219 1559 NO2I1_5VX1 $T=-342040 -143360 0 0 $X=-342470 $Y=-144000
X46429 5 4 2763 157 2263 NO2I1_5VX1 $T=-342040 -62720 1 0 $X=-342470 $Y=-67840
X46430 5 4 1736 7 2328 NO2I1_5VX1 $T=-341480 -188160 1 0 $X=-341910 $Y=-193280
X46431 5 4 2252 157 1548 NO2I1_5VX1 $T=-339800 8960 0 0 $X=-340230 $Y=8320
X46432 5 4 7944 2219 1592 NO2I1_5VX1 $T=-337000 -170240 0 0 $X=-337430 $Y=-170880
X46433 5 4 2281 2219 2287 NO2I1_5VX1 $T=-333640 -134400 1 0 $X=-334070 $Y=-139520
X46434 5 4 8109 2219 1579 NO2I1_5VX1 $T=-333080 -134400 0 0 $X=-333510 $Y=-135040
X46435 5 4 2272 157 2226 NO2I1_5VX1 $T=-333080 0 1 0 $X=-333510 $Y=-5120
X46436 5 4 6460 2219 1566 NO2I1_5VX1 $T=-331960 -170240 0 0 $X=-332390 $Y=-170880
X46437 5 4 1949 157 6482 NO2I1_5VX1 $T=-330840 -17920 0 0 $X=-331270 $Y=-18560
X46438 5 4 1681 2219 6461 NO2I1_5VX1 $T=-326360 -179200 0 180 $X=-330710 $Y=-184320
X46439 5 4 1755 2219 6475 NO2I1_5VX1 $T=-324680 -206080 0 180 $X=-329030 $Y=-211200
X46440 5 4 2323 2219 7945 NO2I1_5VX1 $T=-321320 -188160 0 180 $X=-325670 $Y=-193280
X46441 5 4 2310 2219 1630 NO2I1_5VX1 $T=-323560 -206080 1 0 $X=-323990 $Y=-211200
X46442 5 4 2316 7 2336 NO2I1_5VX1 $T=-323000 -215040 1 0 $X=-323430 $Y=-220160
X46443 5 4 2337 2219 1610 NO2I1_5VX1 $T=-320200 -188160 1 0 $X=-320630 $Y=-193280
X46444 5 4 2311 2219 2350 NO2I1_5VX1 $T=-320200 -179200 1 0 $X=-320630 $Y=-184320
X46445 5 4 6442 2219 2374 NO2I1_5VX1 $T=-316840 -206080 0 0 $X=-317270 $Y=-206720
X46446 5 4 208 7 2438 NO2I1_5VX1 $T=-302280 -232960 1 0 $X=-302710 $Y=-238080
X46447 5 4 2273 7 6720 NO2I1_5VX1 $T=-300600 -224000 1 0 $X=-301030 $Y=-229120
X46448 5 4 6523 100 2476 NO2I1_5VX1 $T=-297240 -179200 1 0 $X=-297670 $Y=-184320
X46449 5 4 2339 2719 1842 NO2I1_5VX1 $T=-256360 -71680 0 0 $X=-256790 $Y=-72320
X46450 5 4 2658 2719 2689 NO2I1_5VX1 $T=-253560 -53760 1 0 $X=-253990 $Y=-58880
X46451 5 4 275 276 2683 NO2I1_5VX1 $T=-253000 -250880 0 0 $X=-253430 $Y=-251520
X46452 5 4 269 276 2706 NO2I1_5VX1 $T=-251880 -259840 1 0 $X=-252310 $Y=-264960
X46453 5 4 277 276 2690 NO2I1_5VX1 $T=-250760 -241920 1 0 $X=-251190 $Y=-247040
X46454 5 4 281 276 285 NO2I1_5VX1 $T=-249080 -268800 1 0 $X=-249510 $Y=-273920
X46455 5 4 2712 2719 2722 NO2I1_5VX1 $T=-244600 -17920 0 0 $X=-245030 $Y=-18560
X46456 5 4 2199 2719 2282 NO2I1_5VX1 $T=-244040 -107520 0 0 $X=-244470 $Y=-108160
X46457 5 4 2347 2719 1738 NO2I1_5VX1 $T=-242360 -116480 1 0 $X=-242790 $Y=-121600
X46458 5 4 293 2719 2756 NO2I1_5VX1 $T=-241800 -143360 1 0 $X=-242230 $Y=-148480
X46459 5 4 2710 2719 304 NO2I1_5VX1 $T=-241800 -134400 0 0 $X=-242230 $Y=-135040
X46460 5 4 2428 2719 6623 NO2I1_5VX1 $T=-239560 -89600 0 0 $X=-239990 $Y=-90240
X46461 5 4 2418 2719 2765 NO2I1_5VX1 $T=-237320 -35840 0 0 $X=-237750 $Y=-36480
X46462 5 4 2747 2719 2750 NO2I1_5VX1 $T=-235640 -152320 0 0 $X=-236070 $Y=-152960
X46463 5 4 2201 2719 2764 NO2I1_5VX1 $T=-235640 -80640 1 0 $X=-236070 $Y=-85760
X46464 5 4 2762 2719 2798 NO2I1_5VX1 $T=-235080 -98560 0 0 $X=-235510 $Y=-99200
X46465 5 4 2375 2719 2777 NO2I1_5VX1 $T=-234520 -161280 0 0 $X=-234950 $Y=-161920
X46466 5 4 2488 2719 2783 NO2I1_5VX1 $T=-233400 -161280 1 0 $X=-233830 $Y=-166400
X46467 5 4 2761 2719 6632 NO2I1_5VX1 $T=-233400 -125440 0 0 $X=-233830 $Y=-126080
X46468 5 4 311 276 2789 NO2I1_5VX1 $T=-232840 -197120 1 0 $X=-233270 $Y=-202240
X46469 5 4 312 2719 6631 NO2I1_5VX1 $T=-232840 -188160 0 0 $X=-233270 $Y=-188800
X46470 5 4 2758 2719 2809 NO2I1_5VX1 $T=-232840 -35840 1 0 $X=-233270 $Y=-40960
X46471 5 4 2356 2719 6637 NO2I1_5VX1 $T=-231720 -53760 0 0 $X=-232150 $Y=-54400
X46472 5 4 310 276 2800 NO2I1_5VX1 $T=-231160 -232960 0 0 $X=-231590 $Y=-233600
X46473 5 4 2770 2719 323 NO2I1_5VX1 $T=-230600 -152320 0 0 $X=-231030 $Y=-152960
X46474 5 4 2775 2719 2805 NO2I1_5VX1 $T=-228920 -161280 0 0 $X=-229350 $Y=-161920
X46475 5 4 320 276 3071 NO2I1_5VX1 $T=-228360 -215040 0 0 $X=-228790 $Y=-215680
X46476 5 4 2522 2719 2819 NO2I1_5VX1 $T=-227800 -188160 0 0 $X=-228230 $Y=-188800
X46477 5 4 2829 141 6643 NO2I1_5VX1 $T=-219400 -215040 1 180 $X=-223750 $Y=-215680
X46478 5 4 141 2818 326 NO2I1_5VX1 $T=-218840 -232960 0 180 $X=-223190 $Y=-238080
X46479 5 4 2379 2719 6653 NO2I1_5VX1 $T=-219400 -17920 1 0 $X=-219830 $Y=-23040
X46480 5 4 2846 2719 2871 NO2I1_5VX1 $T=-216600 -152320 1 0 $X=-217030 $Y=-157440
X46481 5 4 2853 344 2743 NO2I1_5VX1 $T=-216600 -8960 0 0 $X=-217030 $Y=-9600
X46482 5 4 2840 2719 355 NO2I1_5VX1 $T=-209320 -125440 0 0 $X=-209750 $Y=-126080
X46483 5 4 2909 344 2921 NO2I1_5VX1 $T=-205960 0 0 0 $X=-206390 $Y=-640
X46484 5 4 2961 344 2969 NO2I1_5VX1 $T=-194200 -8960 0 0 $X=-194630 $Y=-9600
X46485 5 4 2796 276 391 NO2I1_5VX1 $T=-186920 -206080 1 0 $X=-187350 $Y=-211200
X46486 5 4 3000 2719 3018 NO2I1_5VX1 $T=-185800 -170240 1 0 $X=-186230 $Y=-175360
X46487 5 4 2820 276 387 NO2I1_5VX1 $T=-185240 -197120 1 0 $X=-185670 $Y=-202240
X46488 5 4 2782 276 389 NO2I1_5VX1 $T=-184680 -268800 0 0 $X=-185110 $Y=-269440
X46489 5 4 6691 2719 393 NO2I1_5VX1 $T=-183000 -206080 1 0 $X=-183430 $Y=-211200
X46490 5 4 6634 2719 1586 NO2I1_5VX1 $T=-183000 -44800 1 0 $X=-183430 $Y=-49920
X46491 5 4 3020 276 400 NO2I1_5VX1 $T=-181880 -232960 1 0 $X=-182310 $Y=-238080
X46492 5 4 3016 2719 384 NO2I1_5VX1 $T=-177960 -188160 0 180 $X=-182310 $Y=-193280
X46493 5 4 2812 2719 398 NO2I1_5VX1 $T=-179640 -143360 0 0 $X=-180070 $Y=-144000
X46494 5 4 6651 2719 50 NO2I1_5VX1 $T=-179640 -80640 1 0 $X=-180070 $Y=-85760
X46495 5 4 2858 2719 3176 NO2I1_5VX1 $T=-178520 -62720 1 0 $X=-178950 $Y=-67840
X46496 5 4 2848 2719 1594 NO2I1_5VX1 $T=-177960 -26880 1 0 $X=-178390 $Y=-32000
X46497 5 4 6700 276 410 NO2I1_5VX1 $T=-177400 -259840 1 0 $X=-177830 $Y=-264960
X46498 5 4 6698 276 405 NO2I1_5VX1 $T=-177400 -250880 0 0 $X=-177830 $Y=-251520
X46499 5 4 2861 2719 406 NO2I1_5VX1 $T=-177400 -98560 0 0 $X=-177830 $Y=-99200
X46500 5 4 2897 2719 1632 NO2I1_5VX1 $T=-176840 -53760 1 0 $X=-177270 $Y=-58880
X46501 5 4 2702 2719 411 NO2I1_5VX1 $T=-175720 -179200 0 0 $X=-176150 $Y=-179840
X46502 5 4 2816 2719 415 NO2I1_5VX1 $T=-175160 -98560 1 0 $X=-175590 $Y=-103680
X46503 5 4 3055 2719 412 NO2I1_5VX1 $T=-175160 -35840 0 0 $X=-175590 $Y=-36480
X46504 5 4 3051 2719 413 NO2I1_5VX1 $T=-174600 -80640 1 0 $X=-175030 $Y=-85760
X46505 5 4 2945 344 2811 NO2I1_5VX1 $T=-162840 0 1 0 $X=-163270 $Y=-5120
X46506 5 4 3114 2719 435 NO2I1_5VX1 $T=-160600 -170240 0 0 $X=-161030 $Y=-170880
X46507 5 4 3122 2719 3135 NO2I1_5VX1 $T=-159480 -107520 1 0 $X=-159910 $Y=-112640
X46508 5 4 3127 2719 3141 NO2I1_5VX1 $T=-158920 -134400 1 0 $X=-159350 $Y=-139520
X46509 5 4 6744 2719 452 NO2I1_5VX1 $T=-151640 -206080 0 0 $X=-152070 $Y=-206720
X46510 5 4 8110 2719 458 NO2I1_5VX1 $T=-151640 -152320 0 0 $X=-152070 $Y=-152960
X46511 5 4 449 457 6752 NO2I1_5VX1 $T=-149960 -250880 0 0 $X=-150390 $Y=-251520
X46512 5 4 8111 2719 456 NO2I1_5VX1 $T=-148840 -188160 0 0 $X=-149270 $Y=-188800
X46513 5 4 468 457 3168 NO2I1_5VX1 $T=-142120 -268800 1 180 $X=-146470 $Y=-269440
X46514 5 4 3165 457 3191 NO2I1_5VX1 $T=-145480 -259840 0 0 $X=-145910 $Y=-260480
X46515 5 4 6755 2719 471 NO2I1_5VX1 $T=-145480 -206080 0 0 $X=-145910 $Y=-206720
X46516 5 4 479 457 3254 NO2I1_5VX1 $T=-135400 -268800 1 0 $X=-135830 $Y=-273920
X46517 5 4 3231 457 490 NO2I1_5VX1 $T=-135400 -250880 0 0 $X=-135830 $Y=-251520
X46518 5 4 3243 344 496 NO2I1_5VX1 $T=-124760 0 0 180 $X=-129110 $Y=-5120
X46519 5 4 504 344 499 NO2I1_5VX1 $T=-121960 8960 1 180 $X=-126310 $Y=8320
X46520 5 4 3291 344 500 NO2I1_5VX1 $T=-120840 0 0 180 $X=-125190 $Y=-5120
X46521 5 4 6796 2719 516 NO2I1_5VX1 $T=-124200 -71680 0 0 $X=-124630 $Y=-72320
X46522 5 4 6797 2719 507 NO2I1_5VX1 $T=-124200 -35840 1 0 $X=-124630 $Y=-40960
X46523 5 4 3277 2719 1668 NO2I1_5VX1 $T=-119720 -80640 0 180 $X=-124070 $Y=-85760
X46524 5 4 6760 457 6800 NO2I1_5VX1 $T=-118040 -241920 0 180 $X=-122390 $Y=-247040
X46525 5 4 3273 2719 1696 NO2I1_5VX1 $T=-118040 -53760 1 180 $X=-122390 $Y=-54400
X46526 5 4 6808 2719 509 NO2I1_5VX1 $T=-115800 -116480 0 180 $X=-120150 $Y=-121600
X46527 5 4 6809 2719 514 NO2I1_5VX1 $T=-115240 -224000 1 180 $X=-119590 $Y=-224640
X46528 5 4 6822 2719 512 NO2I1_5VX1 $T=-115240 -107520 1 180 $X=-119590 $Y=-108160
X46529 5 4 3333 2719 3310 NO2I1_5VX1 $T=-114680 -26880 0 180 $X=-119030 $Y=-32000
X46530 5 4 8112 2719 527 NO2I1_5VX1 $T=-113000 -134400 0 180 $X=-117350 $Y=-139520
X46531 5 4 6819 2719 3316 NO2I1_5VX1 $T=-113000 -80640 0 180 $X=-117350 $Y=-85760
X46532 5 4 3321 2719 6807 NO2I1_5VX1 $T=-113000 -71680 1 180 $X=-117350 $Y=-72320
X46533 5 4 6810 2719 3903 NO2I1_5VX1 $T=-113000 -26880 1 180 $X=-117350 $Y=-27520
X46534 5 4 534 344 518 NO2I1_5VX1 $T=-113000 8960 0 180 $X=-117350 $Y=3840
X46535 5 4 533 457 3298 NO2I1_5VX1 $T=-112440 -268800 1 180 $X=-116790 $Y=-269440
X46536 5 4 6816 457 522 NO2I1_5VX1 $T=-112440 -241920 0 180 $X=-116790 $Y=-247040
X46537 5 4 8113 2719 523 NO2I1_5VX1 $T=-112440 -206080 1 180 $X=-116790 $Y=-206720
X46538 5 4 8114 2719 515 NO2I1_5VX1 $T=-112440 -188160 1 180 $X=-116790 $Y=-188800
X46539 5 4 8115 2719 524 NO2I1_5VX1 $T=-112440 -152320 1 180 $X=-116790 $Y=-152960
X46540 5 4 3322 2719 3302 NO2I1_5VX1 $T=-112440 -53760 1 180 $X=-116790 $Y=-54400
X46541 5 4 3329 2719 3319 NO2I1_5VX1 $T=-112440 -35840 1 180 $X=-116790 $Y=-36480
X46542 5 4 8116 2719 525 NO2I1_5VX1 $T=-111880 -170240 1 180 $X=-116230 $Y=-170880
X46543 5 4 531 2719 3344 NO2I1_5VX1 $T=-97880 -188160 1 0 $X=-98310 $Y=-193280
X46544 5 4 532 2719 3345 NO2I1_5VX1 $T=-97880 -170240 1 0 $X=-98310 $Y=-175360
X46545 5 4 3347 2719 537 NO2I1_5VX1 $T=-93400 -224000 1 180 $X=-97750 $Y=-224640
X46546 5 4 543 2719 3352 NO2I1_5VX1 $T=-97320 -197120 1 0 $X=-97750 $Y=-202240
X46547 5 4 3172 2719 3362 NO2I1_5VX1 $T=-96760 -152320 1 0 $X=-97190 $Y=-157440
X46548 5 4 6812 2719 3360 NO2I1_5VX1 $T=-96760 -98560 0 0 $X=-97190 $Y=-99200
X46549 5 4 3286 2719 3287 NO2I1_5VX1 $T=-92280 -116480 0 180 $X=-96630 $Y=-121600
X46550 5 4 573 2719 6842 NO2I1_5VX1 $T=-85000 -143360 1 180 $X=-89350 $Y=-144000
X46551 5 4 614 3532 3505 NO2I1_5VX1 $T=-58680 -44800 0 180 $X=-63030 $Y=-49920
X46552 5 4 713 715 4595 NO2I1_5VX1 $T=-7160 -206080 1 0 $X=-7590 $Y=-211200
X46553 5 4 3808 715 3816 NO2I1_5VX1 $T=-2120 -170240 0 0 $X=-2550 $Y=-170880
X46554 5 4 3820 715 3229 NO2I1_5VX1 $T=1800 -143360 0 180 $X=-2550 $Y=-148480
X46555 5 4 7022 715 728 NO2I1_5VX1 $T=5160 -232960 0 180 $X=810 $Y=-238080
X46556 5 4 3828 715 3526 NO2I1_5VX1 $T=2360 -170240 0 0 $X=1930 $Y=-170880
X46557 5 4 734 715 3399 NO2I1_5VX1 $T=3480 -197120 0 0 $X=3050 $Y=-197760
X46558 5 4 735 715 7026 NO2I1_5VX1 $T=4600 -206080 0 0 $X=4170 $Y=-206720
X46559 5 4 738 715 7027 NO2I1_5VX1 $T=4600 -179200 0 0 $X=4170 $Y=-179840
X46560 5 4 748 715 7018 NO2I1_5VX1 $T=10200 -224000 1 180 $X=5850 $Y=-224640
X46561 5 4 3860 715 3267 NO2I1_5VX1 $T=10200 -161280 1 180 $X=5850 $Y=-161920
X46562 5 4 749 715 3801 NO2I1_5VX1 $T=10760 -232960 0 180 $X=6410 $Y=-238080
X46563 5 4 3747 7024 742 NO2I1_5VX1 $T=10760 -17920 1 180 $X=6410 $Y=-18560
X46564 5 4 3876 715 3831 NO2I1_5VX1 $T=11880 -116480 1 180 $X=7530 $Y=-117120
X46565 5 4 3182 715 755 NO2I1_5VX1 $T=8520 -224000 1 0 $X=8090 $Y=-229120
X46566 5 4 3865 715 3280 NO2I1_5VX1 $T=12440 -197120 1 180 $X=8090 $Y=-197760
X46567 5 4 756 715 3840 NO2I1_5VX1 $T=12440 -134400 1 180 $X=8090 $Y=-135040
X46568 5 4 7023 715 757 NO2I1_5VX1 $T=9080 -250880 1 0 $X=8650 $Y=-256000
X46569 5 4 3877 715 6767 NO2I1_5VX1 $T=14120 -98560 0 180 $X=9770 $Y=-103680
X46570 5 4 753 715 7033 NO2I1_5VX1 $T=10760 -161280 0 0 $X=10330 $Y=-161920
X46571 5 4 7036 715 763 NO2I1_5VX1 $T=17480 -116480 1 180 $X=13130 $Y=-117120
X46572 5 4 3878 715 3884 NO2I1_5VX1 $T=18040 -206080 0 180 $X=13690 $Y=-211200
X46573 5 4 3607 715 3899 NO2I1_5VX1 $T=14120 -98560 1 0 $X=13690 $Y=-103680
X46574 5 4 772 715 3208 NO2I1_5VX1 $T=18040 -71680 0 180 $X=13690 $Y=-76800
X46575 5 4 7031 715 771 NO2I1_5VX1 $T=14680 -250880 1 0 $X=14250 $Y=-256000
X46576 5 4 3676 715 7038 NO2I1_5VX1 $T=14680 -134400 0 0 $X=14250 $Y=-135040
X46577 5 4 3900 715 3186 NO2I1_5VX1 $T=18600 -89600 1 180 $X=14250 $Y=-90240
X46578 5 4 3872 715 778 NO2I1_5VX1 $T=15240 -62720 1 0 $X=14810 $Y=-67840
X46579 5 4 3905 715 3195 NO2I1_5VX1 $T=19160 -53760 0 180 $X=14810 $Y=-58880
X46580 5 4 3910 715 769 NO2I1_5VX1 $T=19720 -268800 1 180 $X=15370 $Y=-269440
X46581 5 4 765 715 7049 NO2I1_5VX1 $T=15800 -143360 0 0 $X=15370 $Y=-144000
X46582 5 4 3882 715 4183 NO2I1_5VX1 $T=15800 -71680 0 0 $X=15370 $Y=-72320
X46583 5 4 3889 715 773 NO2I1_5VX1 $T=16360 -161280 0 0 $X=15930 $Y=-161920
X46584 5 4 2927 715 3917 NO2I1_5VX1 $T=18600 -116480 0 0 $X=18170 $Y=-117120
X46585 5 4 3921 715 776 NO2I1_5VX1 $T=23080 -89600 0 180 $X=18730 $Y=-94720
X46586 5 4 2891 715 4571 NO2I1_5VX1 $T=19720 -125440 0 0 $X=19290 $Y=-126080
X46587 5 4 7057 715 781 NO2I1_5VX1 $T=24760 -143360 0 180 $X=20410 $Y=-148480
X46588 5 4 7067 715 786 NO2I1_5VX1 $T=27000 -89600 0 180 $X=22650 $Y=-94720
X46589 5 4 3951 715 3244 NO2I1_5VX1 $T=27560 -170240 0 180 $X=23210 $Y=-175360
X46590 5 4 3962 715 787 NO2I1_5VX1 $T=29800 -125440 1 180 $X=25450 $Y=-126080
X46591 5 4 3121 715 796 NO2I1_5VX1 $T=32040 -179200 1 0 $X=31610 $Y=-184320
X46592 5 4 4089 715 815 NO2I1_5VX1 $T=52200 -197120 1 180 $X=47850 $Y=-197760
X46593 5 4 825 715 4077 NO2I1_5VX1 $T=56680 -268800 1 180 $X=52330 $Y=-269440
X46594 5 4 3037 821 4103 NO2I1_5VX1 $T=52760 -8960 1 0 $X=52330 $Y=-14080
X46595 5 4 4115 715 3850 NO2I1_5VX1 $T=57240 -250880 0 180 $X=52890 $Y=-256000
X46596 5 4 4107 821 819 NO2I1_5VX1 $T=57240 -17920 0 180 $X=52890 $Y=-23040
X46597 5 4 4654 715 820 NO2I1_5VX1 $T=59480 -259840 0 180 $X=55130 $Y=-264960
X46598 5 4 4616 715 827 NO2I1_5VX1 $T=60600 -268800 0 180 $X=56250 $Y=-273920
X46599 5 4 837 715 7112 NO2I1_5VX1 $T=62840 -250880 0 180 $X=58490 $Y=-256000
X46600 5 4 4142 715 3260 NO2I1_5VX1 $T=62840 -232960 0 180 $X=58490 $Y=-238080
X46601 5 4 7126 821 833 NO2I1_5VX1 $T=62840 -35840 0 180 $X=58490 $Y=-40960
X46602 5 4 836 821 3192 NO2I1_5VX1 $T=63400 -17920 1 180 $X=59050 $Y=-18560
X46603 5 4 4123 715 841 NO2I1_5VX1 $T=60600 -241920 1 0 $X=60170 $Y=-247040
X46604 5 4 7113 715 845 NO2I1_5VX1 $T=60600 -224000 0 0 $X=60170 $Y=-224640
X46605 5 4 7125 715 6801 NO2I1_5VX1 $T=64520 -215040 1 180 $X=60170 $Y=-215680
X46606 5 4 4127 821 4130 NO2I1_5VX1 $T=64520 -26880 0 180 $X=60170 $Y=-32000
X46607 5 4 4136 821 4106 NO2I1_5VX1 $T=64520 -8960 1 180 $X=60170 $Y=-9600
X46608 5 4 838 715 7132 NO2I1_5VX1 $T=63960 -232960 0 0 $X=63530 $Y=-233600
X46609 5 4 7123 821 852 NO2I1_5VX1 $T=64520 -8960 0 0 $X=64090 $Y=-9600
X46610 5 4 860 715 4134 NO2I1_5VX1 $T=69000 -188160 0 180 $X=64650 $Y=-193280
X46611 5 4 3745 715 3969 NO2I1_5VX1 $T=69000 -161280 1 180 $X=64650 $Y=-161920
X46612 5 4 4094 821 844 NO2I1_5VX1 $T=69560 -71680 1 180 $X=65210 $Y=-72320
X46613 5 4 3976 821 3786 NO2I1_5VX1 $T=65640 -53760 0 0 $X=65210 $Y=-54400
X46614 5 4 4144 715 866 NO2I1_5VX1 $T=66200 -179200 1 0 $X=65770 $Y=-184320
X46615 5 4 858 715 7960 NO2I1_5VX1 $T=66200 -170240 0 0 $X=65770 $Y=-170880
X46616 5 4 4148 821 4179 NO2I1_5VX1 $T=66200 -17920 1 0 $X=65770 $Y=-23040
X46617 5 4 857 821 853 NO2I1_5VX1 $T=70680 0 1 180 $X=66330 $Y=-640
X46618 5 4 850 715 7133 NO2I1_5VX1 $T=67320 -206080 0 0 $X=66890 $Y=-206720
X46619 5 4 859 856 7134 NO2I1_5VX1 $T=67320 -134400 1 0 $X=66890 $Y=-139520
X46620 5 4 3160 821 865 NO2I1_5VX1 $T=67320 -44800 0 0 $X=66890 $Y=-45440
X46621 5 4 4165 821 3196 NO2I1_5VX1 $T=71240 -26880 1 180 $X=66890 $Y=-27520
X46622 5 4 7140 821 867 NO2I1_5VX1 $T=68440 -44800 1 0 $X=68010 $Y=-49920
X46623 5 4 861 821 868 NO2I1_5VX1 $T=68440 -8960 0 0 $X=68010 $Y=-9600
X46624 5 4 4176 821 4129 NO2I1_5VX1 $T=74040 -53760 0 180 $X=69690 $Y=-58880
X46625 5 4 4121 856 879 NO2I1_5VX1 $T=70680 -107520 1 0 $X=70250 $Y=-112640
X46626 5 4 4104 856 882 NO2I1_5VX1 $T=70680 -98560 0 0 $X=70250 $Y=-99200
X46627 5 4 4167 856 4174 NO2I1_5VX1 $T=71800 -89600 0 0 $X=71370 $Y=-90240
X46628 5 4 4193 856 880 NO2I1_5VX1 $T=77400 -107520 1 180 $X=73050 $Y=-108160
X46629 5 4 4195 821 4182 NO2I1_5VX1 $T=77960 -26880 1 180 $X=73610 $Y=-27520
X46630 5 4 4171 856 884 NO2I1_5VX1 $T=81880 -89600 1 180 $X=77530 $Y=-90240
X46631 5 4 4205 821 887 NO2I1_5VX1 $T=81880 8960 1 180 $X=77530 $Y=8320
X46632 5 4 4211 856 894 NO2I1_5VX1 $T=83000 -134400 1 180 $X=78650 $Y=-135040
X46633 5 4 4209 821 892 NO2I1_5VX1 $T=83000 8960 0 180 $X=78650 $Y=3840
X46634 5 4 4202 856 896 NO2I1_5VX1 $T=79640 -125440 0 0 $X=79210 $Y=-126080
X46635 5 4 4238 821 900 NO2I1_5VX1 $T=86920 8960 0 180 $X=82570 $Y=3840
X46636 5 4 4272 821 3204 NO2I1_5VX1 $T=92520 -44800 1 180 $X=88170 $Y=-45440
X46637 5 4 912 821 3205 NO2I1_5VX1 $T=92520 -8960 1 180 $X=88170 $Y=-9600
X46638 5 4 4485 821 4490 NO2I1_5VX1 $T=134520 -17920 0 0 $X=134090 $Y=-18560
X46639 5 4 984 993 7964 NO2I1_5VX1 $T=151880 -224000 1 0 $X=151450 $Y=-229120
X46640 5 4 7219 993 986 NO2I1_5VX1 $T=152440 -241920 1 0 $X=152010 $Y=-247040
X46641 5 4 4497 856 7224 NO2I1_5VX1 $T=152440 -89600 0 0 $X=152010 $Y=-90240
X46642 5 4 998 993 7230 NO2I1_5VX1 $T=159720 -152320 1 180 $X=155370 $Y=-152960
X46643 5 4 1005 993 7233 NO2I1_5VX1 $T=160840 -179200 0 180 $X=156490 $Y=-184320
X46644 5 4 991 821 5043 NO2I1_5VX1 $T=156920 -8960 1 0 $X=156490 $Y=-14080
X46645 5 4 1018 993 4523 NO2I1_5VX1 $T=164760 -206080 0 180 $X=160410 $Y=-211200
X46646 5 4 1019 993 4518 NO2I1_5VX1 $T=164760 -161280 0 180 $X=160410 $Y=-166400
X46647 5 4 1020 856 4520 NO2I1_5VX1 $T=164760 -125440 1 180 $X=160410 $Y=-126080
X46648 5 4 7235 856 4254 NO2I1_5VX1 $T=160840 -71680 1 0 $X=160410 $Y=-76800
X46649 5 4 4566 821 1021 NO2I1_5VX1 $T=160840 -26880 1 0 $X=160410 $Y=-32000
X46650 5 4 4543 821 4555 NO2I1_5VX1 $T=160840 -8960 1 0 $X=160410 $Y=-14080
X46651 5 4 1011 821 4558 NO2I1_5VX1 $T=160840 0 0 0 $X=160410 $Y=-640
X46652 5 4 1013 993 4562 NO2I1_5VX1 $T=161960 -170240 1 0 $X=161530 $Y=-175360
X46653 5 4 5111 856 7240 NO2I1_5VX1 $T=165880 -89600 0 180 $X=161530 $Y=-94720
X46654 5 4 7247 856 4521 NO2I1_5VX1 $T=167000 -44800 0 180 $X=162650 $Y=-49920
X46655 5 4 7250 856 1017 NO2I1_5VX1 $T=167560 -134400 1 180 $X=163210 $Y=-135040
X46656 5 4 7245 993 1037 NO2I1_5VX1 $T=164760 -161280 1 0 $X=164330 $Y=-166400
X46657 5 4 7238 993 1032 NO2I1_5VX1 $T=165320 -188160 1 0 $X=164890 $Y=-193280
X46658 5 4 4564 856 1022 NO2I1_5VX1 $T=169240 -116480 1 180 $X=164890 $Y=-117120
X46659 5 4 4561 993 1034 NO2I1_5VX1 $T=165880 -224000 1 0 $X=165450 $Y=-229120
X46660 5 4 4569 993 1027 NO2I1_5VX1 $T=170360 -206080 0 180 $X=166010 $Y=-211200
X46661 5 4 8117 856 1035 NO2I1_5VX1 $T=166440 -80640 0 0 $X=166010 $Y=-81280
X46662 5 4 8118 856 1036 NO2I1_5VX1 $T=166440 -44800 0 0 $X=166010 $Y=-45440
X46663 5 4 4579 856 4548 NO2I1_5VX1 $T=170360 -35840 0 180 $X=166010 $Y=-40960
X46664 5 4 7260 856 1029 NO2I1_5VX1 $T=170920 -98560 1 180 $X=166570 $Y=-99200
X46665 5 4 4573 993 1038 NO2I1_5VX1 $T=168680 -232960 1 0 $X=168250 $Y=-238080
X46666 5 4 4577 821 1046 NO2I1_5VX1 $T=169240 8960 0 0 $X=168810 $Y=8320
X46667 5 4 8119 993 1045 NO2I1_5VX1 $T=170360 -250880 0 0 $X=169930 $Y=-251520
X46668 5 4 7254 993 1051 NO2I1_5VX1 $T=170920 -188160 1 0 $X=170490 $Y=-193280
X46669 5 4 4581 856 4590 NO2I1_5VX1 $T=171480 -35840 1 0 $X=171050 $Y=-40960
X46670 5 4 7262 993 1053 NO2I1_5VX1 $T=173720 -232960 1 0 $X=173290 $Y=-238080
X46671 5 4 4589 856 1057 NO2I1_5VX1 $T=174280 -107520 1 0 $X=173850 $Y=-112640
X46672 5 4 4592 821 1062 NO2I1_5VX1 $T=174840 8960 0 0 $X=174410 $Y=8320
X46673 5 4 4594 821 1071 NO2I1_5VX1 $T=175400 -8960 0 0 $X=174970 $Y=-9600
X46674 5 4 7265 856 1065 NO2I1_5VX1 $T=175960 -98560 1 0 $X=175530 $Y=-103680
X46675 5 4 4603 993 1060 NO2I1_5VX1 $T=181000 -152320 1 180 $X=176650 $Y=-152960
X46676 5 4 1059 993 1066 NO2I1_5VX1 $T=177640 -268800 1 0 $X=177210 $Y=-273920
X46677 5 4 8097 856 4622 NO2I1_5VX1 $T=177640 -62720 1 0 $X=177210 $Y=-67840
X46678 5 4 4587 993 1064 NO2I1_5VX1 $T=182680 -179200 0 180 $X=178330 $Y=-184320
X46679 5 4 1495 993 4612 NO2I1_5VX1 $T=182680 -152320 0 180 $X=178330 $Y=-157440
X46680 5 4 1072 993 7270 NO2I1_5VX1 $T=179880 -250880 1 0 $X=179450 $Y=-256000
X46681 5 4 4657 993 1076 NO2I1_5VX1 $T=187160 -215040 1 180 $X=182810 $Y=-215680
X46682 5 4 4620 856 1082 NO2I1_5VX1 $T=189400 -134400 1 180 $X=185050 $Y=-135040
X46683 5 4 5939 856 4613 NO2I1_5VX1 $T=195000 -53760 0 180 $X=190650 $Y=-58880
X46684 5 4 1106 993 4655 NO2I1_5VX1 $T=198920 -241920 1 180 $X=194570 $Y=-242560
X46685 5 4 4708 856 4670 NO2I1_5VX1 $T=199480 -17920 1 180 $X=195130 $Y=-18560
X46686 5 4 4706 993 1101 NO2I1_5VX1 $T=200600 -250880 1 180 $X=196250 $Y=-251520
X46687 5 4 4726 856 4711 NO2I1_5VX1 $T=203960 -53760 1 180 $X=199610 $Y=-54400
X46688 5 4 7966 993 1131 NO2I1_5VX1 $T=212920 -197120 0 180 $X=208570 $Y=-202240
X46689 5 4 1500 856 1124 NO2I1_5VX1 $T=212920 -8960 1 180 $X=208570 $Y=-9600
X46690 5 4 7309 856 4786 NO2I1_5VX1 $T=209560 -35840 1 0 $X=209130 $Y=-40960
X46691 5 4 4749 993 1128 NO2I1_5VX1 $T=215160 -179200 0 180 $X=210810 $Y=-184320
X46692 5 4 8120 993 1130 NO2I1_5VX1 $T=215160 -170240 1 180 $X=210810 $Y=-170880
X46693 5 4 7322 856 1136 NO2I1_5VX1 $T=217400 -71680 1 180 $X=213050 $Y=-72320
X46694 5 4 1142 856 4709 NO2I1_5VX1 $T=217960 0 0 180 $X=213610 $Y=-5120
X46695 5 4 4685 856 4788 NO2I1_5VX1 $T=219080 -80640 0 180 $X=214730 $Y=-85760
X46696 5 4 4825 856 4630 NO2I1_5VX1 $T=219640 -89600 1 180 $X=215290 $Y=-90240
X46697 5 4 4817 856 1138 NO2I1_5VX1 $T=219640 -17920 1 180 $X=215290 $Y=-18560
X46698 5 4 4818 993 1141 NO2I1_5VX1 $T=220200 -161280 1 180 $X=215850 $Y=-161920
X46699 5 4 4785 856 6223 NO2I1_5VX1 $T=220200 -98560 0 180 $X=215850 $Y=-103680
X46700 5 4 4830 993 4819 NO2I1_5VX1 $T=222440 -152320 1 180 $X=218090 $Y=-152960
X46701 5 4 4842 856 4677 NO2I1_5VX1 $T=222440 -71680 1 180 $X=218090 $Y=-72320
X46702 5 4 4884 856 5510 NO2I1_5VX1 $T=231400 -26880 1 180 $X=227050 $Y=-27520
X46703 5 4 4970 856 4947 NO2I1_5VX1 $T=246520 -53760 0 180 $X=242170 $Y=-58880
X46704 5 4 4982 856 1179 NO2I1_5VX1 $T=248760 -134400 1 180 $X=244410 $Y=-135040
X46705 5 4 4995 856 4972 NO2I1_5VX1 $T=251000 -107520 0 180 $X=246650 $Y=-112640
X46706 5 4 5013 856 1182 NO2I1_5VX1 $T=253240 -125440 1 180 $X=248890 $Y=-126080
X46707 5 4 5027 856 4836 NO2I1_5VX1 $T=256040 -98560 1 180 $X=251690 $Y=-99200
X46708 5 4 5051 856 4862 NO2I1_5VX1 $T=262760 -17920 1 180 $X=258410 $Y=-18560
X46709 5 4 5040 856 4800 NO2I1_5VX1 $T=263320 -44800 0 180 $X=258970 $Y=-49920
X46710 5 4 5129 993 4807 NO2I1_5VX1 $T=266120 -179200 1 180 $X=261770 $Y=-179840
X46711 5 4 5056 993 4827 NO2I1_5VX1 $T=267800 -188160 0 180 $X=263450 $Y=-193280
X46712 5 4 5457 993 1203 NO2I1_5VX1 $T=268360 -268800 0 180 $X=264010 $Y=-273920
X46713 5 4 5057 993 4914 NO2I1_5VX1 $T=268360 -197120 1 180 $X=264010 $Y=-197760
X46714 5 4 5023 993 4864 NO2I1_5VX1 $T=268360 -170240 1 180 $X=264010 $Y=-170880
X46715 5 4 5061 993 4605 NO2I1_5VX1 $T=269480 -206080 1 180 $X=265130 $Y=-206720
X46716 5 4 1209 993 4720 NO2I1_5VX1 $T=270040 -170240 0 180 $X=265690 $Y=-175360
X46717 5 4 5093 993 5050 NO2I1_5VX1 $T=270040 -161280 0 180 $X=265690 $Y=-166400
X46718 5 4 5041 1088 5072 NO2I1_5VX1 $T=266120 -134400 0 0 $X=265690 $Y=-135040
X46719 5 4 5083 856 1206 NO2I1_5VX1 $T=271160 8960 0 180 $X=266810 $Y=3840
X46720 5 4 7971 856 5109 NO2I1_5VX1 $T=267800 -125440 0 0 $X=267370 $Y=-126080
X46721 5 4 1214 993 4647 NO2I1_5VX1 $T=272280 -197120 1 180 $X=267930 $Y=-197760
X46722 5 4 5058 1088 5071 NO2I1_5VX1 $T=268360 -152320 0 0 $X=267930 $Y=-152960
X46723 5 4 5078 856 4676 NO2I1_5VX1 $T=272280 0 1 180 $X=267930 $Y=-640
X46724 5 4 5068 856 5110 NO2I1_5VX1 $T=269480 -107520 1 0 $X=269050 $Y=-112640
X46725 5 4 5105 856 4871 NO2I1_5VX1 $T=273400 -71680 1 180 $X=269050 $Y=-72320
X46726 5 4 5096 856 4847 NO2I1_5VX1 $T=273400 0 0 180 $X=269050 $Y=-5120
X46727 5 4 1213 856 1208 NO2I1_5VX1 $T=275080 8960 1 180 $X=270730 $Y=8320
X46728 5 4 5123 856 7335 NO2I1_5VX1 $T=278440 -80640 0 180 $X=274090 $Y=-85760
X46729 5 4 1226 856 4758 NO2I1_5VX1 $T=285720 -8960 1 180 $X=281370 $Y=-9600
X46730 5 4 1245 1088 4668 NO2I1_5VX1 $T=303640 -152320 1 180 $X=299290 $Y=-152960
X46731 5 4 7453 5230 5247 NO2I1_5VX1 $T=302520 -35840 0 0 $X=302090 $Y=-36480
X46732 5 4 1250 1088 7313 NO2I1_5VX1 $T=308680 -143360 1 180 $X=304330 $Y=-144000
X46733 5 4 5257 1505 7478 NO2I1_5VX1 $T=307560 -53760 0 0 $X=307130 $Y=-54400
X46734 5 4 5309 1088 4752 NO2I1_5VX1 $T=317640 -107520 1 180 $X=313290 $Y=-108160
X46735 5 4 5355 1088 7507 NO2I1_5VX1 $T=330520 -188160 1 180 $X=326170 $Y=-188800
X46736 5 4 1279 1088 7524 NO2I1_5VX1 $T=338360 -179200 1 180 $X=334010 $Y=-179840
X46737 5 4 5479 1088 4744 NO2I1_5VX1 $T=358520 -125440 0 180 $X=354170 $Y=-130560
X46738 5 4 7575 821 5502 NO2I1_5VX1 $T=357400 -8960 0 0 $X=356970 $Y=-9600
X46739 5 4 7590 821 5449 NO2I1_5VX1 $T=361320 0 1 180 $X=356970 $Y=-640
X46740 5 4 5516 821 4672 NO2I1_5VX1 $T=363560 -26880 1 180 $X=359210 $Y=-27520
X46741 5 4 5495 821 1307 NO2I1_5VX1 $T=360200 8960 1 0 $X=359770 $Y=3840
X46742 5 4 5501 821 5513 NO2I1_5VX1 $T=360760 -44800 0 0 $X=360330 $Y=-45440
X46743 5 4 5527 821 5511 NO2I1_5VX1 $T=366360 -35840 1 180 $X=362010 $Y=-36480
X46744 5 4 7588 821 7604 NO2I1_5VX1 $T=362440 -8960 0 0 $X=362010 $Y=-9600
X46745 5 4 7603 1088 1308 NO2I1_5VX1 $T=368600 -224000 1 180 $X=364250 $Y=-224640
X46746 5 4 5488 821 5533 NO2I1_5VX1 $T=364680 -71680 1 0 $X=364250 $Y=-76800
X46747 5 4 7600 1088 6220 NO2I1_5VX1 $T=365240 -89600 0 0 $X=364810 $Y=-90240
X46748 5 4 7611 821 5490 NO2I1_5VX1 $T=369160 -26880 1 180 $X=364810 $Y=-27520
X46749 5 4 5543 1088 5508 NO2I1_5VX1 $T=369720 -143360 0 180 $X=365370 $Y=-148480
X46750 5 4 7978 1088 5541 NO2I1_5VX1 $T=366360 -125440 1 0 $X=365930 $Y=-130560
X46751 5 4 7601 1088 1314 NO2I1_5VX1 $T=366920 -268800 0 0 $X=366490 $Y=-269440
X46752 5 4 8121 1088 6137 NO2I1_5VX1 $T=370840 -161280 1 180 $X=366490 $Y=-161920
X46753 5 4 7613 1088 5538 NO2I1_5VX1 $T=370840 -107520 1 180 $X=366490 $Y=-108160
X46754 5 4 5549 821 4741 NO2I1_5VX1 $T=370840 -62720 0 180 $X=366490 $Y=-67840
X46755 5 4 5548 821 4651 NO2I1_5VX1 $T=370840 -35840 1 180 $X=366490 $Y=-36480
X46756 5 4 5554 1088 5540 NO2I1_5VX1 $T=372520 -188160 0 180 $X=368170 $Y=-193280
X46757 5 4 7610 1088 5560 NO2I1_5VX1 $T=369720 -143360 1 0 $X=369290 $Y=-148480
X46758 5 4 5559 821 4694 NO2I1_5VX1 $T=373640 -71680 0 180 $X=369290 $Y=-76800
X46759 5 4 7608 1088 5998 NO2I1_5VX1 $T=370280 -215040 0 0 $X=369850 $Y=-215680
X46760 5 4 7616 1088 5565 NO2I1_5VX1 $T=371400 -241920 0 0 $X=370970 $Y=-242560
X46761 5 4 5572 1088 5102 NO2I1_5VX1 $T=375320 -206080 1 180 $X=370970 $Y=-206720
X46762 5 4 5574 1088 5297 NO2I1_5VX1 $T=375320 -152320 0 180 $X=370970 $Y=-157440
X46763 5 4 7626 821 5534 NO2I1_5VX1 $T=375320 -44800 0 180 $X=370970 $Y=-49920
X46764 5 4 5555 1088 7621 NO2I1_5VX1 $T=372520 -170240 0 0 $X=372090 $Y=-170880
X46765 5 4 5529 1088 5577 NO2I1_5VX1 $T=373080 -250880 1 0 $X=372650 $Y=-256000
X46766 5 4 8061 1088 5509 NO2I1_5VX1 $T=377560 -98560 1 180 $X=373210 $Y=-99200
X46767 5 4 5561 1088 5576 NO2I1_5VX1 $T=378680 -116480 1 180 $X=374330 $Y=-117120
X46768 5 4 5550 1088 5589 NO2I1_5VX1 $T=375320 -224000 1 0 $X=374890 $Y=-229120
X46769 5 4 5592 1088 5573 NO2I1_5VX1 $T=379240 -179200 0 180 $X=374890 $Y=-184320
X46770 5 4 8063 5581 7605 NO2I1_5VX1 $T=379240 -71680 1 180 $X=374890 $Y=-72320
X46771 5 4 5578 1088 7627 NO2I1_5VX1 $T=376440 -206080 0 0 $X=376010 $Y=-206720
X46772 5 4 7618 1088 6225 NO2I1_5VX1 $T=376440 -89600 1 0 $X=376010 $Y=-94720
X46773 5 4 7622 1088 7634 NO2I1_5VX1 $T=377000 -152320 1 0 $X=376570 $Y=-157440
X46774 5 4 5598 5581 5567 NO2I1_5VX1 $T=382600 -80640 1 180 $X=378250 $Y=-81280
X46775 5 4 7642 5581 7620 NO2I1_5VX1 $T=383160 -44800 1 180 $X=378810 $Y=-45440
X46776 5 4 7636 1088 5597 NO2I1_5VX1 $T=384280 -134400 1 180 $X=379930 $Y=-135040
X46777 5 4 5584 5581 5599 NO2I1_5VX1 $T=384280 -53760 0 180 $X=379930 $Y=-58880
X46778 5 4 7635 1088 5481 NO2I1_5VX1 $T=384840 -188160 1 180 $X=380490 $Y=-188800
X46779 5 4 7990 1088 7629 NO2I1_5VX1 $T=386520 -215040 0 180 $X=382170 $Y=-220160
X46780 5 4 5626 1088 5575 NO2I1_5VX1 $T=387080 -116480 0 180 $X=382730 $Y=-121600
X46781 5 4 7989 1088 7624 NO2I1_5VX1 $T=387640 -250880 1 180 $X=383290 $Y=-251520
X46782 5 4 1321 1088 7638 NO2I1_5VX1 $T=388200 -259840 1 180 $X=383850 $Y=-260480
X46783 5 4 5816 5581 5568 NO2I1_5VX1 $T=440280 -17920 1 180 $X=435930 $Y=-18560
X46784 5 4 5824 5581 5614 NO2I1_5VX1 $T=445880 -107520 1 180 $X=441530 $Y=-108160
X46785 5 4 5839 5581 5618 NO2I1_5VX1 $T=447560 -89600 1 180 $X=443210 $Y=-90240
X46786 5 4 5843 5581 5619 NO2I1_5VX1 $T=448120 -53760 0 180 $X=443770 $Y=-58880
X46787 5 4 7750 5581 5622 NO2I1_5VX1 $T=450360 -71680 0 180 $X=446010 $Y=-76800
X46788 5 4 5846 5581 5603 NO2I1_5VX1 $T=450360 -35840 0 180 $X=446010 $Y=-40960
X46789 5 4 5852 5581 5580 NO2I1_5VX1 $T=452040 -125440 1 180 $X=447690 $Y=-126080
X46790 5 4 5862 5581 5595 NO2I1_5VX1 $T=452600 -161280 1 180 $X=448250 $Y=-161920
X46791 5 4 5880 5581 5620 NO2I1_5VX1 $T=454280 -188160 1 180 $X=449930 $Y=-188800
X46792 5 4 5872 5581 7598 NO2I1_5VX1 $T=454280 -152320 1 180 $X=449930 $Y=-152960
X46793 5 4 5873 5581 5518 NO2I1_5VX1 $T=454840 -161280 0 180 $X=450490 $Y=-166400
X46794 5 4 7781 1133 5915 NO2I1_5VX1 $T=467160 -197120 1 180 $X=462810 $Y=-197760
X46795 5 4 1180 5956 5978 NO2I1_5VX1 $T=472200 -250880 0 0 $X=471770 $Y=-251520
X46796 5 4 7858 1088 6181 NO2I1_5VX1 $T=509160 0 0 0 $X=508730 $Y=-640
X46797 5 4 7864 1088 6130 NO2I1_5VX1 $T=510840 -17920 0 0 $X=510410 $Y=-18560
X46798 5 4 8065 1088 6131 NO2I1_5VX1 $T=511400 8960 0 0 $X=510970 $Y=8320
X46799 5 4 6121 5581 6140 NO2I1_5VX1 $T=513640 -35840 1 0 $X=513210 $Y=-40960
X46800 5 4 7870 1088 6142 NO2I1_5VX1 $T=514760 -17920 1 0 $X=514330 $Y=-23040
X46801 5 4 8067 5581 6159 NO2I1_5VX1 $T=515880 -53760 1 0 $X=515450 $Y=-58880
X46802 5 4 7884 5581 6162 NO2I1_5VX1 $T=518120 -35840 1 0 $X=517690 $Y=-40960
X46803 5 4 6151 5581 6150 NO2I1_5VX1 $T=518680 -197120 1 0 $X=518250 $Y=-202240
X46804 5 4 6146 5581 6206 NO2I1_5VX1 $T=518680 -89600 0 0 $X=518250 $Y=-90240
X46805 5 4 6136 5581 6170 NO2I1_5VX1 $T=518680 -71680 1 0 $X=518250 $Y=-76800
X46806 5 4 6158 5581 6169 NO2I1_5VX1 $T=520360 -107520 0 0 $X=519930 $Y=-108160
X46807 5 4 7893 5581 6175 NO2I1_5VX1 $T=521480 -53760 1 0 $X=521050 $Y=-58880
X46808 5 4 6221 5581 6178 NO2I1_5VX1 $T=522600 -152320 1 0 $X=522170 $Y=-157440
X46809 5 4 7910 5581 6172 NO2I1_5VX1 $T=527640 -197120 0 180 $X=523290 $Y=-202240
X46810 5 4 7896 5581 6179 NO2I1_5VX1 $T=523720 -71680 1 0 $X=523290 $Y=-76800
X46811 5 4 7903 5581 6189 NO2I1_5VX1 $T=525400 -107520 0 0 $X=524970 $Y=-108160
X46812 5 4 6212 5581 7906 NO2I1_5VX1 $T=525960 -161280 1 0 $X=525530 $Y=-166400
X46813 5 4 7905 5581 6186 NO2I1_5VX1 $T=525960 -89600 1 0 $X=525530 $Y=-94720
X46814 5 4 7907 5581 6188 NO2I1_5VX1 $T=526520 -116480 1 0 $X=526090 $Y=-121600
X46815 5 4 7908 5581 6190 NO2I1_5VX1 $T=527640 -125440 1 0 $X=527210 $Y=-130560
X46816 5 4 7904 5581 6192 NO2I1_5VX1 $T=528200 -179200 1 0 $X=527770 $Y=-184320
X46817 5 4 6184 5581 6193 NO2I1_5VX1 $T=528760 -188160 1 0 $X=528330 $Y=-193280
X46818 5 4 6196 5581 6187 NO2I1_5VX1 $T=532680 -143360 1 180 $X=528330 $Y=-144000
X46819 5 4 6194 5581 6217 NO2I1_5VX1 $T=531560 -161280 1 0 $X=531130 $Y=-166400
X46820 5 4 49 51 1838 EN2_5VX1 $T=-445640 -8960 1 180 $X=-452230 $Y=-9600
X46821 5 4 54 49 8073 EN2_5VX1 $T=-436120 -26880 0 180 $X=-442710 $Y=-32000
X46822 5 4 58 59 8074 EN2_5VX1 $T=-433880 -98560 1 180 $X=-440470 $Y=-99200
X46823 5 4 1841 58 1840 EN2_5VX1 $T=-431640 -116480 1 180 $X=-438230 $Y=-117120
X46824 5 4 59 48 6314 EN2_5VX1 $T=-427720 -71680 1 180 $X=-434310 $Y=-72320
X46825 5 4 1870 1851 72 EN2_5VX1 $T=-431080 -17920 0 0 $X=-431510 $Y=-18560
X46826 5 4 1447 1452 1934 EN2_5VX1 $T=-424920 -188160 1 0 $X=-425350 $Y=-193280
X46827 5 4 80 1447 6331 EN2_5VX1 $T=-418200 -215040 1 180 $X=-424790 $Y=-215680
X46828 5 4 1452 1462 6321 EN2_5VX1 $T=-417080 -179200 1 180 $X=-423670 $Y=-179840
X46829 5 4 84 79 6352 EN2_5VX1 $T=-415400 -232960 0 0 $X=-415830 $Y=-233600
X46830 5 4 79 80 6344 EN2_5VX1 $T=-408680 -224000 1 180 $X=-415270 $Y=-224640
X46831 5 4 89 84 6365 EN2_5VX1 $T=-413160 -241920 1 0 $X=-413590 $Y=-247040
X46832 5 4 1986 1961 1993 EN2_5VX1 $T=-412040 -188160 1 0 $X=-412470 $Y=-193280
X46833 5 4 84 80 6387 EN2_5VX1 $T=-393560 -134400 0 180 $X=-400150 $Y=-139520
X46834 5 4 2304 141 2412 EN2_5VX1 $T=-325800 -224000 1 0 $X=-326230 $Y=-229120
X46835 5 4 137 100 2363 EN2_5VX1 $T=-306200 -197120 0 180 $X=-312790 $Y=-202240
X46836 5 4 2475 2493 2452 EN2_5VX1 $T=-286600 -26880 0 180 $X=-293190 $Y=-32000
X46837 5 4 6543 49 234 EN2_5VX1 $T=-283800 -8960 0 0 $X=-284230 $Y=-9600
X46838 5 4 79 2638 2464 EN2_5VX1 $T=-271480 -152320 1 180 $X=-278070 $Y=-152960
X46839 5 4 92 84 2638 EN2_5VX1 $T=-264200 -206080 1 0 $X=-264630 $Y=-211200
X46840 5 4 2652 2665 6597 EN2_5VX1 $T=-258040 -206080 1 0 $X=-258470 $Y=-211200
X46841 5 4 296 286 2652 EN2_5VX1 $T=-241240 -259840 1 180 $X=-247830 $Y=-260480
X46842 5 4 140 301 2739 EN2_5VX1 $T=-243480 -268800 1 0 $X=-243910 $Y=-273920
X46843 5 4 298 2776 2753 EN2_5VX1 $T=-240680 -17920 0 0 $X=-241110 $Y=-18560
X46844 5 4 314 2787 6633 EN2_5VX1 $T=-231720 -53760 1 0 $X=-232150 $Y=-58880
X46845 5 4 138 139 2755 EN2_5VX1 $T=-222760 -241920 0 180 $X=-229350 $Y=-247040
X46846 5 4 328 331 335 EN2_5VX1 $T=-226120 8960 0 0 $X=-226550 $Y=8320
X46847 5 4 79 80 6663 EN2_5VX1 $T=-217720 -107520 1 0 $X=-218150 $Y=-112640
X46848 5 4 1900 2878 2869 EN2_5VX1 $T=-217720 -26880 0 0 $X=-218150 $Y=-27520
X46849 5 4 3188 3228 6772 EN2_5VX1 $T=-142120 -26880 1 0 $X=-142550 $Y=-32000
X46850 5 4 598 594 3445 EN2_5VX1 $T=-70440 8960 0 180 $X=-77030 $Y=3840
X46851 5 4 3459 3471 6883 EN2_5VX1 $T=-75480 -62720 0 0 $X=-75910 $Y=-63360
X46852 5 4 3551 605 3484 EN2_5VX1 $T=-64280 -80640 1 180 $X=-70870 $Y=-81280
X46853 5 4 3516 608 3471 EN2_5VX1 $T=-62040 0 0 180 $X=-68630 $Y=-5120
X46854 5 4 3514 604 3503 EN2_5VX1 $T=-60360 -71680 0 180 $X=-66950 $Y=-76800
X46855 5 4 3539 3515 3468 EN2_5VX1 $T=-55880 -125440 0 180 $X=-62470 $Y=-130560
X46856 5 4 3536 626 3510 EN2_5VX1 $T=-53640 -26880 0 180 $X=-60230 $Y=-32000
X46857 5 4 611 3545 3606 EN2_5VX1 $T=-55880 -71680 1 0 $X=-56310 $Y=-76800
X46858 5 4 3546 641 3470 EN2_5VX1 $T=-45800 -44800 1 180 $X=-52390 $Y=-45440
X46859 5 4 625 3656 3589 EN2_5VX1 $T=-27880 -44800 1 180 $X=-34470 $Y=-45440
X46860 5 4 679 637 6956 EN2_5VX1 $T=-22840 -241920 1 180 $X=-29430 $Y=-242560
X46861 5 4 677 3717 3661 EN2_5VX1 $T=-20040 -215040 0 180 $X=-26630 $Y=-220160
X46862 5 4 683 670 3713 EN2_5VX1 $T=-25640 -268800 0 0 $X=-26070 $Y=-269440
X46863 5 4 637 677 3720 EN2_5VX1 $T=-13320 -215040 0 180 $X=-19910 $Y=-220160
X46864 5 4 607 659 7080 EN2_5VX1 $T=44920 0 1 180 $X=38330 $Y=-640
X46865 5 4 670 637 4108 EN2_5VX1 $T=40440 -250880 0 0 $X=40010 $Y=-251520
X46866 5 4 3504 625 4088 EN2_5VX1 $T=44360 -44800 1 0 $X=43930 $Y=-49920
X46867 5 4 1489 1496 7104 EN2_5VX1 $T=55560 -98560 0 180 $X=48970 $Y=-103680
X46868 5 4 1496 3504 7102 EN2_5VX1 $T=55560 -80640 1 180 $X=48970 $Y=-81280
X46869 5 4 584 1489 4128 EN2_5VX1 $T=71800 -125440 0 180 $X=65210 $Y=-130560
X46870 5 4 632 592 7135 EN2_5VX1 $T=66200 -241920 1 0 $X=65770 $Y=-247040
X46871 5 4 624 584 7151 EN2_5VX1 $T=75160 -152320 0 0 $X=74730 $Y=-152960
X46872 5 4 595 881 7150 EN2_5VX1 $T=75720 -197120 1 0 $X=75290 $Y=-202240
X46873 5 4 592 595 7149 EN2_5VX1 $T=79080 -215040 1 0 $X=78650 $Y=-220160
X46874 5 4 881 624 7159 EN2_5VX1 $T=80760 -170240 0 0 $X=80330 $Y=-170880
X46875 5 4 607 4246 4208 EN2_5VX1 $T=91400 -62720 1 180 $X=84810 $Y=-63360
X46876 5 4 4237 7181 4360 EN2_5VX1 $T=103720 -26880 1 0 $X=103290 $Y=-32000
X46877 5 4 4273 604 944 EN2_5VX1 $T=107640 -8960 1 0 $X=107210 $Y=-14080
X46878 5 4 1157 4889 4964 EN2_5VX1 $T=240920 -17920 0 0 $X=240490 $Y=-18560
X46879 5 4 1181 1186 1196 EN2_5VX1 $T=267240 8960 0 180 $X=260650 $Y=3840
X46880 5 4 1210 1192 5252 EN2_5VX1 $T=300840 -232960 1 0 $X=300410 $Y=-238080
X46881 5 4 1192 1180 7465 EN2_5VX1 $T=302520 -224000 0 0 $X=302090 $Y=-224640
X46882 5 4 1117 1133 7472 EN2_5VX1 $T=302520 -179200 0 0 $X=302090 $Y=-179840
X46883 5 4 1180 1119 7458 EN2_5VX1 $T=309240 -206080 0 180 $X=302650 $Y=-211200
X46884 5 4 1195 1210 7486 EN2_5VX1 $T=308120 -250880 0 0 $X=307690 $Y=-251520
X46885 5 4 1170 5247 8100 EN2_5VX1 $T=315960 -26880 0 180 $X=309370 $Y=-32000
X46886 5 4 1506 4769 5267 EN2_5VX1 $T=317640 -26880 1 180 $X=311050 $Y=-27520
X46887 5 4 1523 1506 5285 EN2_5VX1 $T=319320 -44800 0 180 $X=312730 $Y=-49920
X46888 5 4 7494 5290 7474 EN2_5VX1 $T=320440 -35840 1 180 $X=313850 $Y=-36480
X46889 5 4 1123 5278 5339 EN2_5VX1 $T=314840 -170240 0 0 $X=314410 $Y=-170880
X46890 5 4 4769 5319 7494 EN2_5VX1 $T=316520 -26880 1 0 $X=316090 $Y=-32000
X46891 5 4 1504 7496 7503 EN2_5VX1 $T=318200 -89600 0 0 $X=317770 $Y=-90240
X46892 5 4 1168 1165 1509 EN2_5VX1 $T=318200 8960 1 0 $X=317770 $Y=3840
X46893 5 4 7503 7488 5271 EN2_5VX1 $T=324920 -89600 0 180 $X=318330 $Y=-94720
X46894 5 4 5339 7500 7495 EN2_5VX1 $T=327720 -170240 1 180 $X=321130 $Y=-170880
X46895 5 4 1170 5346 1269 EN2_5VX1 $T=331640 8960 0 180 $X=325050 $Y=3840
X46896 5 4 1506 4769 5781 EN2_5VX1 $T=429640 -17920 1 0 $X=429210 $Y=-23040
X46897 5 4 1192 1180 5817 EN2_5VX1 $T=438600 -215040 1 0 $X=438170 $Y=-220160
X46898 5 4 1506 1168 7731 EN2_5VX1 $T=439160 -8960 1 0 $X=438730 $Y=-14080
X46899 5 4 4769 1165 7729 EN2_5VX1 $T=449240 -17920 0 180 $X=442650 $Y=-23040
X46900 5 4 1119 1117 5841 EN2_5VX1 $T=443640 -232960 1 0 $X=443210 $Y=-238080
X46901 5 4 1168 1159 1368 EN2_5VX1 $T=451480 0 1 180 $X=444890 $Y=-640
X46902 5 4 1379 1378 1373 EN2_5VX1 $T=457080 -268800 0 180 $X=450490 $Y=-273920
X46903 5 4 1109 4762 5887 EN2_5VX1 $T=453160 -170240 1 0 $X=452730 $Y=-175360
X46904 5 4 4762 4754 5900 EN2_5VX1 $T=454280 -161280 0 0 $X=453850 $Y=-161920
X46905 5 4 1117 1133 5899 EN2_5VX1 $T=455400 -224000 1 0 $X=454970 $Y=-229120
X46906 5 4 1387 1210 7782 EN2_5VX1 $T=463240 -241920 0 0 $X=462810 $Y=-242560
X46907 5 4 1523 1506 7792 EN2_5VX1 $T=463800 -80640 1 0 $X=463370 $Y=-85760
X46908 5 4 1387 1195 7787 EN2_5VX1 $T=476680 -241920 1 180 $X=470090 $Y=-242560
X46909 5 4 1210 1180 7790 EN2_5VX1 $T=477800 -224000 0 180 $X=471210 $Y=-229120
X46910 5 4 1117 1123 5973 EN2_5VX1 $T=472760 -152320 0 0 $X=472330 $Y=-152960
X46911 5 4 1119 1133 7806 EN2_5VX1 $T=473880 -197120 0 0 $X=473450 $Y=-197760
X46912 5 4 1168 1165 7811 EN2_5VX1 $T=489000 -35840 0 180 $X=482410 $Y=-40960
X46913 5 4 4754 1515 5996 EN2_5VX1 $T=492360 -143360 0 180 $X=485770 $Y=-148480
X46914 5 4 1165 1159 7823 EN2_5VX1 $T=494040 -8960 1 180 $X=487450 $Y=-9600
X46915 5 4 1195 1192 5991 EN2_5VX1 $T=499640 -232960 1 180 $X=493050 $Y=-233600
X46916 5 4 1786 6300 1806 NA2_5VX1 $T=-451240 -35840 1 0 $X=-451670 $Y=-40960
X46917 5 4 54 1869 51 NA2_5VX1 $T=-426600 -44800 1 180 $X=-429830 $Y=-45440
X46918 5 4 1905 1832 1895 NA2_5VX1 $T=-426040 -125440 1 180 $X=-429270 $Y=-126080
X46919 5 4 2009 1956 1951 NA2_5VX1 $T=-409240 -107520 1 180 $X=-412470 $Y=-108160
X46920 5 4 92 2010 84 NA2_5VX1 $T=-405320 -179200 0 0 $X=-405750 $Y=-179840
X46921 5 4 45 1974 90 NA2_5VX1 $T=-399720 8960 1 180 $X=-402950 $Y=8320
X46922 5 4 2427 2492 2456 NA2_5VX1 $T=-291080 -125440 1 0 $X=-291510 $Y=-130560
X46923 5 4 2477 2589 2475 NA2_5VX1 $T=-282120 -98560 1 0 $X=-282550 $Y=-103680
X46924 5 4 59 236 48 NA2_5VX1 $T=-278200 8960 1 0 $X=-278630 $Y=3840
X46925 5 4 2549 251 2627 NA2_5VX1 $T=-260840 -8960 1 180 $X=-264070 $Y=-9600
X46926 5 4 6633 2817 2786 NA2_5VX1 $T=-230040 -62720 1 0 $X=-230470 $Y=-67840
X46927 5 4 2785 2791 2773 NA2_5VX1 $T=-228920 -80640 0 0 $X=-229350 $Y=-81280
X46928 5 4 2753 6640 2772 NA2_5VX1 $T=-221640 -17920 0 180 $X=-224870 $Y=-23040
X46929 5 4 6647 6649 2838 NA2_5VX1 $T=-222760 -161280 0 0 $X=-223190 $Y=-161920
X46930 5 4 2818 2827 1468 NA2_5VX1 $T=-222200 -188160 0 0 $X=-222630 $Y=-188800
X46931 5 4 335 342 338 NA2_5VX1 $T=-219960 8960 0 0 $X=-220390 $Y=8320
X46932 5 4 2865 6659 2849 NA2_5VX1 $T=-212680 -80640 0 180 $X=-215910 $Y=-85760
X46933 5 4 2849 6661 6664 NA2_5VX1 $T=-214920 -71680 0 0 $X=-215350 $Y=-72320
X46934 5 4 1468 2851 1471 NA2_5VX1 $T=-211000 -152320 1 180 $X=-214230 $Y=-152960
X46935 5 4 1471 6665 2865 NA2_5VX1 $T=-211000 -98560 0 180 $X=-214230 $Y=-103680
X46936 5 4 6664 2886 2883 NA2_5VX1 $T=-212120 -44800 1 0 $X=-212550 $Y=-49920
X46937 5 4 2838 6668 1471 NA2_5VX1 $T=-206520 -179200 1 180 $X=-209750 $Y=-179840
X46938 5 4 3261 3245 3265 NA2_5VX1 $T=-121400 -224000 1 180 $X=-124630 $Y=-224640
X46939 5 4 3304 3249 6794 NA2_5VX1 $T=-118040 -206080 1 180 $X=-121270 $Y=-206720
X46940 5 4 3285 1478 6804 NA2_5VX1 $T=-116920 -179200 0 180 $X=-120150 $Y=-184320
X46941 5 4 3198 3256 3266 NA2_5VX1 $T=-115800 -170240 1 180 $X=-119030 $Y=-170880
X46942 5 4 3532 6902 615 NA2_5VX1 $T=-58680 -17920 0 180 $X=-61910 $Y=-23040
X46943 5 4 638 6919 3595 NA2_5VX1 $T=-50280 -89600 0 0 $X=-50710 $Y=-90240
X46944 5 4 607 3583 620 NA2_5VX1 $T=-45240 -98560 0 180 $X=-48470 $Y=-103680
X46945 5 4 644 3601 1484 NA2_5VX1 $T=-47480 -188160 0 0 $X=-47910 $Y=-188800
X46946 5 4 1484 3576 638 NA2_5VX1 $T=-43000 -170240 0 180 $X=-46230 $Y=-175360
X46947 5 4 3595 3614 6932 NA2_5VX1 $T=-44120 -80640 0 0 $X=-44550 $Y=-81280
X46948 5 4 6932 3623 3628 NA2_5VX1 $T=-41320 -53760 1 0 $X=-41750 $Y=-58880
X46949 5 4 3646 1485 1484 NA2_5VX1 $T=-35720 -241920 1 180 $X=-38950 $Y=-242560
X46950 5 4 632 1486 595 NA2_5VX1 $T=-37960 -224000 0 0 $X=-38390 $Y=-224640
X46951 5 4 3646 6946 644 NA2_5VX1 $T=-36280 -206080 0 0 $X=-36710 $Y=-206720
X46952 5 4 3628 6944 3585 NA2_5VX1 $T=-31800 -35840 0 180 $X=-35030 $Y=-40960
X46953 5 4 671 3681 3717 NA2_5VX1 $T=-31240 -215040 1 0 $X=-31670 $Y=-220160
X46954 5 4 694 6973 3729 NA2_5VX1 $T=-16120 -268800 1 180 $X=-19350 $Y=-269440
X46955 5 4 3733 3683 3757 NA2_5VX1 $T=-15000 -241920 1 180 $X=-18230 $Y=-242560
X46956 5 4 3729 6981 3733 NA2_5VX1 $T=-17240 -250880 0 0 $X=-17670 $Y=-251520
X46957 5 4 3757 6988 3748 NA2_5VX1 $T=-10520 -250880 0 180 $X=-13750 $Y=-256000
X46958 5 4 3812 3784 7017 NA2_5VX1 $T=680 -89600 0 180 $X=-2550 $Y=-94720
X46959 5 4 620 3821 623 NA2_5VX1 $T=3480 0 0 180 $X=250 $Y=-5120
X46960 5 4 611 3747 620 NA2_5VX1 $T=4600 -26880 0 0 $X=4170 $Y=-27520
X46961 5 4 586 4029 584 NA2_5VX1 $T=47160 -170240 1 180 $X=43930 $Y=-170880
X46962 5 4 855 7137 4140 NA2_5VX1 $T=69560 -268800 0 0 $X=69130 $Y=-269440
X46963 5 4 1170 5237 5204 NA2_5VX1 $T=302520 -53760 0 180 $X=299290 $Y=-58880
X46964 5 4 1157 5257 5242 NA2_5VX1 $T=303640 -53760 1 0 $X=303210 $Y=-58880
X46965 5 4 5263 5260 7463 NA2_5VX1 $T=307560 -197120 1 180 $X=304330 $Y=-197760
X46966 5 4 1173 7453 5246 NA2_5VX1 $T=312040 -35840 1 180 $X=308810 $Y=-36480
X46967 5 4 5284 5249 5263 NA2_5VX1 $T=313160 -206080 0 180 $X=309930 $Y=-211200
X46968 5 4 1251 5258 5284 NA2_5VX1 $T=314280 -224000 1 180 $X=311050 $Y=-224640
X46969 5 4 7482 5269 5278 NA2_5VX1 $T=314280 -143360 0 180 $X=311050 $Y=-148480
X46970 5 4 5295 5255 1251 NA2_5VX1 $T=314840 -232960 0 180 $X=311610 $Y=-238080
X46971 5 4 1256 7481 5295 NA2_5VX1 $T=314840 -250880 1 0 $X=314410 $Y=-256000
X46972 5 4 5298 7483 5270 NA2_5VX1 $T=319880 -107520 0 180 $X=316650 $Y=-112640
X46973 5 4 7709 5785 1516 NA2_5VX1 $T=434120 -62720 1 0 $X=433690 $Y=-67840
X46974 5 4 7748 1370 7741 NA2_5VX1 $T=450920 -26880 1 180 $X=447690 $Y=-27520
X46975 5 4 5864 1371 7745 NA2_5VX1 $T=453160 -259840 1 180 $X=449930 $Y=-260480
X46976 5 4 5851 5825 1521 NA2_5VX1 $T=456520 -53760 0 180 $X=453290 $Y=-58880
X46977 5 4 1521 1386 7770 NA2_5VX1 $T=459320 -53760 1 0 $X=458890 $Y=-58880
X46978 5 4 7779 5938 7768 NA2_5VX1 $T=467160 -98560 1 0 $X=466730 $Y=-103680
X46979 5 4 1402 1524 5956 NA2_5VX1 $T=478360 -250880 0 0 $X=477930 $Y=-251520
X46980 5 4 7797 5981 5934 NA2_5VX1 $T=478360 -197120 1 0 $X=477930 $Y=-202240
X46981 5 4 7799 7986 5997 NA2_5VX1 $T=480040 -44800 0 0 $X=479610 $Y=-45440
X46982 5 4 2404 2443 2315 2343 AO21_5VX1 $T=-306760 -241920 0 180 $X=-312230 $Y=-247040
X46983 5 4 6745 3126 6753 6756 AO21_5VX1 $T=-152760 -125440 1 0 $X=-153190 $Y=-130560
X46984 5 4 1522 5952 7778 5926 AO21_5VX1 $T=470520 -71680 0 180 $X=465050 $Y=-76800
X46985 5 4 49 54 6304 OR2_5VX1 $T=-443400 -8960 0 0 $X=-443830 $Y=-9600
X46986 5 4 59 58 1843 OR2_5VX1 $T=-440600 -62720 1 0 $X=-441030 $Y=-67840
X46987 5 4 58 1841 1823 OR2_5VX1 $T=-435560 -89600 0 180 $X=-439910 $Y=-94720
X46988 5 4 1452 1447 6320 OR2_5VX1 $T=-424360 -179200 1 180 $X=-428710 $Y=-179840
X46989 5 4 48 59 1818 OR2_5VX1 $T=-421560 -44800 0 180 $X=-425910 $Y=-49920
X46990 5 4 79 84 6342 OR2_5VX1 $T=-414840 -224000 0 180 $X=-419190 $Y=-229120
X46991 5 4 1447 80 6343 OR2_5VX1 $T=-413160 -188160 0 180 $X=-417510 $Y=-193280
X46992 5 4 84 89 6349 OR2_5VX1 $T=-416520 -241920 0 0 $X=-416950 $Y=-242560
X46993 5 4 80 79 1919 OR2_5VX1 $T=-412040 -215040 1 180 $X=-416390 $Y=-215680
X46994 5 4 1462 1452 1876 OR2_5VX1 $T=-400840 -134400 0 180 $X=-405190 $Y=-139520
X46995 5 4 79 89 2024 OR2_5VX1 $T=-391320 -143360 0 180 $X=-395670 $Y=-148480
X46996 5 4 3131 3149 6753 OR2_5VX1 $T=-153320 -134400 1 0 $X=-153750 $Y=-139520
X46997 5 4 609 614 3499 OR2_5VX1 $T=-56440 -62720 1 180 $X=-60790 $Y=-63360
X46998 5 4 3832 7017 3804 OR2_5VX1 $T=5160 -80640 0 180 $X=810 $Y=-85760
X46999 5 4 1496 1489 7099 OR2_5VX1 $T=55000 -62720 0 180 $X=50650 $Y=-67840
X47000 5 4 3504 1496 7108 OR2_5VX1 $T=55560 -53760 0 180 $X=51210 $Y=-58880
X47001 5 4 1489 584 4086 OR2_5VX1 $T=61160 -107520 0 180 $X=56810 $Y=-112640
X47002 5 4 584 624 7121 OR2_5VX1 $T=60040 -125440 1 0 $X=59610 $Y=-130560
X47003 5 4 592 632 7147 OR2_5VX1 $T=76280 -224000 1 0 $X=75850 $Y=-229120
X47004 5 4 595 592 7152 OR2_5VX1 $T=79640 -206080 0 0 $X=79210 $Y=-206720
X47005 5 4 624 881 7148 OR2_5VX1 $T=85240 -161280 1 180 $X=80890 $Y=-161920
X47006 5 4 881 595 7157 OR2_5VX1 $T=83560 -179200 1 0 $X=83130 $Y=-184320
X47007 5 4 1506 1523 5268 OR2_5VX1 $T=318200 -35840 0 180 $X=313850 $Y=-40960
X47008 5 4 5775 1516 7981 OR2_5VX1 $T=438600 -53760 1 0 $X=438170 $Y=-58880
X47009 5 4 1119 1180 7746 OR2_5VX1 $T=445320 -241920 1 0 $X=444890 $Y=-247040
X47010 5 4 4762 1123 7737 OR2_5VX1 $T=457080 -134400 1 180 $X=452730 $Y=-135040
X47011 5 4 7770 1521 7769 OR2_5VX1 $T=458200 -62720 0 0 $X=457770 $Y=-63360
X47012 5 4 4762 1109 7777 OR2_5VX1 $T=462120 -161280 0 0 $X=461690 $Y=-161920
X47013 5 4 1117 1119 7780 OR2_5VX1 $T=469960 -224000 0 180 $X=465610 $Y=-229120
X47014 5 4 1195 1398 1394 OR2_5VX1 $T=466600 -268800 1 0 $X=466170 $Y=-273920
X47015 5 4 1515 4754 5914 OR2_5VX1 $T=476680 -116480 1 180 $X=472330 $Y=-117120
X47016 5 4 5934 7797 5992 OR2_5VX1 $T=476680 -206080 0 0 $X=476250 $Y=-206720
X47017 5 4 1506 1523 7809 OR2_5VX1 $T=477800 -62720 0 0 $X=477370 $Y=-63360
X47018 5 4 4754 4762 7812 OR2_5VX1 $T=481160 -143360 1 0 $X=480730 $Y=-148480
X47019 5 4 1165 1168 6029 OR2_5VX1 $T=491800 0 0 0 $X=491370 $Y=-640
X47020 5 4 48 1806 47 NO2_5VX1 $T=-437240 -44800 1 180 $X=-440470 $Y=-45440
X47021 5 4 54 6315 51 NO2_5VX1 $T=-427160 -44800 0 180 $X=-430390 $Y=-49920
X47022 5 4 51 1932 55 NO2_5VX1 $T=-429960 0 1 0 $X=-430390 $Y=-5120
X47023 5 4 1841 1881 59 NO2_5VX1 $T=-423800 -71680 1 180 $X=-427030 $Y=-72320
X47024 5 4 1951 6333 1914 NO2_5VX1 $T=-419880 -107520 1 180 $X=-423110 $Y=-108160
X47025 5 4 49 1926 45 NO2_5VX1 $T=-422120 -17920 0 0 $X=-422550 $Y=-18560
X47026 5 4 1452 1943 1900 NO2_5VX1 $T=-421000 -134400 0 0 $X=-421430 $Y=-135040
X47027 5 4 6332 86 1932 NO2_5VX1 $T=-421000 8960 1 0 $X=-421430 $Y=3840
X47028 5 4 59 1908 47 NO2_5VX1 $T=-417080 -44800 1 180 $X=-420310 $Y=-45440
X47029 5 4 1462 1895 1900 NO2_5VX1 $T=-415960 -125440 0 180 $X=-419190 $Y=-130560
X47030 5 4 1447 1880 1462 NO2_5VX1 $T=-413720 -125440 1 180 $X=-416950 $Y=-126080
X47031 5 4 58 1917 48 NO2_5VX1 $T=-411480 -44800 1 180 $X=-414710 $Y=-45440
X47032 5 4 6361 1938 2003 NO2_5VX1 $T=-409240 -26880 1 180 $X=-412470 $Y=-27520
X47033 5 4 80 1941 1452 NO2_5VX1 $T=-404760 -125440 0 180 $X=-407990 $Y=-130560
X47034 5 4 47 6361 49 NO2_5VX1 $T=-404200 -44800 1 180 $X=-407430 $Y=-45440
X47035 5 4 45 1448 90 NO2_5VX1 $T=-401960 8960 0 180 $X=-405190 $Y=3840
X47036 5 4 84 2011 80 NO2_5VX1 $T=-400840 -161280 0 0 $X=-401270 $Y=-161920
X47037 5 4 79 1979 1447 NO2_5VX1 $T=-395240 -125440 0 180 $X=-398470 $Y=-130560
X47038 5 4 2047 6400 1451 NO2_5VX1 $T=-394680 -170240 1 0 $X=-395110 $Y=-175360
X47039 5 4 141 2404 100 NO2_5VX1 $T=-302840 -259840 1 0 $X=-303270 $Y=-264960
X47040 5 4 58 2408 59 NO2_5VX1 $T=-301160 -44800 0 0 $X=-301590 $Y=-45440
X47041 5 4 59 2431 48 NO2_5VX1 $T=-298920 -53760 1 0 $X=-299350 $Y=-58880
X47042 5 4 137 6523 100 NO2_5VX1 $T=-298360 -188160 1 0 $X=-298790 $Y=-193280
X47043 5 4 92 2504 89 NO2_5VX1 $T=-291640 -197120 1 0 $X=-292070 $Y=-202240
X47044 5 4 2447 6539 6532 NO2_5VX1 $T=-289400 -71680 1 0 $X=-289830 $Y=-76800
X47045 5 4 2475 6538 2447 NO2_5VX1 $T=-288840 -80640 1 0 $X=-289270 $Y=-85760
X47046 5 4 48 2466 47 NO2_5VX1 $T=-286040 -35840 1 180 $X=-289270 $Y=-36480
X47047 5 4 2483 2472 2503 NO2_5VX1 $T=-285480 -44800 1 180 $X=-288710 $Y=-45440
X47048 5 4 1900 2489 1841 NO2_5VX1 $T=-287720 -107520 0 0 $X=-288150 $Y=-108160
X47049 5 4 79 2509 80 NO2_5VX1 $T=-287160 -143360 0 0 $X=-287590 $Y=-144000
X47050 5 4 2427 2526 2456 NO2_5VX1 $T=-286600 -125440 1 0 $X=-287030 $Y=-130560
X47051 5 4 2503 2479 221 NO2_5VX1 $T=-285480 -26880 1 0 $X=-285910 $Y=-32000
X47052 5 4 1841 2486 58 NO2_5VX1 $T=-282120 -80640 1 180 $X=-285350 $Y=-81280
X47053 5 4 2479 6543 2466 NO2_5VX1 $T=-281560 -35840 1 180 $X=-284790 $Y=-36480
X47054 5 4 1452 2512 1462 NO2_5VX1 $T=-283800 -62720 0 0 $X=-284230 $Y=-63360
X47055 5 4 2456 2556 2477 NO2_5VX1 $T=-282120 -116480 0 0 $X=-282550 $Y=-117120
X47056 5 4 2477 2566 2475 NO2_5VX1 $T=-279880 -98560 0 0 $X=-280310 $Y=-99200
X47057 5 4 84 2523 79 NO2_5VX1 $T=-275960 -197120 0 180 $X=-279190 $Y=-202240
X47058 5 4 1447 2531 1452 NO2_5VX1 $T=-277640 -80640 1 0 $X=-278070 $Y=-85760
X47059 5 4 80 2561 1447 NO2_5VX1 $T=-276520 -134400 0 0 $X=-276950 $Y=-135040
X47060 5 4 1900 242 1841 NO2_5VX1 $T=-273720 -35840 0 0 $X=-274150 $Y=-36480
X47061 5 4 1841 235 58 NO2_5VX1 $T=-273720 -17920 1 0 $X=-274150 $Y=-23040
X47062 5 4 1452 2533 1462 NO2_5VX1 $T=-269800 -134400 1 180 $X=-273030 $Y=-135040
X47063 5 4 59 249 48 NO2_5VX1 $T=-264200 8960 1 180 $X=-267430 $Y=8320
X47064 5 4 1462 2642 1900 NO2_5VX1 $T=-260280 -44800 0 180 $X=-263510 $Y=-49920
X47065 5 4 54 2620 51 NO2_5VX1 $T=-260280 8960 0 180 $X=-263510 $Y=3840
X47066 5 4 2661 2665 6602 NO2_5VX1 $T=-249640 -215040 0 180 $X=-252870 $Y=-220160
X47067 5 4 2691 2661 2678 NO2_5VX1 $T=-247960 -206080 0 180 $X=-251190 $Y=-211200
X47068 5 4 92 6602 79 NO2_5VX1 $T=-245160 -215040 0 180 $X=-248390 $Y=-220160
X47069 5 4 138 2836 139 NO2_5VX1 $T=-221080 -259840 1 0 $X=-221510 $Y=-264960
X47070 5 4 2818 6662 1468 NO2_5VX1 $T=-217720 -188160 0 0 $X=-218150 $Y=-188800
X47071 5 4 1462 2878 1900 NO2_5VX1 $T=-210440 -35840 1 180 $X=-213670 $Y=-36480
X47072 5 4 2838 2880 1471 NO2_5VX1 $T=-211560 -170240 1 0 $X=-211990 $Y=-175360
X47073 5 4 1841 1472 59 NO2_5VX1 $T=-210440 -71680 0 0 $X=-210870 $Y=-72320
X47074 5 4 354 2903 353 NO2_5VX1 $T=-206520 8960 0 0 $X=-206950 $Y=8320
X47075 5 4 436 6741 6750 NO2_5VX1 $T=-157240 -259840 0 0 $X=-157670 $Y=-260480
X47076 5 4 8107 3213 6769 NO2_5VX1 $T=-134280 -116480 1 180 $X=-137510 $Y=-117120
X47077 5 4 6777 3238 6775 NO2_5VX1 $T=-134840 -17920 1 0 $X=-135270 $Y=-23040
X47078 5 4 3269 3258 1477 NO2_5VX1 $T=-122520 -107520 1 180 $X=-125750 $Y=-108160
X47079 5 4 1496 3572 625 NO2_5VX1 $T=-49720 -188160 0 180 $X=-52950 $Y=-193280
X47080 5 4 620 3541 614 NO2_5VX1 $T=-49160 -80640 1 180 $X=-52390 $Y=-81280
X47081 5 4 607 1483 620 NO2_5VX1 $T=-39640 -98560 0 180 $X=-42870 $Y=-103680
X47082 5 4 3385 3656 625 NO2_5VX1 $T=-27320 -35840 0 180 $X=-30550 $Y=-40960
X47083 5 4 595 1487 586 NO2_5VX1 $T=-22280 -152320 0 180 $X=-25510 $Y=-157440
X47084 5 4 592 3624 595 NO2_5VX1 $T=-20600 -170240 0 180 $X=-23830 $Y=-175360
X47085 5 4 679 3714 637 NO2_5VX1 $T=-22840 -241920 0 0 $X=-23270 $Y=-242560
X47086 5 4 670 684 679 NO2_5VX1 $T=-18920 -250880 1 180 $X=-22150 $Y=-251520
X47087 5 4 677 3800 632 NO2_5VX1 $T=-17240 -206080 0 180 $X=-20470 $Y=-211200
X47088 5 4 637 3717 677 NO2_5VX1 $T=-16120 -224000 1 180 $X=-19350 $Y=-224640
X47089 5 4 632 3711 592 NO2_5VX1 $T=-15560 -197120 1 180 $X=-18790 $Y=-197760
X47090 5 4 637 3724 677 NO2_5VX1 $T=-8280 -215040 0 180 $X=-11510 $Y=-220160
X47091 5 4 586 3782 624 NO2_5VX1 $T=-2120 -143360 0 180 $X=-5350 $Y=-148480
X47092 5 4 624 3783 584 NO2_5VX1 $T=6840 -134400 1 180 $X=3610 $Y=-135040
X47093 5 4 584 1490 1489 NO2_5VX1 $T=6840 -107520 0 180 $X=3610 $Y=-112640
X47094 5 4 611 7024 620 NO2_5VX1 $T=11320 -17920 0 180 $X=8090 $Y=-23040
X47095 5 4 1489 3742 1496 NO2_5VX1 $T=13000 -89600 1 180 $X=9770 $Y=-90240
X47096 5 4 625 3867 607 NO2_5VX1 $T=10200 -53760 1 0 $X=9770 $Y=-58880
X47097 5 4 3504 3805 625 NO2_5VX1 $T=13560 -53760 1 180 $X=10330 $Y=-54400
X47098 5 4 1496 768 625 NO2_5VX1 $T=13560 -44800 1 0 $X=13130 $Y=-49920
X47099 5 4 595 3935 624 NO2_5VX1 $T=29240 -152320 0 180 $X=26010 $Y=-157440
X47100 5 4 592 3934 586 NO2_5VX1 $T=31480 -170240 0 180 $X=28250 $Y=-175360
X47101 5 4 1489 1493 3504 NO2_5VX1 $T=35400 -62720 1 180 $X=32170 $Y=-63360
X47102 5 4 632 3961 595 NO2_5VX1 $T=44920 -197120 1 180 $X=41690 $Y=-197760
X47103 5 4 3504 4032 625 NO2_5VX1 $T=44920 -17920 1 180 $X=41690 $Y=-18560
X47104 5 4 584 3886 1496 NO2_5VX1 $T=45480 -71680 1 180 $X=42250 $Y=-72320
X47105 5 4 670 4006 637 NO2_5VX1 $T=47160 -250880 0 180 $X=43930 $Y=-256000
X47106 5 4 624 4023 1489 NO2_5VX1 $T=58360 -125440 0 180 $X=55130 $Y=-130560
X47107 5 4 679 4095 677 NO2_5VX1 $T=60040 -232960 1 180 $X=56810 $Y=-233600
X47108 5 4 637 4140 677 NO2_5VX1 $T=63400 -259840 1 0 $X=62970 $Y=-264960
X47109 5 4 4232 7155 4228 NO2_5VX1 $T=83000 -152320 0 0 $X=82570 $Y=-152960
X47110 5 4 4236 4257 7162 NO2_5VX1 $T=88600 -107520 1 0 $X=88170 $Y=-112640
X47111 5 4 3504 4320 625 NO2_5VX1 $T=89720 -134400 0 0 $X=89290 $Y=-135040
X47112 5 4 584 4268 1489 NO2_5VX1 $T=90280 -179200 1 0 $X=89850 $Y=-184320
X47113 5 4 1489 7165 1496 NO2_5VX1 $T=94200 -161280 0 180 $X=90970 $Y=-166400
X47114 5 4 4237 7166 4236 NO2_5VX1 $T=92520 -116480 1 0 $X=92090 $Y=-121600
X47115 5 4 4241 4270 4273 NO2_5VX1 $T=95320 -53760 1 0 $X=94890 $Y=-58880
X47116 5 4 4261 7172 4232 NO2_5VX1 $T=96440 -161280 1 0 $X=96010 $Y=-166400
X47117 5 4 4228 4321 4237 NO2_5VX1 $T=98120 -116480 1 0 $X=97690 $Y=-121600
X47118 5 4 620 7173 623 NO2_5VX1 $T=100920 -89600 0 180 $X=97690 $Y=-94720
X47119 5 4 607 4309 611 NO2_5VX1 $T=99240 -53760 1 0 $X=98810 $Y=-58880
X47120 5 4 4290 4319 4261 NO2_5VX1 $T=99800 -179200 1 0 $X=99370 $Y=-184320
X47121 5 4 1496 4296 3504 NO2_5VX1 $T=103720 -134400 1 180 $X=100490 $Y=-135040
X47122 5 4 4243 4335 4290 NO2_5VX1 $T=103720 -206080 0 0 $X=103290 $Y=-206720
X47123 5 4 625 7186 607 NO2_5VX1 $T=104280 -134400 0 0 $X=103850 $Y=-135040
X47124 5 4 611 4250 620 NO2_5VX1 $T=107080 -80640 1 180 $X=103850 $Y=-81280
X47125 5 4 614 1497 604 NO2_5VX1 $T=109320 -44800 1 0 $X=108890 $Y=-49920
X47126 5 4 7962 4357 936 NO2_5VX1 $T=109880 -26880 0 0 $X=109450 $Y=-27520
X47127 5 4 4218 941 4305 NO2_5VX1 $T=110440 -232960 0 0 $X=110010 $Y=-233600
X47128 5 4 624 7191 584 NO2_5VX1 $T=110440 -197120 0 0 $X=110010 $Y=-197760
X47129 5 4 908 942 4218 NO2_5VX1 $T=114920 -268800 1 180 $X=111690 $Y=-269440
X47130 5 4 4305 4372 4243 NO2_5VX1 $T=118280 -215040 0 180 $X=115050 $Y=-220160
X47131 5 4 595 4403 586 NO2_5VX1 $T=118840 -250880 1 0 $X=118410 $Y=-256000
X47132 5 4 586 4418 624 NO2_5VX1 $T=119400 -241920 0 0 $X=118970 $Y=-242560
X47133 5 4 4762 4897 4754 NO2_5VX1 $T=225800 -224000 1 0 $X=225370 $Y=-229120
X47134 5 4 1506 7347 4769 NO2_5VX1 $T=231400 -170240 0 0 $X=230970 $Y=-170880
X47135 5 4 1117 1158 1133 NO2_5VX1 $T=235320 -268800 1 0 $X=234890 $Y=-273920
X47136 5 4 1109 4936 4762 NO2_5VX1 $T=242600 -232960 1 180 $X=239370 $Y=-233600
X47137 5 4 1123 4939 1109 NO2_5VX1 $T=243160 -250880 0 180 $X=239930 $Y=-256000
X47138 5 4 4948 7358 4960 NO2_5VX1 $T=241480 -241920 0 0 $X=241050 $Y=-242560
X47139 5 4 4960 4900 4953 NO2_5VX1 $T=243160 -224000 0 0 $X=242730 $Y=-224640
X47140 5 4 1154 4943 1161 NO2_5VX1 $T=243160 -71680 0 0 $X=242730 $Y=-72320
X47141 5 4 1133 1502 1123 NO2_5VX1 $T=248760 -259840 0 180 $X=245530 $Y=-264960
X47142 5 4 1171 7360 4948 NO2_5VX1 $T=248760 -250880 0 180 $X=245530 $Y=-256000
X47143 5 4 4953 4931 4966 NO2_5VX1 $T=250440 -215040 1 180 $X=247210 $Y=-215680
X47144 5 4 4956 1503 4984 NO2_5VX1 $T=250440 -71680 0 180 $X=247210 $Y=-76800
X47145 5 4 4966 4986 4987 NO2_5VX1 $T=248200 -206080 1 0 $X=247770 $Y=-211200
X47146 5 4 5000 4968 4956 NO2_5VX1 $T=252120 -62720 0 180 $X=248890 $Y=-67840
X47147 5 4 1170 4974 1157 NO2_5VX1 $T=253240 -80640 0 180 $X=250010 $Y=-85760
X47148 5 4 1189 1177 1171 NO2_5VX1 $T=253800 -268800 1 180 $X=250570 $Y=-269440
X47149 5 4 1173 5014 1157 NO2_5VX1 $T=255480 -80640 1 180 $X=252250 $Y=-81280
X47150 5 4 4754 5029 1515 NO2_5VX1 $T=253240 -206080 1 0 $X=252810 $Y=-211200
X47151 5 4 1165 5004 1159 NO2_5VX1 $T=257720 -125440 1 180 $X=254490 $Y=-126080
X47152 5 4 5020 4988 5000 NO2_5VX1 $T=257720 -89600 0 180 $X=254490 $Y=-94720
X47153 5 4 5039 7383 5020 NO2_5VX1 $T=257720 -107520 1 0 $X=257290 $Y=-112640
X47154 5 4 1159 4998 1170 NO2_5VX1 $T=260520 -80640 1 180 $X=257290 $Y=-81280
X47155 5 4 4987 5017 5011 NO2_5VX1 $T=261640 -188160 1 180 $X=258410 $Y=-188800
X47156 5 4 5028 4938 5008 NO2_5VX1 $T=262200 -152320 0 180 $X=258970 $Y=-157440
X47157 5 4 1154 7386 1162 NO2_5VX1 $T=259400 -8960 1 0 $X=258970 $Y=-14080
X47158 5 4 1515 7970 1504 NO2_5VX1 $T=263880 -206080 1 180 $X=260650 $Y=-206720
X47159 5 4 1186 7385 1191 NO2_5VX1 $T=261080 8960 0 0 $X=260650 $Y=8320
X47160 5 4 1168 5021 1165 NO2_5VX1 $T=264440 -134400 1 180 $X=261210 $Y=-135040
X47161 5 4 1170 7451 5204 NO2_5VX1 $T=293000 -62720 0 0 $X=292570 $Y=-63360
X47162 5 4 1173 5230 5246 NO2_5VX1 $T=305320 -35840 0 180 $X=302090 $Y=-40960
X47163 5 4 1157 1505 5242 NO2_5VX1 $T=311480 -53760 0 180 $X=308250 $Y=-58880
X47164 5 4 1117 7974 1133 NO2_5VX1 $T=310920 -170240 1 0 $X=310490 $Y=-175360
X47165 5 4 1109 5315 4754 NO2_5VX1 $T=319320 -206080 0 0 $X=318890 $Y=-206720
X47166 5 4 7482 5318 5298 NO2_5VX1 $T=319880 -143360 0 0 $X=319450 $Y=-144000
X47167 5 4 1123 5330 4762 NO2_5VX1 $T=320440 -241920 0 0 $X=320010 $Y=-242560
X47168 5 4 1506 5319 4769 NO2_5VX1 $T=327160 -26880 1 180 $X=323930 $Y=-27520
X47169 5 4 1157 7512 1161 NO2_5VX1 $T=324920 -53760 0 0 $X=324490 $Y=-54400
X47170 5 4 1515 7496 1504 NO2_5VX1 $T=328840 -89600 1 180 $X=325610 $Y=-90240
X47171 5 4 1523 1510 4769 NO2_5VX1 $T=331640 -107520 1 180 $X=328410 $Y=-108160
X47172 5 4 1170 5359 1173 NO2_5VX1 $T=336120 -80640 1 180 $X=332890 $Y=-81280
X47173 5 4 1168 1508 1159 NO2_5VX1 $T=337240 -62720 0 180 $X=334010 $Y=-67840
X47174 5 4 1168 1344 1165 NO2_5VX1 $T=424600 0 1 0 $X=424170 $Y=-5120
X47175 5 4 1165 1345 1159 NO2_5VX1 $T=425160 8960 1 0 $X=424730 $Y=3840
X47176 5 4 1504 5743 1523 NO2_5VX1 $T=426840 -89600 0 0 $X=426410 $Y=-90240
X47177 5 4 1119 5762 1117 NO2_5VX1 $T=430760 -197120 1 0 $X=430330 $Y=-202240
X47178 5 4 1515 5763 1504 NO2_5VX1 $T=430760 -98560 0 0 $X=430330 $Y=-99200
X47179 5 4 4754 5768 1515 NO2_5VX1 $T=435240 -107520 0 180 $X=432010 $Y=-112640
X47180 5 4 4769 1356 1168 NO2_5VX1 $T=434120 -26880 0 0 $X=433690 $Y=-27520
X47181 5 4 4762 5779 4754 NO2_5VX1 $T=439160 -134400 1 180 $X=435930 $Y=-135040
X47182 5 4 1192 5800 1180 NO2_5VX1 $T=439160 -232960 1 0 $X=438730 $Y=-238080
X47183 5 4 1506 5794 4769 NO2_5VX1 $T=439160 -26880 0 0 $X=438730 $Y=-27520
X47184 5 4 1133 5804 1123 NO2_5VX1 $T=441960 -179200 1 0 $X=441530 $Y=-184320
X47185 5 4 1117 5765 1133 NO2_5VX1 $T=445320 -188160 1 180 $X=442090 $Y=-188800
X47186 5 4 1180 5786 1119 NO2_5VX1 $T=446440 -232960 1 180 $X=443210 $Y=-233600
X47187 5 4 1123 5812 1109 NO2_5VX1 $T=448120 -152320 1 180 $X=444890 $Y=-152960
X47188 5 4 7745 7733 5831 NO2_5VX1 $T=450360 -250880 0 180 $X=447130 $Y=-256000
X47189 5 4 1109 5881 4754 NO2_5VX1 $T=455960 -143360 1 0 $X=455530 $Y=-148480
X47190 5 4 1195 1372 1210 NO2_5VX1 $T=459320 -250880 0 180 $X=456090 $Y=-256000
X47191 5 4 4754 5875 1504 NO2_5VX1 $T=459320 -107520 0 180 $X=456090 $Y=-112640
X47192 5 4 1515 7768 1504 NO2_5VX1 $T=457640 -98560 1 0 $X=457210 $Y=-103680
X47193 5 4 1391 5859 1195 NO2_5VX1 $T=464920 -268800 0 180 $X=461690 $Y=-273920
X47194 5 4 4762 5858 1515 NO2_5VX1 $T=466040 -125440 0 180 $X=462810 $Y=-130560
X47195 5 4 1504 5929 1506 NO2_5VX1 $T=463800 -89600 0 0 $X=463370 $Y=-90240
X47196 5 4 1387 7764 1195 NO2_5VX1 $T=467720 -232960 0 180 $X=464490 $Y=-238080
X47197 5 4 1117 7781 1133 NO2_5VX1 $T=471640 -197120 0 180 $X=468410 $Y=-202240
X47198 5 4 1515 5946 1523 NO2_5VX1 $T=468840 -89600 0 0 $X=468410 $Y=-90240
X47199 5 4 1210 5999 1180 NO2_5VX1 $T=472200 -241920 1 0 $X=471770 $Y=-247040
X47200 5 4 1180 7796 1117 NO2_5VX1 $T=472200 -215040 0 0 $X=471770 $Y=-215680
X47201 5 4 1523 1522 4769 NO2_5VX1 $T=477240 -71680 0 180 $X=474010 $Y=-76800
X47202 5 4 1117 5953 1123 NO2_5VX1 $T=480040 -188160 1 180 $X=476810 $Y=-188800
X47203 5 4 6002 7798 5950 NO2_5VX1 $T=480040 -170240 1 180 $X=476810 $Y=-170880
X47204 5 4 1506 5997 4769 NO2_5VX1 $T=477800 -44800 1 0 $X=477370 $Y=-49920
X47205 5 4 1229 1404 1387 NO2_5VX1 $T=483960 -268800 1 0 $X=483530 $Y=-273920
X47206 5 4 1192 6024 1119 NO2_5VX1 $T=504680 -224000 0 180 $X=501450 $Y=-229120
X47207 5 4 48 1870 1909 NA2I1_5VX1 $T=-435560 -26880 0 0 $X=-435990 $Y=-27520
X47208 5 4 92 1973 6356 NA2I1_5VX1 $T=-413720 -259840 0 0 $X=-414150 $Y=-260480
X47209 5 4 58 1983 6364 NA2I1_5VX1 $T=-411480 -80640 0 0 $X=-411910 $Y=-81280
X47210 5 4 141 2304 6500 NA2I1_5VX1 $T=-316280 -224000 0 0 $X=-316710 $Y=-224640
X47211 5 4 1462 2883 6655 NA2I1_5VX1 $T=-213240 -35840 1 180 $X=-217590 $Y=-36480
X47212 5 4 1900 2878 352 NA2I1_5VX1 $T=-212120 -17920 1 0 $X=-212550 $Y=-23040
X47213 5 4 3198 3210 3218 NA2I1_5VX1 $T=-139880 -170240 0 0 $X=-140310 $Y=-170880
X47214 5 4 3265 1476 6781 NA2I1_5VX1 $T=-127000 -224000 0 180 $X=-131350 $Y=-229120
X47215 5 4 6794 3284 6787 NA2I1_5VX1 $T=-124200 -206080 1 180 $X=-128550 $Y=-206720
X47216 5 4 3285 3282 6798 NA2I1_5VX1 $T=-121960 -188160 1 180 $X=-126310 $Y=-188800
X47217 5 4 3268 3242 6795 NA2I1_5VX1 $T=-120840 -134400 0 180 $X=-125190 $Y=-139520
X47218 5 4 3376 6827 6832 NA2I1_5VX1 $T=-97880 -26880 1 0 $X=-98310 $Y=-32000
X47219 5 4 3385 3585 6915 NA2I1_5VX1 $T=-46360 -26880 1 180 $X=-50710 $Y=-27520
X47220 5 4 625 3656 3659 NA2I1_5VX1 $T=-35720 -17920 1 0 $X=-36150 $Y=-23040
X47221 5 4 611 3833 720 NA2I1_5VX1 $T=6280 -35840 1 180 $X=1930 $Y=-36480
X47222 5 4 3504 761 754 NA2I1_5VX1 $T=23640 -26880 1 180 $X=19290 $Y=-27520
X47223 5 4 625 4032 7076 NA2I1_5VX1 $T=42120 -17920 1 180 $X=37770 $Y=-18560
X47224 5 4 4036 670 4003 NA2I1_5VX1 $T=42680 -250880 0 180 $X=38330 $Y=-256000
X47225 5 4 683 822 818 NA2I1_5VX1 $T=51640 -268800 1 0 $X=51210 $Y=-273920
X47226 5 4 7451 5237 7439 NA2I1_5VX1 $T=298600 -53760 0 180 $X=294250 $Y=-58880
X47227 5 4 1117 7463 5264 NA2I1_5VX1 $T=303640 -188160 0 0 $X=303210 $Y=-188800
X47228 5 4 1515 5270 7467 NA2I1_5VX1 $T=310920 -89600 0 180 $X=306570 $Y=-94720
X47229 5 4 1109 5298 7484 NA2I1_5VX1 $T=321000 -125440 0 180 $X=316650 $Y=-130560
X47230 5 4 4769 5319 5323 NA2I1_5VX1 $T=319320 -17920 1 0 $X=318890 $Y=-23040
X47231 5 4 1504 7496 5308 NA2I1_5VX1 $T=327720 -80640 0 180 $X=323370 $Y=-85760
X47232 5 4 1170 7741 1383 NA2I1_5VX1 $T=456520 -26880 0 0 $X=456090 $Y=-27520
X47233 5 4 1123 5915 7784 NA2I1_5VX1 $T=465480 -188160 0 0 $X=465050 $Y=-188800
X47234 5 4 1195 5988 5960 NA2I1_5VX1 $T=482840 -224000 0 180 $X=478490 $Y=-229120
X47235 5 4 6396 2021 1977 2024 ON21_5VX1 $T=-395800 -152320 0 180 $X=-400150 $Y=-157440
X47236 5 4 2611 2566 2587 2589 ON21_5VX1 $T=-265320 -143360 1 180 $X=-269670 $Y=-144000
X47237 5 4 2653 2526 2641 2492 ON21_5VX1 $T=-256360 -143360 0 180 $X=-260710 $Y=-148480
X47238 5 4 343 6662 2864 2827 ON21_5VX1 $T=-215480 -215040 1 0 $X=-215910 $Y=-220160
X47239 5 4 2867 2880 2879 6668 ON21_5VX1 $T=-213240 -188160 0 0 $X=-213670 $Y=-188800
X47240 5 4 3551 3505 3444 3499 ON21_5VX1 $T=-63160 -71680 1 180 $X=-67510 $Y=-72320
X47241 5 4 3546 3537 3454 6902 ON21_5VX1 $T=-58120 -26880 1 180 $X=-62470 $Y=-27520
X47242 5 4 3536 635 3438 627 ON21_5VX1 $T=-51960 -17920 1 180 $X=-56310 $Y=-18560
X47243 5 4 3570 3554 1482 6909 ON21_5VX1 $T=-51400 -179200 0 180 $X=-55750 $Y=-184320
X47244 5 4 1907 1906 6337 1917 NO22_5VX1 $T=-427720 -89600 0 0 $X=-428150 $Y=-90240
X47245 5 4 6333 1890 1911 1881 NO22_5VX1 $T=-422120 -107520 0 180 $X=-427590 $Y=-112640
X47246 5 4 1971 1887 1837 1926 NO22_5VX1 $T=-426040 -17920 1 0 $X=-426470 $Y=-23040
X47247 5 4 6332 1809 1923 1932 NO22_5VX1 $T=-425480 0 1 0 $X=-425910 $Y=-5120
X47248 5 4 1937 1930 1896 1908 NO22_5VX1 $T=-418760 -71680 1 180 $X=-424230 $Y=-72320
X47249 5 4 6332 1870 83 1932 NO22_5VX1 $T=-422680 0 0 0 $X=-423110 $Y=-640
X47250 5 4 87 1931 1863 77 NO22_5VX1 $T=-416520 8960 1 180 $X=-421990 $Y=8320
X47251 5 4 1920 1955 6341 1943 NO22_5VX1 $T=-414280 -143360 0 180 $X=-419750 $Y=-148480
X47252 5 4 7996 1972 1845 1448 NO22_5VX1 $T=-411480 8960 0 180 $X=-416950 $Y=3840
X47253 5 4 1964 1946 1940 1880 NO22_5VX1 $T=-409800 -170240 1 180 $X=-415270 $Y=-170880
X47254 5 4 1971 54 95 1926 NO22_5VX1 $T=-412040 -17920 0 0 $X=-412470 $Y=-18560
X47255 5 4 6360 1986 1991 1941 NO22_5VX1 $T=-410360 -179200 1 0 $X=-410790 $Y=-184320
X47256 5 4 2003 1968 1897 6361 NO22_5VX1 $T=-404200 -44800 0 180 $X=-409670 $Y=-49920
X47257 5 4 2002 2035 1999 1979 NO22_5VX1 $T=-395800 -197120 1 180 $X=-401270 $Y=-197760
X47258 5 4 6400 2071 2057 2011 NO22_5VX1 $T=-388520 -197120 1 180 $X=-393990 $Y=-197760
X47259 5 4 47 6517 2416 2408 NO22_5VX1 $T=-307320 -35840 0 0 $X=-307750 $Y=-36480
X47260 5 4 6517 2409 2392 2408 NO22_5VX1 $T=-301720 -53760 0 180 $X=-307190 $Y=-58880
X47261 5 4 212 2410 1460 203 NO22_5VX1 $T=-300600 -8960 1 180 $X=-306070 $Y=-9600
X47262 5 4 6517 1900 6522 2408 NO22_5VX1 $T=-301720 -35840 0 0 $X=-302150 $Y=-36480
X47263 5 4 209 217 215 2404 NO22_5VX1 $T=-295560 -268800 0 180 $X=-301030 $Y=-273920
X47264 5 4 2472 2440 2370 2431 NO22_5VX1 $T=-294440 -71680 0 180 $X=-299910 $Y=-76800
X47265 5 4 2479 2436 2332 2466 NO22_5VX1 $T=-293880 -62720 0 180 $X=-299350 $Y=-67840
X47266 5 4 2472 1841 216 2431 NO22_5VX1 $T=-292200 -44800 0 180 $X=-297670 $Y=-49920
X47267 5 4 2479 6532 2461 2466 NO22_5VX1 $T=-289400 -62720 1 180 $X=-294870 $Y=-63360
X47268 5 4 2468 219 223 2504 NO22_5VX1 $T=-292760 -259840 0 0 $X=-293190 $Y=-260480
X47269 5 4 6539 2519 2391 2486 NO22_5VX1 $T=-285480 -98560 0 180 $X=-290950 $Y=-103680
X47270 5 4 6539 1462 2445 2486 NO22_5VX1 $T=-285480 -80640 1 180 $X=-290950 $Y=-81280
X47271 5 4 2468 6536 2448 2504 NO22_5VX1 $T=-289400 -241920 1 0 $X=-289830 $Y=-247040
X47272 5 4 6534 2495 2505 2509 NO22_5VX1 $T=-289400 -206080 1 0 $X=-289830 $Y=-211200
X47273 5 4 6538 2506 2415 2489 NO22_5VX1 $T=-284360 -116480 1 180 $X=-289830 $Y=-117120
X47274 5 4 6540 92 2481 2523 NO22_5VX1 $T=-286600 -197120 1 0 $X=-287030 $Y=-202240
X47275 5 4 6538 1452 2520 2489 NO22_5VX1 $T=-286600 -89600 1 0 $X=-287030 $Y=-94720
X47276 5 4 6540 224 2528 2523 NO22_5VX1 $T=-285480 -215040 1 0 $X=-285910 $Y=-220160
X47277 5 4 2556 80 2494 2533 NO22_5VX1 $T=-277080 -125440 1 180 $X=-282550 $Y=-126080
X47278 5 4 2540 2402 2524 2561 NO22_5VX1 $T=-279880 -170240 1 0 $X=-280310 $Y=-175360
X47279 5 4 2540 2557 2548 2561 NO22_5VX1 $T=-277080 -215040 0 0 $X=-277510 $Y=-215680
X47280 5 4 6549 2463 6558 2531 NO22_5VX1 $T=-277080 -116480 0 0 $X=-277510 $Y=-117120
X47281 5 4 7948 255 254 2620 NO22_5VX1 $T=-259160 8960 1 180 $X=-264630 $Y=8320
X47282 5 4 7948 2629 2632 2620 NO22_5VX1 $T=-258600 0 1 180 $X=-264070 $Y=-640
X47283 5 4 2556 1465 2640 2533 NO22_5VX1 $T=-262520 -152320 0 0 $X=-262950 $Y=-152960
X47284 5 4 2661 84 2487 6602 NO22_5VX1 $T=-254120 -215040 1 180 $X=-259590 $Y=-215680
X47285 5 4 2661 292 6610 6602 NO22_5VX1 $T=-241240 -250880 1 180 $X=-246710 $Y=-251520
X47286 5 4 2903 6677 2920 1472 NO22_5VX1 $T=-205400 -98560 1 0 $X=-205830 $Y=-103680
X47287 5 4 360 2930 2942 365 NO22_5VX1 $T=-201480 8960 0 0 $X=-201910 $Y=8320
X47288 5 4 367 2926 2935 361 NO22_5VX1 $T=-195880 8960 0 180 $X=-201350 $Y=3840
X47289 5 4 1475 3212 6769 3207 NO22_5VX1 $T=-137080 -116480 0 180 $X=-142550 $Y=-121600
X47290 5 4 3292 3223 6775 3228 NO22_5VX1 $T=-130920 -26880 0 180 $X=-136390 $Y=-32000
X47291 5 4 3524 6904 6903 3541 NO22_5VX1 $T=-63160 -80640 1 0 $X=-63590 $Y=-85760
X47292 5 4 3554 3547 3519 3572 NO22_5VX1 $T=-56440 -188160 1 180 $X=-61910 $Y=-188800
X47293 5 4 3524 3555 3464 3541 NO22_5VX1 $T=-54760 -98560 1 180 $X=-60230 $Y=-99200
X47294 5 4 6961 681 693 3714 NO22_5VX1 $T=-25640 -268800 1 0 $X=-26070 $Y=-273920
X47295 5 4 7085 3943 3971 3934 NO22_5VX1 $T=35400 -215040 0 180 $X=29930 $Y=-220160
X47296 5 4 4013 805 7092 4095 NO22_5VX1 $T=39320 -232960 0 0 $X=38890 $Y=-233600
X47297 5 4 4042 7092 7086 3961 NO22_5VX1 $T=45480 -215040 0 180 $X=40010 $Y=-220160
X47298 5 4 4025 4005 4043 4023 NO22_5VX1 $T=41560 -152320 1 0 $X=41130 $Y=-157440
X47299 5 4 7155 624 4220 7165 NO22_5VX1 $T=87480 -161280 0 0 $X=87050 $Y=-161920
X47300 5 4 4270 625 4221 4250 NO22_5VX1 $T=93080 -71680 1 180 $X=87610 $Y=-72320
X47301 5 4 7155 4259 4267 7165 NO22_5VX1 $T=89720 -188160 0 0 $X=89290 $Y=-188800
X47302 5 4 4256 7162 4226 7173 NO22_5VX1 $T=90280 -89600 1 0 $X=89850 $Y=-94720
X47303 5 4 7172 906 4278 4268 NO22_5VX1 $T=98680 -170240 1 180 $X=93210 $Y=-170880
X47304 5 4 4256 7167 7169 7173 NO22_5VX1 $T=93640 -98560 0 0 $X=93210 $Y=-99200
X47305 5 4 7166 1489 4300 4320 NO22_5VX1 $T=94200 -134400 0 0 $X=93770 $Y=-135040
X47306 5 4 4270 4260 7175 4250 NO22_5VX1 $T=95880 -89600 0 0 $X=95450 $Y=-90240
X47307 5 4 7166 4306 7183 4320 NO22_5VX1 $T=99240 -143360 0 0 $X=98810 $Y=-144000
X47308 5 4 4321 584 7178 4296 NO22_5VX1 $T=104840 -125440 1 180 $X=99370 $Y=-126080
X47309 5 4 7172 4310 4327 4268 NO22_5VX1 $T=100920 -188160 0 0 $X=100490 $Y=-188800
X47310 5 4 4342 3504 4307 4309 NO22_5VX1 $T=107080 -26880 1 180 $X=101610 $Y=-27520
X47311 5 4 4321 4314 4336 4296 NO22_5VX1 $T=104280 -152320 1 0 $X=103850 $Y=-157440
X47312 5 4 4257 1496 4356 7186 NO22_5VX1 $T=106520 -125440 1 0 $X=106090 $Y=-130560
X47313 5 4 4319 595 4355 7191 NO22_5VX1 $T=107080 -188160 0 0 $X=106650 $Y=-188800
X47314 5 4 4357 4273 943 1497 NO22_5VX1 $T=109880 -35840 0 0 $X=109450 $Y=-36480
X47315 5 4 4257 4383 4370 7186 NO22_5VX1 $T=116600 -134400 0 180 $X=111130 $Y=-139520
X47316 5 4 4357 4368 4332 1497 NO22_5VX1 $T=117160 -53760 1 180 $X=111690 $Y=-54400
X47317 5 4 4342 4315 4351 4309 NO22_5VX1 $T=117720 -80640 1 180 $X=112250 $Y=-81280
X47318 5 4 623 4342 951 4309 NO22_5VX1 $T=117720 -26880 1 180 $X=112250 $Y=-27520
X47319 5 4 4372 632 4367 4403 NO22_5VX1 $T=114920 -232960 0 0 $X=114490 $Y=-233600
X47320 5 4 4372 956 4409 4403 NO22_5VX1 $T=117720 -268800 0 0 $X=117290 $Y=-269440
X47321 5 4 4335 592 4419 4418 NO22_5VX1 $T=120520 -215040 1 0 $X=120090 $Y=-220160
X47322 5 4 4319 964 7198 7191 NO22_5VX1 $T=127800 -232960 1 180 $X=122330 $Y=-233600
X47323 5 4 4335 968 4440 4418 NO22_5VX1 $T=123320 -250880 0 0 $X=122890 $Y=-251520
X47324 5 4 4931 1148 7346 4897 NO22_5VX1 $T=239800 -241920 1 180 $X=234330 $Y=-242560
X47325 5 4 4900 1143 7353 4936 NO22_5VX1 $T=235320 -259840 0 0 $X=234890 $Y=-260480
X47326 5 4 4938 4908 4915 7347 NO22_5VX1 $T=240360 -179200 1 180 $X=234890 $Y=-179840
X47327 5 4 4920 4887 4935 4943 NO22_5VX1 $T=237560 -71680 1 0 $X=237130 $Y=-76800
X47328 5 4 7358 1167 1164 4939 NO22_5VX1 $T=243720 -259840 0 180 $X=238250 $Y=-264960
X47329 5 4 4938 1504 4969 7347 NO22_5VX1 $T=244840 -161280 1 180 $X=239370 $Y=-161920
X47330 5 4 7360 1174 1169 1502 NO22_5VX1 $T=245960 -268800 0 180 $X=240490 $Y=-273920
X47331 5 4 1503 4954 7365 4974 NO22_5VX1 $T=242600 -116480 0 0 $X=242170 $Y=-117120
X47332 5 4 1503 1165 4962 4974 NO22_5VX1 $T=242600 -71680 1 0 $X=242170 $Y=-76800
X47333 5 4 1177 1180 4952 1158 NO22_5VX1 $T=248200 -268800 1 180 $X=242730 $Y=-269440
X47334 5 4 7360 1119 4965 1502 NO22_5VX1 $T=243720 -259840 0 0 $X=243290 $Y=-260480
X47335 5 4 4900 1133 4978 4936 NO22_5VX1 $T=244840 -232960 0 0 $X=244410 $Y=-233600
X47336 5 4 7358 1117 4989 4939 NO22_5VX1 $T=246520 -241920 0 0 $X=246090 $Y=-242560
X47337 5 4 4968 4909 4918 4998 NO22_5VX1 $T=247080 -125440 1 0 $X=246650 $Y=-130560
X47338 5 4 4931 1123 4994 4897 NO22_5VX1 $T=247640 -224000 0 0 $X=247210 $Y=-224640
X47339 5 4 1173 4968 5005 4998 NO22_5VX1 $T=248200 -53760 1 0 $X=247770 $Y=-58880
X47340 5 4 4988 4929 7370 5004 NO22_5VX1 $T=248760 -134400 0 0 $X=248330 $Y=-135040
X47341 5 4 4996 4999 4961 5014 NO22_5VX1 $T=248760 -107520 0 0 $X=248330 $Y=-108160
X47342 5 4 4920 4984 1185 4943 NO22_5VX1 $T=248760 -71680 0 0 $X=248330 $Y=-72320
X47343 5 4 4988 4769 7372 5004 NO22_5VX1 $T=256040 -107520 0 180 $X=250570 $Y=-112640
X47344 5 4 4996 5000 1190 5014 NO22_5VX1 $T=251000 -71680 1 0 $X=250570 $Y=-76800
X47345 5 4 4968 1168 5025 4998 NO22_5VX1 $T=254920 -53760 1 0 $X=254490 $Y=-58880
X47346 5 4 5017 4905 4823 7970 NO22_5VX1 $T=256040 -206080 0 0 $X=255610 $Y=-206720
X47347 5 4 5017 4762 5026 7970 NO22_5VX1 $T=256040 -197120 0 0 $X=255610 $Y=-197760
X47348 5 4 7383 4944 5022 5021 NO22_5VX1 $T=261080 -143360 0 180 $X=255610 $Y=-148480
X47349 5 4 4986 1163 4893 5029 NO22_5VX1 $T=256600 -215040 1 0 $X=256170 $Y=-220160
X47350 5 4 4986 1109 5030 5029 NO22_5VX1 $T=257720 -206080 1 0 $X=257290 $Y=-211200
X47351 5 4 7383 1506 5038 5021 NO22_5VX1 $T=259960 -125440 0 0 $X=259530 $Y=-126080
X47352 5 4 5035 5048 4993 7385 NO22_5VX1 $T=266680 0 0 180 $X=261210 $Y=-5120
X47353 5 4 5060 5033 4926 7386 NO22_5VX1 $T=267240 -26880 0 180 $X=261770 $Y=-32000
X47354 5 4 5060 7391 1198 7386 NO22_5VX1 $T=268360 -17920 0 180 $X=262890 $Y=-23040
X47355 5 4 5035 1204 1202 7385 NO22_5VX1 $T=263880 8960 0 0 $X=263450 $Y=8320
X47356 5 4 1193 5060 1201 7386 NO22_5VX1 $T=270040 -8960 0 180 $X=264570 $Y=-14080
X47357 5 4 1252 5291 1254 1257 NO22_5VX1 $T=311480 8960 1 0 $X=311050 $Y=3840
X47358 5 4 1252 5300 7485 1257 NO22_5VX1 $T=314840 0 1 0 $X=314410 $Y=-5120
X47359 5 4 5307 1260 5314 5315 NO22_5VX1 $T=326040 -224000 0 180 $X=320570 $Y=-229120
X47360 5 4 7489 7501 5332 1508 NO22_5VX1 $T=321560 -116480 0 0 $X=321130 $Y=-117120
X47361 5 4 7505 5292 5392 1510 NO22_5VX1 $T=325480 -134400 1 0 $X=325050 $Y=-139520
X47362 5 4 5350 5294 5347 7512 NO22_5VX1 $T=325480 -44800 1 0 $X=325050 $Y=-49920
X47363 5 4 5353 5289 5334 5359 NO22_5VX1 $T=331080 -80640 1 180 $X=325610 $Y=-81280
X47364 5 4 5318 1273 5320 5330 NO22_5VX1 $T=332760 -241920 1 180 $X=327290 $Y=-242560
X47365 5 4 5350 5328 1271 7512 NO22_5VX1 $T=332760 -26880 0 180 $X=327290 $Y=-32000
X47366 5 4 5353 5349 7523 5359 NO22_5VX1 $T=329400 -80640 1 0 $X=328970 $Y=-85760
X47367 5 4 5350 5337 7522 7512 NO22_5VX1 $T=335000 -53760 1 180 $X=329530 $Y=-54400
X47368 5 4 1342 7684 7678 1338 NO22_5VX1 $T=421800 -17920 0 180 $X=416330 $Y=-23040
X47369 5 4 5761 5756 7708 5765 NO22_5VX1 $T=429640 -215040 1 0 $X=429210 $Y=-220160
X47370 5 4 5761 1517 5736 5765 NO22_5VX1 $T=436920 -232960 1 180 $X=431450 $Y=-233600
X47371 5 4 5811 1518 7725 5786 NO22_5VX1 $T=445320 -259840 1 180 $X=439850 $Y=-260480
X47372 5 4 5811 1519 1364 5786 NO22_5VX1 $T=445880 -268800 1 180 $X=440410 $Y=-269440
X47373 5 4 7733 1366 1357 5800 NO22_5VX1 $T=447000 -250880 1 180 $X=441530 $Y=-251520
X47374 5 4 5830 5869 8105 1382 NO22_5VX1 $T=452040 -8960 0 0 $X=451610 $Y=-9600
X47375 5 4 7754 5874 5884 5875 NO22_5VX1 $T=454280 -125440 0 0 $X=453850 $Y=-126080
X47376 5 4 7763 1385 1519 5859 NO22_5VX1 $T=460440 -268800 1 180 $X=454970 $Y=-269440
X47377 5 4 1400 7789 5941 1390 NO22_5VX1 $T=474440 8960 1 180 $X=468970 $Y=8320
X47378 5 4 7788 5958 5931 5953 NO22_5VX1 $T=472200 -188160 0 0 $X=471770 $Y=-188800
X47379 5 4 7815 5968 5969 7796 NO22_5VX1 $T=479480 -215040 0 180 $X=474010 $Y=-220160
X47380 5 4 5963 5975 7801 5929 NO22_5VX1 $T=476120 -107520 1 0 $X=475690 $Y=-112640
X47381 5 4 7804 5921 5940 1406 NO22_5VX1 $T=481160 -8960 0 180 $X=475690 $Y=-14080
X47382 5 4 7798 5931 7826 5881 NO22_5VX1 $T=477240 -179200 0 0 $X=476810 $Y=-179840
X47383 5 4 5943 5951 5990 1522 NO22_5VX1 $T=477240 -80640 0 0 $X=476810 $Y=-81280
X47384 5 4 5978 1397 7817 5999 NO22_5VX1 $T=482840 -250880 1 0 $X=482410 $Y=-256000
X47385 5 4 5978 1408 7833 5999 NO22_5VX1 $T=483400 -268800 0 0 $X=482970 $Y=-269440
X47386 5 4 6008 6060 6043 5858 NO22_5VX1 $T=497400 -152320 0 180 $X=491930 $Y=-157440
X47387 5 4 6036 1410 6033 6024 NO22_5VX1 $T=492920 -241920 0 0 $X=492490 $Y=-242560
X47388 5 4 6036 1411 6053 6024 NO22_5VX1 $T=492920 -232960 1 0 $X=492490 $Y=-238080
X47389 5 4 1862 1869 1872 6315 AN21_5VX1 $T=-435560 -44800 1 0 $X=-435990 $Y=-49920
X47390 5 4 1947 6345 1890 1943 AN21_5VX1 $T=-413160 -143360 1 180 $X=-417510 $Y=-144000
X47391 5 4 1977 6351 1936 1880 AN21_5VX1 $T=-410360 -152320 1 180 $X=-414710 $Y=-152960
X47392 5 4 69 1974 97 1448 AN21_5VX1 $T=-414280 8960 0 0 $X=-414710 $Y=8320
X47393 5 4 6367 1974 104 1448 AN21_5VX1 $T=-408120 8960 0 0 $X=-408550 $Y=8320
X47394 5 4 2025 2010 6381 1450 AN21_5VX1 $T=-398600 -179200 0 180 $X=-402950 $Y=-184320
X47395 5 4 201 2443 6514 2404 AN21_5VX1 $T=-308440 -259840 1 0 $X=-308870 $Y=-264960
X47396 5 4 2429 6528 2430 2509 AN21_5VX1 $T=-296120 -197120 0 0 $X=-296550 $Y=-197760
X47397 5 4 2529 6550 2541 2512 AN21_5VX1 $T=-281560 -80640 1 0 $X=-281990 $Y=-85760
X47398 5 4 2511 7947 6568 235 AN21_5VX1 $T=-279880 -35840 0 0 $X=-280310 $Y=-36480
X47399 5 4 2542 2584 2606 6572 AN21_5VX1 $T=-271480 -17920 0 0 $X=-271910 $Y=-18560
X47400 5 4 2551 236 2552 249 AN21_5VX1 $T=-265880 0 1 180 $X=-270230 $Y=-640
X47401 5 4 2579 1463 6560 242 AN21_5VX1 $T=-265320 -44800 0 180 $X=-269670 $Y=-49920
X47402 5 4 2616 6573 2572 2642 AN21_5VX1 $T=-264200 -62720 1 180 $X=-268550 $Y=-63360
X47403 5 4 2814 6645 2795 329 AN21_5VX1 $T=-221080 -250880 1 180 $X=-225430 $Y=-251520
X47404 5 4 2869 6675 362 1472 AN21_5VX1 $T=-203720 -17920 0 0 $X=-204150 $Y=-18560
X47405 5 4 6795 3206 3207 6788 AN21_5VX1 $T=-126440 -125440 0 180 $X=-130790 $Y=-130560
X47406 5 4 1482 3583 3501 1483 AN21_5VX1 $T=-50840 -116480 0 0 $X=-51270 $Y=-117120
X47407 5 4 3589 3583 3592 1483 AN21_5VX1 $T=-48600 -80640 0 0 $X=-49030 $Y=-81280
X47408 5 4 658 6934 6937 3624 AN21_5VX1 $T=-42440 -206080 0 0 $X=-42870 $Y=-206720
X47409 5 4 3661 1486 3650 6947 AN21_5VX1 $T=-36840 -215040 1 0 $X=-37270 $Y=-220160
X47410 5 4 656 3671 3630 3711 AN21_5VX1 $T=-32360 -197120 0 0 $X=-32790 $Y=-197760
X47411 5 4 3620 3662 6959 1487 AN21_5VX1 $T=-30680 -170240 0 0 $X=-31110 $Y=-170880
X47412 5 4 695 3719 3615 3800 AN21_5VX1 $T=-17240 -232960 0 180 $X=-21590 $Y=-238080
X47413 5 4 3753 6985 6978 3742 AN21_5VX1 $T=-11080 -116480 1 180 $X=-15430 $Y=-117120
X47414 5 4 709 3752 3610 3724 AN21_5VX1 $T=-7720 -241920 1 180 $X=-12070 $Y=-242560
X47415 5 4 3754 6996 6998 3774 AN21_5VX1 $T=-11640 -89600 1 0 $X=-12070 $Y=-94720
X47416 5 4 3693 6997 3772 3782 AN21_5VX1 $T=-9400 -170240 1 0 $X=-9830 $Y=-175360
X47417 5 4 3701 3776 3779 3783 AN21_5VX1 $T=-9400 -143360 1 0 $X=-9830 $Y=-148480
X47418 5 4 3775 7004 7003 1490 AN21_5VX1 $T=-6040 -125440 0 0 $X=-6470 $Y=-126080
X47419 5 4 3777 3794 7007 1491 AN21_5VX1 $T=-6040 -44800 0 0 $X=-6470 $Y=-45440
X47420 5 4 3747 3821 719 3798 AN21_5VX1 $T=-4360 -8960 0 0 $X=-4790 $Y=-9600
X47421 5 4 3737 3804 7000 3805 AN21_5VX1 $T=-3800 -80640 0 0 $X=-4230 $Y=-81280
X47422 5 4 3824 3821 3837 3798 AN21_5VX1 $T=3480 -8960 1 180 $X=-870 $Y=-9600
X47423 5 4 3859 3747 8095 7024 AN21_5VX1 $T=10200 -26880 0 180 $X=5850 $Y=-32000
X47424 5 4 3811 7030 3861 3867 AN21_5VX1 $T=14120 -71680 1 180 $X=9770 $Y=-72320
X47425 5 4 3937 3946 7059 3930 AN21_5VX1 $T=27560 -26880 1 180 $X=23210 $Y=-27520
X47426 5 4 7058 3956 3964 768 AN21_5VX1 $T=26440 -44800 0 0 $X=26010 $Y=-45440
X47427 5 4 3998 7074 7072 3935 AN21_5VX1 $T=36520 -197120 1 180 $X=32170 $Y=-197760
X47428 5 4 799 4003 3923 4006 AN21_5VX1 $T=34840 -259840 1 0 $X=34410 $Y=-264960
X47429 5 4 3999 4029 4017 1494 AN21_5VX1 $T=34840 -179200 0 0 $X=34410 $Y=-179840
X47430 5 4 4011 3929 3994 1493 AN21_5VX1 $T=39320 -71680 0 180 $X=34970 $Y=-76800
X47431 5 4 4045 4029 4024 1494 AN21_5VX1 $T=44360 -179200 1 180 $X=40010 $Y=-179840
X47432 5 4 4055 4051 3989 3886 AN21_5VX1 $T=48280 -89600 1 180 $X=43930 $Y=-90240
X47433 5 4 4120 4069 4117 4023 AN21_5VX1 $T=60600 -152320 0 180 $X=56250 $Y=-157440
X47434 5 4 5206 5237 7447 7451 AN21_5VX1 $T=301400 -53760 1 180 $X=297050 $Y=-54400
X47435 5 4 1170 7453 7440 5230 AN21_5VX1 $T=301400 -35840 1 180 $X=297050 $Y=-36480
X47436 5 4 5233 5257 7973 1505 AN21_5VX1 $T=302520 -53760 0 0 $X=302090 $Y=-54400
X47437 5 4 7494 1507 1266 1508 AN21_5VX1 $T=320440 -35840 0 0 $X=320010 $Y=-36480
X47438 5 4 5254 7509 7499 5330 AN21_5VX1 $T=327720 -161280 0 180 $X=323370 $Y=-166400
X47439 5 4 5339 7516 5317 5315 AN21_5VX1 $T=329960 -179200 0 180 $X=325610 $Y=-184320
X47440 5 4 7503 7514 5360 1510 AN21_5VX1 $T=326040 -98560 0 0 $X=325610 $Y=-99200
X47441 5 4 5694 1340 5695 1339 AN21_5VX1 $T=423480 0 1 180 $X=419130 $Y=-640
X47442 5 4 5730 7692 7705 1344 AN21_5VX1 $T=424040 -26880 0 0 $X=423610 $Y=-27520
X47443 5 4 5764 5758 7698 5743 AN21_5VX1 $T=432440 -89600 0 180 $X=428090 $Y=-94720
X47444 5 4 5748 5759 7710 1345 AN21_5VX1 $T=429080 0 1 0 $X=428650 $Y=-5120
X47445 5 4 5772 7707 5742 5768 AN21_5VX1 $T=435240 -116480 0 180 $X=430890 $Y=-121600
X47446 5 4 5767 5776 7723 5762 AN21_5VX1 $T=432440 -206080 1 0 $X=432010 $Y=-211200
X47447 5 4 5777 5784 5796 5779 AN21_5VX1 $T=434680 -134400 1 0 $X=434250 $Y=-139520
X47448 5 4 5793 7718 7703 5763 AN21_5VX1 $T=441400 -107520 0 180 $X=437050 $Y=-112640
X47449 5 4 5809 7720 5797 1356 AN21_5VX1 $T=441400 -44800 1 180 $X=437050 $Y=-45440
X47450 5 4 1358 7722 1360 1361 AN21_5VX1 $T=438040 -268800 1 0 $X=437610 $Y=-273920
X47451 5 4 5774 7981 5780 5794 AN21_5VX1 $T=443640 -62720 1 180 $X=439290 $Y=-63360
X47452 5 4 5746 7726 7735 5812 AN21_5VX1 $T=440280 -161280 1 0 $X=439850 $Y=-166400
X47453 5 4 5803 7728 5818 7730 AN21_5VX1 $T=441400 -71680 1 0 $X=440970 $Y=-76800
X47454 5 4 5827 7742 5838 5804 AN21_5VX1 $T=446440 -179200 1 0 $X=446010 $Y=-184320
X47455 5 4 1376 7766 1518 5859 AN21_5VX1 $T=453160 -268800 1 180 $X=448810 $Y=-269440
X47456 5 4 5878 7759 5898 1382 AN21_5VX1 $T=457640 0 0 0 $X=457210 $Y=-640
X47457 5 4 5926 7769 5892 7773 AN21_5VX1 $T=467160 -62720 1 180 $X=462810 $Y=-63360
X47458 5 4 5911 7795 5961 5929 AN21_5VX1 $T=471640 -98560 1 0 $X=471210 $Y=-103680
X47459 5 4 1525 5888 5994 5946 AN21_5VX1 $T=472200 -125440 0 0 $X=471770 $Y=-126080
X47460 5 4 6006 5992 6018 8004 AN21_5VX1 $T=485640 -206080 0 0 $X=485210 $Y=-206720
X47461 5 4 1857 55 68 EN2_5VX0 $T=-436680 0 1 0 $X=-437110 $Y=-5120
X47462 5 4 1462 1841 6353 EN2_5VX0 $T=-419320 -80640 0 0 $X=-419750 $Y=-81280
X47463 5 4 1900 58 1965 EN2_5VX0 $T=-408120 -62720 1 180 $X=-414710 $Y=-63360
X47464 5 4 1841 59 8075 EN2_5VX0 $T=-399720 -53760 1 180 $X=-406310 $Y=-54400
X47465 5 4 1469 2835 2785 EN2_5VX0 $T=-214920 -71680 1 180 $X=-221510 $Y=-72320
X47466 5 4 84 79 2843 EN2_5VX0 $T=-220520 -125440 0 0 $X=-220950 $Y=-126080
X47467 5 4 1841 58 350 EN2_5VX0 $T=-216600 8960 0 0 $X=-217030 $Y=8320
X47468 5 4 89 84 6650 EN2_5VX0 $T=-209880 -134400 0 180 $X=-216470 $Y=-139520
X47469 5 4 1447 1452 6658 EN2_5VX0 $T=-209880 -71680 0 180 $X=-216470 $Y=-76800
X47470 5 4 80 1447 2852 EN2_5VX0 $T=-206520 -80640 0 180 $X=-213110 $Y=-85760
X47471 5 4 1462 1900 2844 EN2_5VX0 $T=-204280 -35840 1 180 $X=-210870 $Y=-36480
X47472 5 4 1452 1462 6670 EN2_5VX0 $T=-202040 -44800 0 180 $X=-208630 $Y=-49920
X47473 5 4 3555 3545 6895 EN2_5VX0 $T=-55880 -107520 1 180 $X=-62470 $Y=-108160
X47474 5 4 586 624 6914 EN2_5VX0 $T=-57560 -116480 0 0 $X=-57990 $Y=-117120
X47475 5 4 3385 625 6913 EN2_5VX0 $T=-45800 -17920 1 180 $X=-52390 $Y=-18560
X47476 5 4 595 586 6930 EN2_5VX0 $T=-48600 -134400 0 0 $X=-49030 $Y=-135040
X47477 5 4 3414 584 3600 EN2_5VX0 $T=-40200 -89600 1 180 $X=-46790 $Y=-90240
X47478 5 4 3407 3413 3634 EN2_5VX0 $T=-45240 -44800 1 0 $X=-45670 $Y=-49920
X47479 5 4 592 595 3638 EN2_5VX0 $T=-42440 -152320 0 0 $X=-42870 $Y=-152960
X47480 5 4 584 3407 3616 EN2_5VX0 $T=-35160 -62720 0 180 $X=-41750 $Y=-67840
X47481 5 4 662 632 6938 EN2_5VX0 $T=-33480 -268800 0 180 $X=-40070 $Y=-273920
X47482 5 4 3413 3385 8090 EN2_5VX0 $T=-26760 -35840 1 180 $X=-33350 $Y=-36480
X47483 5 4 632 592 6954 EN2_5VX0 $T=-23400 -179200 1 180 $X=-29990 $Y=-179840
X47484 5 4 3747 7928 707 EN2_5VX0 $T=-14440 0 1 0 $X=-14870 $Y=-5120
X47485 5 4 670 679 8093 EN2_5VX0 $T=-7160 -241920 0 180 $X=-13750 $Y=-247040
X47486 5 4 3504 625 3787 EN2_5VX0 $T=9640 -53760 0 180 $X=3050 $Y=-58880
X47487 5 4 4762 4754 7480 EN2_5VX0 $T=306440 -125440 1 0 $X=306010 $Y=-130560
X47488 5 4 1119 1117 5253 EN2_5VX0 $T=313720 -197120 1 180 $X=307130 $Y=-197760
X47489 5 4 4754 1515 5306 EN2_5VX0 $T=308120 -116480 1 0 $X=307690 $Y=-121600
X47490 5 4 1515 1504 5259 EN2_5VX0 $T=315960 -89600 1 180 $X=309370 $Y=-90240
X47491 5 4 1109 4762 7471 EN2_5VX0 $T=316520 -143360 1 180 $X=309930 $Y=-144000
X47492 5 4 1109 4754 5833 EN2_5VX0 $T=457080 -125440 0 180 $X=450490 $Y=-130560
X47493 5 4 2649 2638 2731 EO2_5VX0 $T=-246840 -224000 1 0 $X=-247270 $Y=-229120
X47494 5 4 3232 6781 3245 3241 NA22_5VX1 $T=-133160 -215040 1 0 $X=-133590 $Y=-220160
X47495 5 4 3241 6787 3249 3250 NA22_5VX1 $T=-132600 -197120 1 0 $X=-133030 $Y=-202240
X47496 5 4 3217 3218 3256 6793 NA22_5VX1 $T=-132040 -161280 1 0 $X=-132470 $Y=-166400
X47497 5 4 3250 6798 1478 3217 NA22_5VX1 $T=-121960 -179200 1 180 $X=-126870 $Y=-179840
X47498 5 4 3371 6832 7924 3355 NA22_5VX1 $T=-88920 -26880 1 180 $X=-93830 $Y=-27520
X47499 5 4 1486 662 1485 655 NA22_5VX1 $T=-35720 -259840 1 180 $X=-40630 $Y=-260480
X47500 5 4 2753 2772 6640 1900 ON21_5VX4 $T=-228360 -26880 0 0 $X=-228790 $Y=-27520
X47501 5 4 2785 2773 2791 1447 ON21_5VX4 $T=-226120 -80640 0 0 $X=-226550 $Y=-81280
X47502 5 4 6633 2786 2817 1452 ON21_5VX4 $T=-225560 -62720 1 0 $X=-225990 $Y=-67840
X47503 5 4 2808 6641 1467 1462 MU2_5VX4 $T=-227240 -44800 1 0 $X=-227670 $Y=-49920
X47504 5 4 6636 2806 2810 1841 MU2_5VX4 $T=-227240 -8960 0 0 $X=-227670 $Y=-9600
X47505 5 4 6648 2790 6642 79 MU2_5VX4 $T=-224440 -116480 0 0 $X=-224870 $Y=-117120
X47506 5 4 436 6750 3152 139 MU2_5VX4 $T=-147720 -259840 0 180 $X=-158790 $Y=-264960
X47507 5 4 80 2784 6403 2807 2773 FA_5VX4 $T=-246280 -89600 1 0 $X=-246710 $Y=-94720
X47508 5 4 84 6639 2108 2825 2790 FA_5VX4 $T=-242360 -125440 1 0 $X=-242790 $Y=-130560
X47509 5 4 89 6644 2834 2847 6639 FA_5VX4 $T=-239560 -143360 0 0 $X=-239990 $Y=-144000
X47510 5 4 92 2824 2338 2842 6644 FA_5VX4 $T=-239000 -170240 0 0 $X=-239430 $Y=-170880
X47511 5 4 584 6837 3158 6824 3350 FA_5VX4 $T=-75480 -71680 1 180 $X=-98310 $Y=-72320
X47512 5 4 595 6839 6821 6825 3369 FA_5VX4 $T=-72680 -125440 0 180 $X=-95510 $Y=-130560
X47513 5 4 1109 4696 4628 4624 4661 FA_5VX4 $T=203400 -152320 1 180 $X=180570 $Y=-152960
X47514 5 4 4754 7290 1085 4679 7288 FA_5VX4 $T=209000 -116480 1 180 $X=186170 $Y=-117120
X47515 5 4 4769 4739 1089 4662 1100 FA_5VX4 $T=211240 -26880 1 180 $X=188410 $Y=-27520
X47516 5 4 4762 4661 1090 4664 7290 FA_5VX4 $T=211800 -134400 1 180 $X=188970 $Y=-135040
X47517 5 4 1515 7288 1091 4704 7293 FA_5VX4 $T=211800 -98560 1 180 $X=188970 $Y=-99200
X47518 5 4 1504 7293 1096 8098 7300 FA_5VX4 $T=214600 -80640 0 180 $X=191770 $Y=-85760
X47519 5 4 1523 7300 1099 4680 4725 FA_5VX4 $T=217400 -53760 0 180 $X=194570 $Y=-58880
X47520 5 4 1506 4725 1121 4593 4739 FA_5VX4 $T=225800 -35840 1 180 $X=202970 $Y=-36480
X47521 5 4 100 6737 3144 2842 HA_5VX4 $T=-167880 -197120 0 0 $X=-168310 $Y=-197760
X47522 5 4 137 3112 6754 3144 HA_5VX4 $T=-167320 -215040 1 0 $X=-167750 $Y=-220160
X47523 5 4 141 6741 8082 3112 HA_5VX4 $T=-161720 -241920 0 0 $X=-162150 $Y=-242560
X47524 5 4 637 3802 3730 6984 HA_5VX4 $T=-1000 -215040 1 180 $X=-17110 $Y=-215680
X47525 5 4 679 6991 7011 3730 HA_5VX4 $T=-16120 -232960 1 0 $X=-16550 $Y=-238080
X47526 5 4 677 3722 6984 3425 HA_5VX4 $T=1800 -197120 1 180 $X=-14310 $Y=-197760
X47527 5 4 670 3799 743 7011 HA_5VX4 $T=-7160 -241920 1 0 $X=-7590 $Y=-247040
X47528 5 4 1119 7282 1095 4682 HA_5VX4 $T=208440 -268800 1 180 $X=192330 $Y=-269440
X47529 5 4 1117 4598 4682 7295 HA_5VX4 $T=209000 -232960 0 180 $X=192890 $Y=-238080
X47530 5 4 1123 7287 4684 4696 HA_5VX4 $T=210680 -197120 1 180 $X=194570 $Y=-197760
X47531 5 4 1133 4729 7295 4684 HA_5VX4 $T=214600 -232960 1 180 $X=198490 $Y=-233600
X47532 5 4 1596 30 1549 DFRQ_5VX1 $T=-493240 -17920 0 0 $X=-493670 $Y=-18560
X47533 5 4 1598 1643 6243 DFRQ_5VX1 $T=-492680 -89600 0 0 $X=-493110 $Y=-90240
X47534 5 4 1601 30 6241 DFRQ_5VX1 $T=-492680 -8960 0 0 $X=-493110 $Y=-9600
X47535 5 4 1604 1621 1561 DFRQ_5VX1 $T=-491560 -71680 0 0 $X=-491990 $Y=-72320
X47536 5 4 1606 30 6242 DFRQ_5VX1 $T=-491560 -26880 1 0 $X=-491990 $Y=-32000
X47537 5 4 1605 1621 1656 DFRQ_5VX1 $T=-491000 -53760 1 0 $X=-491430 $Y=-58880
X47538 5 4 6240 1621 1593 DFRQ_5VX1 $T=-476440 -44800 1 180 $X=-491430 $Y=-45440
X47539 5 4 6236 1621 6248 DFRQ_5VX1 $T=-489880 -80640 0 0 $X=-490310 $Y=-81280
X47540 5 4 1612 1690 6250 DFRQ_5VX1 $T=-489320 -134400 1 0 $X=-489750 $Y=-139520
X47541 5 4 1590 1643 1444 DFRQ_5VX1 $T=-488760 -98560 0 0 $X=-489190 $Y=-99200
X47542 5 4 1583 30 1530 DFRQ_5VX1 $T=-488760 0 0 0 $X=-489190 $Y=-640
X47543 5 4 1616 30 32 DFRQ_5VX1 $T=-488760 8960 1 0 $X=-489190 $Y=3840
X47544 5 4 6237 1643 1624 DFRQ_5VX1 $T=-488200 -125440 0 0 $X=-488630 $Y=-126080
X47545 5 4 1557 1621 6246 DFRQ_5VX1 $T=-487080 -53760 0 0 $X=-487510 $Y=-54400
X47546 5 4 6238 1690 6260 DFRQ_5VX1 $T=-484840 -125440 1 0 $X=-485270 $Y=-130560
X47547 5 4 1631 1643 7934 DFRQ_5VX1 $T=-484840 -107520 1 0 $X=-485270 $Y=-112640
X47548 5 4 1650 1643 1625 DFRQ_5VX1 $T=-468600 -107520 1 180 $X=-483590 $Y=-108160
X47549 5 4 6247 1690 6268 DFRQ_5VX1 $T=-478120 -152320 0 0 $X=-478550 $Y=-152960
X47550 5 4 6264 1690 1638 DFRQ_5VX1 $T=-461880 -161280 0 180 $X=-476870 $Y=-166400
X47551 5 4 1675 6270 1702 DFRQ_5VX1 $T=-473640 -179200 1 0 $X=-474070 $Y=-184320
X47552 5 4 1664 1690 6280 DFRQ_5VX1 $T=-473080 -170240 1 0 $X=-473510 $Y=-175360
X47553 5 4 1714 1815 6296 DFRQ_5VX1 $T=-465240 -232960 0 0 $X=-465670 $Y=-233600
X47554 5 4 6275 6270 6292 DFRQ_5VX1 $T=-465240 -197120 1 0 $X=-465670 $Y=-202240
X47555 5 4 1741 6270 1765 DFRQ_5VX1 $T=-461320 -215040 0 0 $X=-461750 $Y=-215680
X47556 5 4 1751 6270 7938 DFRQ_5VX1 $T=-459640 -188160 1 0 $X=-460070 $Y=-193280
X47557 5 4 1764 1815 6298 DFRQ_5VX1 $T=-457400 -241920 0 0 $X=-457830 $Y=-242560
X47558 5 4 1715 6270 6302 DFRQ_5VX1 $T=-451240 -206080 0 0 $X=-451670 $Y=-206720
X47559 5 4 6295 1815 6312 DFRQ_5VX1 $T=-450680 -250880 1 0 $X=-451110 $Y=-256000
X47560 5 4 7920 1815 1865 DFRQ_5VX1 $T=-449000 -224000 0 0 $X=-449430 $Y=-224640
X47561 5 4 6310 63 7939 DFRQ_5VX1 $T=-430520 -268800 1 180 $X=-445510 $Y=-269440
X47562 5 4 7921 1815 1894 DFRQ_5VX1 $T=-443960 -232960 1 0 $X=-444390 $Y=-238080
X47563 5 4 6308 63 1916 DFRQ_5VX1 $T=-440040 -250880 0 0 $X=-440470 $Y=-251520
X47564 5 4 1812 63 1933 DFRQ_5VX1 $T=-434440 -259840 1 0 $X=-434870 $Y=-264960
X47565 5 4 2027 2172 2032 DFRQ_5VX1 $T=-403640 -80640 0 0 $X=-404070 $Y=-81280
X47566 5 4 2012 2172 2083 DFRQ_5VX1 $T=-403080 -98560 0 0 $X=-403510 $Y=-99200
X47567 5 4 1554 2172 6403 DFRQ_5VX1 $T=-403080 -89600 1 0 $X=-403510 $Y=-94720
X47568 5 4 6390 2172 2108 DFRQ_5VX1 $T=-399720 -116480 0 0 $X=-400150 $Y=-117120
X47569 5 4 2039 2261 1957 DFRQ_5VX1 $T=-385160 -35840 1 0 $X=-385590 $Y=-40960
X47570 5 4 6421 2175 6438 DFRQ_5VX1 $T=-377320 -62720 0 0 $X=-377750 $Y=-63360
X47571 5 4 2089 2174 2200 DFRQ_5VX1 $T=-376760 -116480 1 0 $X=-377190 $Y=-121600
X47572 5 4 2087 2172 1942 DFRQ_5VX1 $T=-376760 -98560 1 0 $X=-377190 $Y=-103680
X47573 5 4 2155 2172 6439 DFRQ_5VX1 $T=-376760 -89600 1 0 $X=-377190 $Y=-94720
X47574 5 4 2049 2174 2834 DFRQ_5VX1 $T=-376200 -125440 1 0 $X=-376630 $Y=-130560
X47575 5 4 2158 2172 6443 DFRQ_5VX1 $T=-376200 -80640 0 0 $X=-376630 $Y=-81280
X47576 5 4 2034 2175 2202 DFRQ_5VX1 $T=-376200 -53760 1 0 $X=-376630 $Y=-58880
X47577 5 4 2159 2175 6445 DFRQ_5VX1 $T=-376200 -53760 0 0 $X=-376630 $Y=-54400
X47578 5 4 2160 2261 8108 DFRQ_5VX1 $T=-376200 -26880 1 0 $X=-376630 $Y=-32000
X47579 5 4 1618 2240 7944 DFRQ_5VX1 $T=-348200 -170240 1 0 $X=-348630 $Y=-175360
X47580 5 4 2203 2240 2770 DFRQ_5VX1 $T=-348200 -152320 1 0 $X=-348630 $Y=-157440
X47581 5 4 7943 2240 2234 DFRQ_5VX1 $T=-348200 -152320 0 0 $X=-348630 $Y=-152960
X47582 5 4 2229 2240 2268 DFRQ_5VX1 $T=-348200 -134400 1 0 $X=-348630 $Y=-139520
X47583 5 4 2189 2174 8109 DFRQ_5VX1 $T=-348200 -134400 0 0 $X=-348630 $Y=-135040
X47584 5 4 2256 2174 6446 DFRQ_5VX1 $T=-333640 -116480 1 180 $X=-348630 $Y=-117120
X47585 5 4 1617 2174 2250 DFRQ_5VX1 $T=-348200 -98560 1 0 $X=-348630 $Y=-103680
X47586 5 4 1595 2175 2269 DFRQ_5VX1 $T=-348200 -89600 0 0 $X=-348630 $Y=-90240
X47587 5 4 2230 2261 1873 DFRQ_5VX1 $T=-348200 -26880 0 0 $X=-348630 $Y=-27520
X47588 5 4 1581 166 2216 DFRQ_5VX1 $T=-348200 -8960 0 0 $X=-348630 $Y=-9600
X47589 5 4 2205 166 2252 DFRQ_5VX1 $T=-348200 8960 1 0 $X=-348630 $Y=3840
X47590 5 4 1646 2240 6460 DFRQ_5VX1 $T=-347640 -161280 1 0 $X=-348070 $Y=-166400
X47591 5 4 6436 166 2251 DFRQ_5VX1 $T=-347640 -17920 0 0 $X=-348070 $Y=-18560
X47592 5 4 2090 166 1959 DFRQ_5VX1 $T=-347640 0 1 0 $X=-348070 $Y=-5120
X47593 5 4 2066 2175 6472 DFRQ_5VX1 $T=-347080 -71680 0 0 $X=-347510 $Y=-72320
X47594 5 4 1587 2261 2221 DFRQ_5VX1 $T=-331960 -53760 1 180 $X=-346950 $Y=-54400
X47595 5 4 2235 2175 2276 DFRQ_5VX1 $T=-345960 -80640 1 0 $X=-346390 $Y=-85760
X47596 5 4 1585 2261 2190 DFRQ_5VX1 $T=-329160 -26880 0 180 $X=-344150 $Y=-32000
X47597 5 4 1572 2261 6451 DFRQ_5VX1 $T=-328040 -44800 1 180 $X=-343030 $Y=-45440
X47598 5 4 2236 2240 2280 DFRQ_5VX1 $T=-339240 -161280 0 0 $X=-339670 $Y=-161920
X47599 5 4 6461 2298 2311 DFRQ_5VX1 $T=-338120 -179200 0 0 $X=-338550 $Y=-179840
X47600 5 4 2154 2309 2354 DFRQ_5VX1 $T=-335880 -224000 0 0 $X=-336310 $Y=-224640
X47601 5 4 176 166 1469 DFRQ_5VX1 $T=-335320 -8960 1 0 $X=-335750 $Y=-14080
X47602 5 4 1602 166 1997 DFRQ_5VX1 $T=-320760 8960 1 180 $X=-335750 $Y=8320
X47603 5 4 1647 2174 6466 DFRQ_5VX1 $T=-319640 -125440 0 180 $X=-334630 $Y=-130560
X47604 5 4 6475 2309 2310 DFRQ_5VX1 $T=-333640 -215040 0 0 $X=-334070 $Y=-215680
X47605 5 4 1658 2298 6491 DFRQ_5VX1 $T=-333640 -170240 1 0 $X=-334070 $Y=-175360
X47606 5 4 2062 2240 2338 DFRQ_5VX1 $T=-333640 -152320 0 0 $X=-334070 $Y=-152960
X47607 5 4 1623 2240 2321 DFRQ_5VX1 $T=-332520 -143360 1 0 $X=-332950 $Y=-148480
X47608 5 4 2294 2309 191 DFRQ_5VX1 $T=-331400 -241920 1 0 $X=-331830 $Y=-247040
X47609 5 4 2198 2309 2170 DFRQ_5VX1 $T=-331400 -206080 0 0 $X=-331830 $Y=-206720
X47610 5 4 2104 2309 2214 DFRQ_5VX1 $T=-330840 -232960 0 0 $X=-331270 $Y=-233600
X47611 5 4 7945 2298 2337 DFRQ_5VX1 $T=-329720 -197120 0 0 $X=-330150 $Y=-197760
X47612 5 4 2317 2298 2346 DFRQ_5VX1 $T=-326920 -170240 0 0 $X=-327350 $Y=-170880
X47613 5 4 2328 2298 2385 DFRQ_5VX1 $T=-324680 -188160 0 0 $X=-325110 $Y=-188800
X47614 5 4 1711 2309 2558 DFRQ_5VX1 $T=-319080 -206080 1 0 $X=-319510 $Y=-211200
X47615 5 4 1689 2298 2091 DFRQ_5VX1 $T=-314600 -188160 1 0 $X=-315030 $Y=-193280
X47616 5 4 7915 2298 2173 DFRQ_5VX1 $T=-314600 -179200 1 0 $X=-315030 $Y=-184320
X47617 5 4 2287 6627 2717 DFRQ_5VX1 $T=-259160 -134400 0 0 $X=-259590 $Y=-135040
X47618 5 4 2263 2744 2767 DFRQ_5VX1 $T=-246840 -62720 0 0 $X=-247270 $Y=-63360
X47619 5 4 1456 2751 2781 DFRQ_5VX1 $T=-243480 -80640 0 0 $X=-243910 $Y=-81280
X47620 5 4 2729 2744 2779 DFRQ_5VX1 $T=-243480 -26880 1 0 $X=-243910 $Y=-32000
X47621 5 4 2260 6627 2161 DFRQ_5VX1 $T=-242920 -116480 0 0 $X=-243350 $Y=-117120
X47622 5 4 2706 308 2782 DFRQ_5VX1 $T=-242360 -268800 0 0 $X=-242790 $Y=-269440
X47623 5 4 2180 2751 2752 DFRQ_5VX1 $T=-242360 -71680 0 0 $X=-242790 $Y=-72320
X47624 5 4 2246 2744 3164 DFRQ_5VX1 $T=-242360 -44800 0 0 $X=-242790 $Y=-45440
X47625 5 4 2689 2744 6634 DFRQ_5VX1 $T=-241800 -44800 1 0 $X=-242230 $Y=-49920
X47626 5 4 2742 2751 2797 DFRQ_5VX1 $T=-240680 -107520 1 0 $X=-241110 $Y=-112640
X47627 5 4 2738 315 2794 DFRQ_5VX1 $T=-240120 -8960 1 0 $X=-240550 $Y=-14080
X47628 5 4 2756 6627 2812 DFRQ_5VX1 $T=-237880 -143360 1 0 $X=-238310 $Y=-148480
X47629 5 4 2334 2751 2816 DFRQ_5VX1 $T=-237880 -107520 0 0 $X=-238310 $Y=-108160
X47630 5 4 2766 315 2813 DFRQ_5VX1 $T=-236760 8960 1 0 $X=-237190 $Y=3840
X47631 5 4 6631 6627 3000 DFRQ_5VX1 $T=-236200 -170240 1 0 $X=-236630 $Y=-175360
X47632 5 4 6600 6627 2815 DFRQ_5VX1 $T=-236200 -134400 0 0 $X=-236630 $Y=-135040
X47633 5 4 6632 6627 2840 DFRQ_5VX1 $T=-234520 -116480 1 0 $X=-234950 $Y=-121600
X47634 5 4 6623 2751 3051 DFRQ_5VX1 $T=-233400 -89600 0 0 $X=-233830 $Y=-90240
X47635 5 4 2778 6627 2833 DFRQ_5VX1 $T=-232840 -152320 1 0 $X=-233270 $Y=-157440
X47636 5 4 2765 2744 2848 DFRQ_5VX1 $T=-231720 -35840 0 0 $X=-232150 $Y=-36480
X47637 5 4 2764 2751 6651 DFRQ_5VX1 $T=-230600 -80640 1 0 $X=-231030 $Y=-85760
X47638 5 4 2798 2751 2861 DFRQ_5VX1 $T=-230040 -98560 0 0 $X=-230470 $Y=-99200
X47639 5 4 2809 2744 3055 DFRQ_5VX1 $T=-228360 -35840 1 0 $X=-228790 $Y=-40960
X47640 5 4 2242 2751 3167 DFRQ_5VX1 $T=-223880 -89600 1 0 $X=-224310 $Y=-94720
X47641 5 4 6637 2744 2897 DFRQ_5VX1 $T=-222760 -53760 0 0 $X=-223190 $Y=-54400
X47642 5 4 6653 315 2961 DFRQ_5VX1 $T=-221080 -17920 0 0 $X=-221510 $Y=-18560
X47643 5 4 2734 315 6669 DFRQ_5VX1 $T=-218840 0 1 0 $X=-219270 $Y=-5120
X47644 5 4 2722 315 2945 DFRQ_5VX1 $T=-211000 -8960 1 0 $X=-211430 $Y=-14080
X47645 5 4 2789 2974 3016 DFRQ_5VX1 $T=-197000 -197120 0 0 $X=-197430 $Y=-197760
X47646 5 4 2683 381 6700 DFRQ_5VX1 $T=-193080 -259840 0 0 $X=-193510 $Y=-260480
X47647 5 4 2690 381 6698 DFRQ_5VX1 $T=-191400 -241920 1 0 $X=-191830 $Y=-247040
X47648 5 4 2800 2974 3020 DFRQ_5VX1 $T=-188040 -224000 1 0 $X=-188470 $Y=-229120
X47649 5 4 390 2974 3062 DFRQ_5VX1 $T=-186360 -188160 0 0 $X=-186790 $Y=-188800
X47650 5 4 2777 3097 3079 DFRQ_5VX1 $T=-183560 -161280 1 0 $X=-183990 $Y=-166400
X47651 5 4 2374 2974 3088 DFRQ_5VX1 $T=-182440 -197120 0 0 $X=-182870 $Y=-197760
X47652 5 4 3030 3097 6725 DFRQ_5VX1 $T=-182440 -152320 1 0 $X=-182870 $Y=-157440
X47653 5 4 2241 6707 3060 DFRQ_5VX1 $T=-182440 -8960 0 0 $X=-182870 $Y=-9600
X47654 5 4 3071 3094 6691 DFRQ_5VX1 $T=-167320 -215040 0 180 $X=-182310 $Y=-220160
X47655 5 4 2265 6709 6729 DFRQ_5VX1 $T=-181880 -170240 1 0 $X=-182310 $Y=-175360
X47656 5 4 2921 407 3054 DFRQ_5VX1 $T=-181320 8960 1 0 $X=-181750 $Y=3840
X47657 5 4 401 2974 6726 DFRQ_5VX1 $T=-180760 -206080 0 0 $X=-181190 $Y=-206720
X47658 5 4 404 381 425 DFRQ_5VX1 $T=-179080 -268800 0 0 $X=-179510 $Y=-269440
X47659 5 4 2336 3094 3104 DFRQ_5VX1 $T=-177960 -215040 0 0 $X=-178390 $Y=-215680
X47660 5 4 417 381 6731 DFRQ_5VX1 $T=-176840 -241920 1 0 $X=-177270 $Y=-247040
X47661 5 4 418 3094 3095 DFRQ_5VX1 $T=-175160 -232960 0 0 $X=-175590 $Y=-233600
X47662 5 4 419 3097 6736 DFRQ_5VX1 $T=-175160 -134400 1 0 $X=-175590 $Y=-139520
X47663 5 4 2419 6707 3111 DFRQ_5VX1 $T=-175160 -53760 0 0 $X=-175590 $Y=-54400
X47664 5 4 2414 6707 3118 DFRQ_5VX1 $T=-174600 -26880 0 0 $X=-175030 $Y=-27520
X47665 5 4 416 3211 3105 DFRQ_5VX1 $T=-174040 -125440 0 0 $X=-174470 $Y=-126080
X47666 5 4 2424 3099 3115 DFRQ_5VX1 $T=-174040 -89600 0 0 $X=-174470 $Y=-90240
X47667 5 4 3081 6707 2249 DFRQ_5VX1 $T=-174040 -26880 1 0 $X=-174470 $Y=-32000
X47668 5 4 6720 3094 8078 DFRQ_5VX1 $T=-173480 -224000 1 0 $X=-173910 $Y=-229120
X47669 5 4 422 3097 3183 DFRQ_5VX1 $T=-173480 -143360 0 0 $X=-173910 $Y=-144000
X47670 5 4 423 3180 3107 DFRQ_5VX1 $T=-172920 -259840 1 0 $X=-173350 $Y=-264960
X47671 5 4 2381 3099 3098 DFRQ_5VX1 $T=-171800 -98560 0 0 $X=-172230 $Y=-99200
X47672 5 4 2783 3097 3114 DFRQ_5VX1 $T=-168440 -161280 1 0 $X=-168870 $Y=-166400
X47673 5 4 2805 3097 8110 DFRQ_5VX1 $T=-168440 -152320 0 0 $X=-168870 $Y=-152960
X47674 5 4 3048 3094 6744 DFRQ_5VX1 $T=-167320 -206080 1 0 $X=-167750 $Y=-211200
X47675 5 4 2819 6709 3161 DFRQ_5VX1 $T=-165640 -170240 1 0 $X=-166070 $Y=-175360
X47676 5 4 3113 6709 8111 DFRQ_5VX1 $T=-165080 -188160 0 0 $X=-165510 $Y=-188800
X47677 5 4 2438 3094 6765 DFRQ_5VX1 $T=-162840 -232960 1 0 $X=-163270 $Y=-238080
X47678 5 4 3125 6709 6755 DFRQ_5VX1 $T=-162280 -197120 1 0 $X=-162710 $Y=-202240
X47679 5 4 7917 3099 470 DFRQ_5VX1 $T=-156680 -98560 0 0 $X=-157110 $Y=-99200
X47680 5 4 3074 407 3193 DFRQ_5VX1 $T=-156120 0 0 0 $X=-156550 $Y=-640
X47681 5 4 3168 460 437 DFRQ_5VX1 $T=-153320 -268800 1 0 $X=-153750 $Y=-273920
X47682 5 4 6752 3180 2948 DFRQ_5VX1 $T=-152760 -250880 1 0 $X=-153190 $Y=-256000
X47683 5 4 3135 3178 476 DFRQ_5VX1 $T=-152760 -107520 1 0 $X=-153190 $Y=-112640
X47684 5 4 2854 3099 3033 DFRQ_5VX1 $T=-152200 -80640 0 0 $X=-152630 $Y=-81280
X47685 5 4 6767 3178 8077 DFRQ_5VX1 $T=-137080 -98560 0 180 $X=-152070 $Y=-103680
X47686 5 4 3194 3099 3136 DFRQ_5VX1 $T=-137080 -89600 1 180 $X=-152070 $Y=-90240
X47687 5 4 3192 3179 3129 DFRQ_5VX1 $T=-137080 -8960 0 180 $X=-152070 $Y=-14080
X47688 5 4 3195 3184 3132 DFRQ_5VX1 $T=-136520 -53760 1 180 $X=-151510 $Y=-54400
X47689 5 4 3196 6707 3133 DFRQ_5VX1 $T=-136520 -17920 0 180 $X=-151510 $Y=-23040
X47690 5 4 3176 3184 3219 DFRQ_5VX1 $T=-150520 -62720 1 0 $X=-150950 $Y=-67840
X47691 5 4 3204 6707 3147 DFRQ_5VX1 $T=-135960 -35840 1 180 $X=-150950 $Y=-36480
X47692 5 4 2386 3184 2831 DFRQ_5VX1 $T=-149960 -44800 1 0 $X=-150390 $Y=-49920
X47693 5 4 3205 407 3130 DFRQ_5VX1 $T=-134840 8960 1 180 $X=-149830 $Y=8320
X47694 5 4 3208 3184 3155 DFRQ_5VX1 $T=-134280 -71680 1 180 $X=-149270 $Y=-72320
X47695 5 4 3840 3211 3149 DFRQ_5VX1 $T=-133720 -134400 0 180 $X=-148710 $Y=-139520
X47696 5 4 462 3197 481 DFRQ_5VX1 $T=-147720 -215040 1 0 $X=-148150 $Y=-220160
X47697 5 4 464 6709 491 DFRQ_5VX1 $T=-147720 -197120 1 0 $X=-148150 $Y=-202240
X47698 5 4 3141 3211 486 DFRQ_5VX1 $T=-147720 -125440 1 0 $X=-148150 $Y=-130560
X47699 5 4 3078 6709 489 DFRQ_5VX1 $T=-146600 -161280 1 0 $X=-147030 $Y=-166400
X47700 5 4 466 3211 484 DFRQ_5VX1 $T=-146040 -152320 0 0 $X=-146470 $Y=-152960
X47701 5 4 3229 3211 3153 DFRQ_5VX1 $T=-130360 -143360 0 180 $X=-145350 $Y=-148480
X47702 5 4 2925 3179 6789 DFRQ_5VX1 $T=-144360 0 1 0 $X=-144790 $Y=-5120
X47703 5 4 473 3226 497 DFRQ_5VX1 $T=-142680 -188160 0 0 $X=-143110 $Y=-188800
X47704 5 4 3244 3226 3171 DFRQ_5VX1 $T=-127000 -179200 0 180 $X=-141990 $Y=-184320
X47705 5 4 3248 3099 3202 DFRQ_5VX1 $T=-125880 -80640 0 180 $X=-140870 $Y=-85760
X47706 5 4 3260 3197 3216 DFRQ_5VX1 $T=-124200 -232960 0 180 $X=-139190 $Y=-238080
X47707 5 4 3267 3226 3199 DFRQ_5VX1 $T=-123640 -161280 1 180 $X=-138630 $Y=-161920
X47708 5 4 495 3178 3227 DFRQ_5VX1 $T=-121960 -116480 0 180 $X=-136950 $Y=-121600
X47709 5 4 3280 3263 6771 DFRQ_5VX1 $T=-120840 -197120 1 180 $X=-135830 $Y=-197760
X47710 5 4 2537 3184 6776 DFRQ_5VX1 $T=-120840 -44800 0 180 $X=-135830 $Y=-49920
X47711 5 4 503 3179 3243 DFRQ_5VX1 $T=-119160 8960 0 180 $X=-134150 $Y=3840
X47712 5 4 6801 3197 3237 DFRQ_5VX1 $T=-118600 -215040 1 180 $X=-133590 $Y=-215680
X47713 5 4 506 3226 3246 DFRQ_5VX1 $T=-116920 -152320 1 180 $X=-131910 $Y=-152960
X47714 5 4 2644 3179 3271 DFRQ_5VX1 $T=-116360 -35840 1 180 $X=-131350 $Y=-36480
X47715 5 4 510 460 488 DFRQ_5VX1 $T=-114120 -268800 0 180 $X=-129110 $Y=-273920
X47716 5 4 3298 3180 3231 DFRQ_5VX1 $T=-114120 -259840 0 180 $X=-129110 $Y=-264960
X47717 5 4 511 3180 6785 DFRQ_5VX1 $T=-114120 -250880 0 180 $X=-129110 $Y=-256000
X47718 5 4 3302 3184 3273 DFRQ_5VX1 $T=-114120 -53760 0 180 $X=-129110 $Y=-58880
X47719 5 4 513 3180 3264 DFRQ_5VX1 $T=-113560 -250880 1 180 $X=-128550 $Y=-251520
X47720 5 4 519 3226 3276 DFRQ_5VX1 $T=-113000 -170240 0 180 $X=-127990 $Y=-175360
X47721 5 4 520 3178 6792 DFRQ_5VX1 $T=-113000 -98560 0 180 $X=-127990 $Y=-103680
X47722 5 4 3306 3178 6796 DFRQ_5VX1 $T=-113000 -71680 0 180 $X=-127990 $Y=-76800
X47723 5 4 3289 3179 6810 DFRQ_5VX1 $T=-127560 -17920 0 0 $X=-127990 $Y=-18560
X47724 5 4 3307 3179 3235 DFRQ_5VX1 $T=-113000 -8960 0 180 $X=-127990 $Y=-14080
X47725 5 4 6800 3197 3293 DFRQ_5VX1 $T=-127000 -241920 0 0 $X=-127430 $Y=-242560
X47726 5 4 501 3197 3299 DFRQ_5VX1 $T=-127000 -215040 1 0 $X=-127430 $Y=-220160
X47727 5 4 3287 3178 6808 DFRQ_5VX1 $T=-127000 -116480 0 0 $X=-127430 $Y=-117120
X47728 5 4 3309 3184 6779 DFRQ_5VX1 $T=-112440 -62720 0 180 $X=-127430 $Y=-67840
X47729 5 4 505 3197 6809 DFRQ_5VX1 $T=-126440 -224000 1 0 $X=-126870 $Y=-229120
X47730 5 4 528 3263 3278 DFRQ_5VX1 $T=-111880 -197120 0 180 $X=-126870 $Y=-202240
X47731 5 4 529 3226 3279 DFRQ_5VX1 $T=-111880 -161280 0 180 $X=-126870 $Y=-166400
X47732 5 4 521 3296 6791 DFRQ_5VX1 $T=-111880 -134400 1 180 $X=-126870 $Y=-135040
X47733 5 4 3379 3099 3277 DFRQ_5VX1 $T=-111880 -89600 1 180 $X=-126870 $Y=-90240
X47734 5 4 3313 3184 6797 DFRQ_5VX1 $T=-111880 -44800 1 180 $X=-126870 $Y=-45440
X47735 5 4 3352 3263 8113 DFRQ_5VX1 $T=-83320 -206080 1 180 $X=-98310 $Y=-206720
X47736 5 4 3345 3263 8116 DFRQ_5VX1 $T=-83320 -170240 1 180 $X=-98310 $Y=-170880
X47737 5 4 6842 3296 8112 DFRQ_5VX1 $T=-83320 -134400 0 180 $X=-98310 $Y=-139520
X47738 5 4 3344 3263 8114 DFRQ_5VX1 $T=-82760 -188160 1 180 $X=-97750 $Y=-188800
X47739 5 4 3362 3296 8115 DFRQ_5VX1 $T=-82200 -152320 1 180 $X=-97190 $Y=-152960
X47740 5 4 3360 3296 6822 DFRQ_5VX1 $T=-81080 -98560 0 180 $X=-96070 $Y=-103680
X47741 5 4 3831 3296 3187 DFRQ_5VX1 $T=-71000 -116480 1 180 $X=-85990 $Y=-117120
X47742 5 4 3254 714 724 DFRQ_5VX1 $T=-13880 -268800 1 0 $X=-14310 $Y=-273920
X47743 5 4 733 3814 704 DFRQ_5VX1 $T=5720 -224000 0 180 $X=-9270 $Y=-229120
X47744 5 4 3191 714 740 DFRQ_5VX1 $T=-8280 -250880 1 0 $X=-8710 $Y=-256000
X47745 5 4 3801 3814 7022 DFRQ_5VX1 $T=-6040 -241920 0 0 $X=-6470 $Y=-242560
X47746 5 4 3850 714 3240 DFRQ_5VX1 $T=13000 -259840 1 180 $X=-1990 $Y=-260480
X47747 5 4 7026 3814 718 DFRQ_5VX1 $T=13560 -197120 0 180 $X=-1430 $Y=-202240
X47748 5 4 3853 3966 3809 DFRQ_5VX1 $T=13560 -161280 0 180 $X=-1430 $Y=-166400
X47749 5 4 3855 3814 3769 DFRQ_5VX1 $T=14120 -206080 0 180 $X=-870 $Y=-211200
X47750 5 4 3461 3966 3807 DFRQ_5VX1 $T=14120 -188160 1 180 $X=-870 $Y=-188800
X47751 5 4 7027 3966 721 DFRQ_5VX1 $T=14120 -170240 0 180 $X=-870 $Y=-175360
X47752 5 4 7018 3814 3815 DFRQ_5VX1 $T=120 -215040 0 0 $X=-310 $Y=-215680
X47753 5 4 764 3966 3773 DFRQ_5VX1 $T=19160 -143360 0 180 $X=4170 $Y=-148480
X47754 5 4 3863 7035 7046 DFRQ_5VX1 $T=6840 -98560 0 0 $X=6410 $Y=-99200
X47755 5 4 7038 7035 3851 DFRQ_5VX1 $T=23080 -125440 0 180 $X=8090 $Y=-130560
X47756 5 4 759 7035 3854 DFRQ_5VX1 $T=8520 -107520 1 0 $X=8090 $Y=-112640
X47757 5 4 774 3814 7028 DFRQ_5VX1 $T=23640 -250880 1 180 $X=8650 $Y=-251520
X47758 5 4 7033 3966 7057 DFRQ_5VX1 $T=10200 -152320 1 0 $X=9770 $Y=-157440
X47759 5 4 3885 7035 3813 DFRQ_5VX1 $T=10760 -80640 0 0 $X=10330 $Y=-81280
X47760 5 4 4077 714 7031 DFRQ_5VX1 $T=26440 -259840 0 180 $X=11450 $Y=-264960
X47761 5 4 7049 3966 3844 DFRQ_5VX1 $T=27000 -134400 0 180 $X=12010 $Y=-139520
X47762 5 4 3790 7035 7036 DFRQ_5VX1 $T=30360 -116480 0 180 $X=15370 $Y=-121600
X47763 5 4 3969 7063 780 DFRQ_5VX1 $T=35400 -161280 1 180 $X=20410 $Y=-161920
X47764 5 4 808 7063 3950 DFRQ_5VX1 $T=48280 -188160 0 180 $X=33290 $Y=-193280
X47765 5 4 823 4076 4048 DFRQ_5VX1 $T=59480 -17920 1 180 $X=44490 $Y=-18560
X47766 5 4 4071 4076 4107 DFRQ_5VX1 $T=46040 -8960 0 0 $X=45610 $Y=-9600
X47767 5 4 826 4076 4060 DFRQ_5VX1 $T=61720 8960 1 180 $X=46730 $Y=8320
X47768 5 4 4130 4191 7126 DFRQ_5VX1 $T=51640 -35840 0 0 $X=51210 $Y=-36480
X47769 5 4 4112 4191 4146 DFRQ_5VX1 $T=52760 -44800 0 0 $X=52330 $Y=-45440
X47770 5 4 839 7116 3927 DFRQ_5VX1 $T=68440 -241920 1 180 $X=53450 $Y=-242560
X47771 5 4 7112 7116 4123 DFRQ_5VX1 $T=55000 -250880 0 0 $X=54570 $Y=-251520
X47772 5 4 3992 4133 4044 DFRQ_5VX1 $T=70120 -134400 1 180 $X=55130 $Y=-135040
X47773 5 4 4122 7119 4157 DFRQ_5VX1 $T=55560 -71680 1 0 $X=55130 $Y=-76800
X47774 5 4 4125 4133 4014 DFRQ_5VX1 $T=56120 -98560 1 0 $X=55690 $Y=-103680
X47775 5 4 4129 7119 4070 DFRQ_5VX1 $T=56680 -62720 1 0 $X=56250 $Y=-67840
X47776 5 4 4134 7063 4144 DFRQ_5VX1 $T=58360 -188160 0 0 $X=57930 $Y=-188800
X47777 5 4 7132 7116 7113 DFRQ_5VX1 $T=74600 -224000 0 180 $X=59610 $Y=-229120
X47778 5 4 7960 7063 4124 DFRQ_5VX1 $T=74600 -161280 0 180 $X=59610 $Y=-166400
X47779 5 4 7133 7116 4089 DFRQ_5VX1 $T=75720 -197120 0 180 $X=60730 $Y=-202240
X47780 5 4 876 7116 4116 DFRQ_5VX1 $T=76280 -215040 0 180 $X=61290 $Y=-220160
X47781 5 4 877 4076 7123 DFRQ_5VX1 $T=77400 0 0 180 $X=62410 $Y=-5120
X47782 5 4 878 7063 3933 DFRQ_5VX1 $T=77960 -170240 0 180 $X=62970 $Y=-175360
X47783 5 4 849 4076 3915 DFRQ_5VX1 $T=63400 8960 0 0 $X=62970 $Y=8320
X47784 5 4 863 4076 3451 DFRQ_5VX1 $T=65640 -8960 1 0 $X=65210 $Y=-14080
X47785 5 4 7136 4191 888 DFRQ_5VX1 $T=66200 -35840 0 0 $X=65770 $Y=-36480
X47786 5 4 4175 7119 4251 DFRQ_5VX1 $T=70120 -80640 0 0 $X=69690 $Y=-81280
X47787 5 4 4177 4191 4229 DFRQ_5VX1 $T=70120 -53760 0 0 $X=69690 $Y=-54400
X47788 5 4 4179 4191 4195 DFRQ_5VX1 $T=70120 -17920 1 0 $X=69690 $Y=-23040
X47789 5 4 3652 4133 4193 DFRQ_5VX1 $T=70680 -98560 1 0 $X=70250 $Y=-103680
X47790 5 4 4183 7119 4225 DFRQ_5VX1 $T=71240 -62720 1 0 $X=70810 $Y=-67840
X47791 5 4 3817 4191 7140 DFRQ_5VX1 $T=86920 -44800 0 180 $X=71930 $Y=-49920
X47792 5 4 4187 4133 4202 DFRQ_5VX1 $T=72920 -116480 0 0 $X=72490 $Y=-117120
X47793 5 4 4219 4133 4110 DFRQ_5VX1 $T=88040 -125440 0 180 $X=73050 $Y=-130560
X47794 5 4 7134 4133 4211 DFRQ_5VX1 $T=74040 -134400 1 0 $X=73610 $Y=-139520
X47795 5 4 4163 7119 4156 DFRQ_5VX1 $T=74040 -89600 1 0 $X=73610 $Y=-94720
X47796 5 4 4103 4076 3672 DFRQ_5VX1 $T=74040 -8960 0 0 $X=73610 $Y=-9600
X47797 5 4 3899 7119 5245 DFRQ_5VX1 $T=76840 -98560 0 0 $X=76410 $Y=-99200
X47798 5 4 988 7236 4559 DFRQ_5VX1 $T=151880 -224000 0 0 $X=151450 $Y=-224640
X47799 5 4 4518 4580 4303 DFRQ_5VX1 $T=151880 -161280 0 0 $X=151450 $Y=-161920
X47800 5 4 989 4545 4563 DFRQ_5VX1 $T=151880 -125440 1 0 $X=151450 $Y=-130560
X47801 5 4 4520 4545 4564 DFRQ_5VX1 $T=151880 -116480 1 0 $X=151450 $Y=-121600
X47802 5 4 7224 4533 8117 DFRQ_5VX1 $T=151880 -80640 0 0 $X=151450 $Y=-81280
X47803 5 4 7228 4534 3873 DFRQ_5VX1 $T=151880 -53760 0 0 $X=151450 $Y=-54400
X47804 5 4 4521 4534 8118 DFRQ_5VX1 $T=151880 -44800 0 0 $X=151450 $Y=-45440
X47805 5 4 4548 4534 4501 DFRQ_5VX1 $T=166440 -35840 1 180 $X=151450 $Y=-36480
X47806 5 4 4522 4535 4556 DFRQ_5VX1 $T=151880 -17920 1 0 $X=151450 $Y=-23040
X47807 5 4 7964 7236 4573 DFRQ_5VX1 $T=152440 -232960 0 0 $X=152010 $Y=-233600
X47808 5 4 4523 7236 4569 DFRQ_5VX1 $T=152440 -215040 0 0 $X=152010 $Y=-215680
X47809 5 4 7230 4580 7250 DFRQ_5VX1 $T=152440 -143360 0 0 $X=152010 $Y=-144000
X47810 5 4 992 999 8119 DFRQ_5VX1 $T=153000 -250880 0 0 $X=152570 $Y=-251520
X47811 5 4 7233 4544 7254 DFRQ_5VX1 $T=155240 -188160 0 0 $X=154810 $Y=-188800
X47812 5 4 4667 4545 4524 DFRQ_5VX1 $T=170360 -107520 0 180 $X=155370 $Y=-112640
X47813 5 4 7240 4533 7260 DFRQ_5VX1 $T=158040 -98560 1 0 $X=157610 $Y=-103680
X47814 5 4 1015 999 4588 DFRQ_5VX1 $T=159720 -259840 1 0 $X=159290 $Y=-264960
X47815 5 4 4557 4535 4596 DFRQ_5VX1 $T=160840 -8960 0 0 $X=160410 $Y=-9600
X47816 5 4 4584 4608 4546 DFRQ_5VX1 $T=175960 -71680 1 180 $X=160970 $Y=-72320
X47817 5 4 1024 4575 1049 DFRQ_5VX1 $T=161960 -206080 0 0 $X=161530 $Y=-206720
X47818 5 4 4560 4533 4599 DFRQ_5VX1 $T=161960 -89600 0 0 $X=161530 $Y=-90240
X47819 5 4 4562 4544 7245 DFRQ_5VX1 $T=178200 -170240 1 180 $X=163210 $Y=-170880
X47820 5 4 1056 999 7246 DFRQ_5VX1 $T=178760 -250880 0 180 $X=163770 $Y=-256000
X47821 5 4 1031 4544 4374 DFRQ_5VX1 $T=164200 -179200 1 0 $X=163770 $Y=-184320
X47822 5 4 4612 4580 4328 DFRQ_5VX1 $T=178760 -143360 0 180 $X=163770 $Y=-148480
X47823 5 4 4571 4545 4607 DFRQ_5VX1 $T=164760 -125440 0 0 $X=164330 $Y=-126080
X47824 5 4 4397 4535 4637 DFRQ_5VX1 $T=164760 -26880 1 0 $X=164330 $Y=-32000
X47825 5 4 4591 4535 4543 DFRQ_5VX1 $T=179320 -8960 0 180 $X=164330 $Y=-14080
X47826 5 4 4527 1041 4592 DFRQ_5VX1 $T=165320 0 0 0 $X=164890 $Y=-640
X47827 5 4 1054 4580 1028 DFRQ_5VX1 $T=181000 -161280 1 180 $X=166010 $Y=-161920
X47828 5 4 4600 4534 7251 DFRQ_5VX1 $T=181000 -53760 1 180 $X=166010 $Y=-54400
X47829 5 4 1058 4642 7249 DFRQ_5VX1 $T=181560 -232960 1 180 $X=166570 $Y=-233600
X47830 5 4 1039 4580 4619 DFRQ_5VX1 $T=167000 -143360 0 0 $X=166570 $Y=-144000
X47831 5 4 1044 4544 4606 DFRQ_5VX1 $T=167560 -170240 1 0 $X=167130 $Y=-175360
X47832 5 4 4605 7236 1026 DFRQ_5VX1 $T=182680 -215040 1 180 $X=167690 $Y=-215680
X47833 5 4 4330 4533 4430 DFRQ_5VX1 $T=168120 -71680 1 0 $X=167690 $Y=-76800
X47834 5 4 1061 4535 4576 DFRQ_5VX1 $T=182680 -17920 0 180 $X=167690 $Y=-23040
X47835 5 4 4586 4545 4635 DFRQ_5VX1 $T=168680 -134400 0 0 $X=168250 $Y=-135040
X47836 5 4 4613 4608 4509 DFRQ_5VX1 $T=183800 -62720 1 180 $X=168810 $Y=-63360
X47837 5 4 1068 4575 1043 DFRQ_5VX1 $T=184920 -188160 1 180 $X=169930 $Y=-188800
X47838 5 4 4630 4608 3941 DFRQ_5VX1 $T=186040 -80640 1 180 $X=171050 $Y=-81280
X47839 5 4 3917 4545 4644 DFRQ_5VX1 $T=172040 -116480 0 0 $X=171610 $Y=-117120
X47840 5 4 4601 4534 4648 DFRQ_5VX1 $T=172040 -35840 0 0 $X=171610 $Y=-36480
X47841 5 4 4595 4575 4649 DFRQ_5VX1 $T=172600 -206080 1 0 $X=172170 $Y=-211200
X47842 5 4 1077 4533 4337 DFRQ_5VX1 $T=188280 -98560 1 180 $X=173290 $Y=-99200
X47843 5 4 7270 999 1055 DFRQ_5VX1 $T=188840 -259840 1 180 $X=173850 $Y=-260480
X47844 5 4 1070 7236 4659 DFRQ_5VX1 $T=174840 -224000 0 0 $X=174410 $Y=-224640
X47845 5 4 1086 4575 4602 DFRQ_5VX1 $T=191080 -188160 0 180 $X=176090 $Y=-193280
X47846 5 4 4623 4608 4262 DFRQ_5VX1 $T=176520 -53760 1 0 $X=176090 $Y=-58880
X47847 5 4 4647 4575 3874 DFRQ_5VX1 $T=191640 -206080 1 180 $X=176650 $Y=-206720
X47848 5 4 1084 4642 1063 DFRQ_5VX1 $T=192760 -250880 1 180 $X=177770 $Y=-251520
X47849 5 4 4651 4534 4614 DFRQ_5VX1 $T=192760 -35840 0 180 $X=177770 $Y=-40960
X47850 5 4 4655 4642 1069 DFRQ_5VX1 $T=193320 -241920 0 180 $X=178330 $Y=-247040
X47851 5 4 1073 4642 4673 DFRQ_5VX1 $T=178760 -232960 1 0 $X=178330 $Y=-238080
X47852 5 4 1074 4642 1093 DFRQ_5VX1 $T=178760 -215040 1 0 $X=178330 $Y=-220160
X47853 5 4 1094 4645 4626 DFRQ_5VX1 $T=193880 -8960 1 180 $X=178890 $Y=-9600
X47854 5 4 1078 4721 4638 DFRQ_5VX1 $T=180440 -143360 1 0 $X=180010 $Y=-148480
X47855 5 4 4672 4645 4105 DFRQ_5VX1 $T=195000 -17920 1 180 $X=180010 $Y=-18560
X47856 5 4 4670 4645 3500 DFRQ_5VX1 $T=195000 -8960 0 180 $X=180010 $Y=-14080
X47857 5 4 4668 4721 3700 DFRQ_5VX1 $T=195560 -161280 1 180 $X=180570 $Y=-161920
X47858 5 4 4675 4658 4629 DFRQ_5VX1 $T=196120 -107520 0 180 $X=181130 $Y=-112640
X47859 5 4 4676 1041 3845 DFRQ_5VX1 $T=196120 8960 1 180 $X=181130 $Y=8320
X47860 5 4 3816 4544 4688 DFRQ_5VX1 $T=182120 -170240 1 0 $X=181690 $Y=-175360
X47861 5 4 4677 4608 4733 DFRQ_5VX1 $T=197240 -71680 0 180 $X=182250 $Y=-76800
X47862 5 4 4694 4608 4428 DFRQ_5VX1 $T=200600 -80640 1 180 $X=185610 $Y=-81280
X47863 5 4 4686 7294 4738 DFRQ_5VX1 $T=191080 -44800 1 0 $X=190650 $Y=-49920
X47864 5 4 4720 4806 4663 DFRQ_5VX1 $T=206200 -179200 1 180 $X=191210 $Y=-179840
X47865 5 4 1108 4806 1120 DFRQ_5VX1 $T=192760 -197120 1 0 $X=192330 $Y=-202240
X47866 5 4 4701 4645 5184 DFRQ_5VX1 $T=193880 -8960 0 0 $X=193450 $Y=-9600
X47867 5 4 1104 4721 1125 DFRQ_5VX1 $T=195000 -170240 0 0 $X=194570 $Y=-170880
X47868 5 4 1107 4806 1132 DFRQ_5VX1 $T=195560 -188160 0 0 $X=195130 $Y=-188800
X47869 5 4 4741 4761 4692 DFRQ_5VX1 $T=210120 -71680 1 180 $X=195130 $Y=-72320
X47870 5 4 4709 1110 4759 DFRQ_5VX1 $T=195560 8960 1 0 $X=195130 $Y=3840
X47871 5 4 4744 4658 4691 DFRQ_5VX1 $T=210680 -125440 1 180 $X=195690 $Y=-126080
X47872 5 4 7313 4721 4585 DFRQ_5VX1 $T=212920 -143360 1 180 $X=197930 $Y=-144000
X47873 5 4 4752 4658 4707 DFRQ_5VX1 $T=212920 -107520 1 180 $X=197930 $Y=-108160
X47874 5 4 1112 4721 1134 DFRQ_5VX1 $T=199480 -161280 1 0 $X=199050 $Y=-166400
X47875 5 4 4757 4658 4714 DFRQ_5VX1 $T=214040 -98560 0 180 $X=199050 $Y=-103680
X47876 5 4 4758 4645 4715 DFRQ_5VX1 $T=214040 0 0 180 $X=199050 $Y=-5120
X47877 5 4 4732 4761 4791 DFRQ_5VX1 $T=200600 -80640 0 0 $X=200170 $Y=-81280
X47878 5 4 1122 4645 4794 DFRQ_5VX1 $T=201160 -17920 0 0 $X=200730 $Y=-18560
X47879 5 4 4746 4761 4792 DFRQ_5VX1 $T=202280 -62720 1 0 $X=201850 $Y=-67840
X47880 5 4 4778 4760 4728 DFRQ_5VX1 $T=217960 -152320 1 180 $X=202970 $Y=-152960
X47881 5 4 5388 7294 4735 DFRQ_5VX1 $T=217960 -26880 0 180 $X=202970 $Y=-32000
X47882 5 4 4800 7294 7309 DFRQ_5VX1 $T=220200 -44800 1 180 $X=205210 $Y=-45440
X47883 5 4 4807 4806 4749 DFRQ_5VX1 $T=221320 -179200 1 180 $X=206330 $Y=-179840
X47884 5 4 4947 7294 4726 DFRQ_5VX1 $T=221320 -44800 0 180 $X=206330 $Y=-49920
X47885 5 4 4820 4658 4764 DFRQ_5VX1 $T=224120 -116480 1 180 $X=209130 $Y=-117120
X47886 5 4 4827 4806 7966 DFRQ_5VX1 $T=225240 -197120 1 180 $X=210250 $Y=-197760
X47887 5 4 4828 4760 4763 DFRQ_5VX1 $T=225240 -125440 1 180 $X=210250 $Y=-126080
X47888 5 4 4836 4761 4785 DFRQ_5VX1 $T=227480 -98560 1 180 $X=212490 $Y=-99200
X47889 5 4 4839 7294 4768 DFRQ_5VX1 $T=227480 -26880 1 180 $X=212490 $Y=-27520
X47890 5 4 1149 4760 4724 DFRQ_5VX1 $T=228600 -134400 0 180 $X=213610 $Y=-139520
X47891 5 4 4847 1110 1137 DFRQ_5VX1 $T=228600 0 1 180 $X=213610 $Y=-640
X47892 5 4 4862 1110 1500 DFRQ_5VX1 $T=230280 -8960 0 180 $X=215290 $Y=-14080
X47893 5 4 4864 4760 8120 DFRQ_5VX1 $T=230840 -170240 1 180 $X=215850 $Y=-170880
X47894 5 4 4871 4761 7322 DFRQ_5VX1 $T=231400 -62720 0 180 $X=216410 $Y=-67840
X47895 5 4 7335 4761 4646 DFRQ_5VX1 $T=233640 -80640 0 180 $X=218650 $Y=-85760
X47896 5 4 5050 4760 4818 DFRQ_5VX1 $T=236440 -161280 0 180 $X=221450 $Y=-166400
X47897 5 4 4914 5055 4657 DFRQ_5VX1 $T=240920 -206080 0 180 $X=225930 $Y=-211200
X47898 5 4 7930 5055 4329 DFRQ_5VX1 $T=276200 -188160 1 180 $X=261210 $Y=-188800
X47899 5 4 5071 5081 4830 DFRQ_5VX1 $T=277320 -152320 0 180 $X=262330 $Y=-157440
X47900 5 4 5087 5055 4718 DFRQ_5VX1 $T=277880 -206080 0 180 $X=262890 $Y=-211200
X47901 5 4 5072 5081 4982 DFRQ_5VX1 $T=277880 -134400 0 180 $X=262890 $Y=-139520
X47902 5 4 5102 5055 7390 DFRQ_5VX1 $T=279000 -215040 0 180 $X=264010 $Y=-220160
X47903 5 4 5109 5081 5013 DFRQ_5VX1 $T=280680 -125440 0 180 $X=265690 $Y=-130560
X47904 5 4 5110 5081 4995 DFRQ_5VX1 $T=283480 -107520 1 180 $X=268490 $Y=-108160
X47905 5 4 5297 5081 5182 DFRQ_5VX1 $T=317640 -152320 0 180 $X=302650 $Y=-157440
X47906 5 4 5449 5520 1284 DFRQ_5VX1 $T=355160 0 0 180 $X=340170 $Y=-5120
X47907 5 4 5470 5520 5467 DFRQ_5VX1 $T=360200 -35840 1 180 $X=345210 $Y=-36480
X47908 5 4 6219 1295 5432 DFRQ_5VX1 $T=360200 8960 1 180 $X=345210 $Y=8320
X47909 5 4 5463 5531 5519 DFRQ_5VX1 $T=349000 -107520 1 0 $X=348570 $Y=-112640
X47910 5 4 5468 7599 7596 DFRQ_5VX1 $T=350680 -161280 0 0 $X=350250 $Y=-161920
X47911 5 4 1300 5569 5525 DFRQ_5VX1 $T=351800 -224000 1 0 $X=351370 $Y=-229120
X47912 5 4 5481 5504 5554 DFRQ_5VX1 $T=354040 -188160 0 0 $X=353610 $Y=-188800
X47913 5 4 5483 5504 5551 DFRQ_5VX1 $T=354600 -197120 0 0 $X=354170 $Y=-197760
X47914 5 4 5518 5504 5465 DFRQ_5VX1 $T=369160 -170240 1 180 $X=354170 $Y=-170880
X47915 5 4 1527 5539 7568 DFRQ_5VX1 $T=369720 -44800 0 180 $X=354730 $Y=-49920
X47916 5 4 5521 5520 7572 DFRQ_5VX1 $T=369720 0 0 180 $X=354730 $Y=-5120
X47917 5 4 5490 5520 5527 DFRQ_5VX1 $T=356280 -26880 1 0 $X=355850 $Y=-32000
X47918 5 4 5532 5600 7977 DFRQ_5VX1 $T=371400 -89600 0 180 $X=356410 $Y=-94720
X47919 5 4 5507 5504 7612 DFRQ_5VX1 $T=358520 -179200 1 0 $X=358090 $Y=-184320
X47920 5 4 5508 7599 7610 DFRQ_5VX1 $T=358520 -134400 1 0 $X=358090 $Y=-139520
X47921 5 4 5509 5531 7613 DFRQ_5VX1 $T=358520 -98560 1 0 $X=358090 $Y=-103680
X47922 5 4 7605 5600 5488 DFRQ_5VX1 $T=373080 -71680 1 180 $X=358090 $Y=-72320
X47923 5 4 7604 5520 7575 DFRQ_5VX1 $T=373080 -17920 1 180 $X=358090 $Y=-18560
X47924 5 4 5546 5531 5499 DFRQ_5VX1 $T=374760 -116480 1 180 $X=359770 $Y=-117120
X47925 5 4 5553 5539 7586 DFRQ_5VX1 $T=375880 -53760 0 180 $X=360890 $Y=-58880
X47926 5 4 7598 7599 5583 DFRQ_5VX1 $T=361880 -152320 0 0 $X=361450 $Y=-152960
X47927 5 4 7615 5600 7582 DFRQ_5VX1 $T=376440 -80640 1 180 $X=361450 $Y=-81280
X47928 5 4 5558 5531 5487 DFRQ_5VX1 $T=377560 -134400 1 180 $X=362570 $Y=-135040
X47929 5 4 5534 5539 5584 DFRQ_5VX1 $T=363000 -53760 0 0 $X=362570 $Y=-54400
X47930 5 4 1318 1316 7591 DFRQ_5VX1 $T=379240 -268800 0 180 $X=364250 $Y=-273920
X47931 5 4 5567 5600 7600 DFRQ_5VX1 $T=379240 -80640 0 180 $X=364250 $Y=-85760
X47932 5 4 7620 5539 5501 DFRQ_5VX1 $T=379240 -44800 1 180 $X=364250 $Y=-45440
X47933 5 4 5568 5520 5523 DFRQ_5VX1 $T=379240 -17920 0 180 $X=364250 $Y=-23040
X47934 5 4 5575 5531 7978 DFRQ_5VX1 $T=380360 -125440 1 180 $X=365370 $Y=-126080
X47935 5 4 7624 1316 5529 DFRQ_5VX1 $T=381480 -250880 1 180 $X=366490 $Y=-251520
X47936 5 4 5582 5569 7595 DFRQ_5VX1 $T=381480 -215040 0 180 $X=366490 $Y=-220160
X47937 5 4 5587 1316 7594 DFRQ_5VX1 $T=382600 -259840 0 180 $X=367610 $Y=-264960
X47938 5 4 5588 5569 5542 DFRQ_5VX1 $T=383160 -241920 0 180 $X=368170 $Y=-247040
X47939 5 4 5595 5504 1311 DFRQ_5VX1 $T=383160 -161280 0 180 $X=368170 $Y=-166400
X47940 5 4 7627 5569 7608 DFRQ_5VX1 $T=383720 -206080 0 180 $X=368730 $Y=-211200
X47941 5 4 5603 5539 7619 DFRQ_5VX1 $T=385400 -35840 1 180 $X=370410 $Y=-36480
X47942 5 4 7621 5504 5592 DFRQ_5VX1 $T=371400 -179200 0 0 $X=370970 $Y=-179840
X47943 5 4 7629 5569 7603 DFRQ_5VX1 $T=386520 -224000 1 180 $X=371530 $Y=-224640
X47944 5 4 5589 5569 7616 DFRQ_5VX1 $T=387080 -232960 0 180 $X=372090 $Y=-238080
X47945 5 4 5614 5531 5561 DFRQ_5VX1 $T=387080 -107520 0 180 $X=372090 $Y=-112640
X47946 5 4 5616 7599 5563 DFRQ_5VX1 $T=387640 -134400 0 180 $X=372650 $Y=-139520
X47947 5 4 5580 7599 7636 DFRQ_5VX1 $T=373080 -125440 1 0 $X=372650 $Y=-130560
X47948 5 4 5617 5531 5564 DFRQ_5VX1 $T=387640 -107520 1 180 $X=372650 $Y=-108160
X47949 5 4 5618 5600 7618 DFRQ_5VX1 $T=387640 -89600 1 180 $X=372650 $Y=-90240
X47950 5 4 5619 5539 5566 DFRQ_5VX1 $T=387640 -62720 1 180 $X=372650 $Y=-63360
X47951 5 4 7638 1316 7601 DFRQ_5VX1 $T=388200 -268800 1 180 $X=373210 $Y=-269440
X47952 5 4 5620 5504 5677 DFRQ_5VX1 $T=388200 -188160 0 180 $X=373210 $Y=-193280
X47953 5 4 7634 7599 8121 DFRQ_5VX1 $T=388200 -161280 1 180 $X=373210 $Y=-161920
X47954 5 4 5621 7599 5486 DFRQ_5VX1 $T=388200 -143360 0 180 $X=373210 $Y=-148480
X47955 5 4 5622 5600 5570 DFRQ_5VX1 $T=388200 -71680 0 180 $X=373210 $Y=-76800
X47956 5 4 6133 1424 6102 DFRQ_5VX1 $T=519800 0 0 180 $X=504810 $Y=-5120
X47957 5 4 6200 6171 6115 DFRQ_5VX1 $T=523720 -26880 1 180 $X=508730 $Y=-27520
X47958 5 4 6131 1424 7858 DFRQ_5VX1 $T=524840 8960 0 180 $X=509850 $Y=3840
X47959 5 4 6168 6171 6124 DFRQ_5VX1 $T=526520 -44800 0 180 $X=511530 $Y=-49920
X47960 5 4 6130 6171 7870 DFRQ_5VX1 $T=526520 -8960 0 180 $X=511530 $Y=-14080
X47961 5 4 7897 6195 6141 DFRQ_5VX1 $T=527080 -188160 0 180 $X=512090 $Y=-193280
X47962 5 4 6150 6195 7910 DFRQ_5VX1 $T=515320 -206080 1 0 $X=514890 $Y=-211200
X47963 5 4 6180 6171 7883 DFRQ_5VX1 $T=531560 -62720 1 180 $X=516570 $Y=-63360
X47964 5 4 6140 6171 7884 DFRQ_5VX1 $T=531560 -35840 1 180 $X=516570 $Y=-36480
X47965 5 4 7914 6176 6153 DFRQ_5VX1 $T=533240 -134400 0 180 $X=518250 $Y=-139520
X47966 5 4 6159 6171 7893 DFRQ_5VX1 $T=533240 -53760 1 180 $X=518250 $Y=-54400
X47967 5 4 6191 6176 7894 DFRQ_5VX1 $T=534360 -80640 1 180 $X=519370 $Y=-81280
X47968 5 4 6170 6171 7896 DFRQ_5VX1 $T=534920 -71680 1 180 $X=519930 $Y=-72320
X47969 5 4 6199 6176 7898 DFRQ_5VX1 $T=537160 -116480 1 180 $X=522170 $Y=-117120
X47970 5 4 7906 6195 6194 DFRQ_5VX1 $T=523160 -170240 0 0 $X=522730 $Y=-170880
X47971 5 4 6193 6195 7904 DFRQ_5VX1 $T=539400 -188160 1 180 $X=524410 $Y=-188800
X47972 5 4 6178 6195 6196 DFRQ_5VX1 $T=524840 -152320 0 0 $X=524410 $Y=-152960
X47973 5 4 6169 6176 7903 DFRQ_5VX1 $T=539400 -98560 0 180 $X=524410 $Y=-103680
X47974 5 4 6206 6176 7905 DFRQ_5VX1 $T=539400 -89600 1 180 $X=524410 $Y=-90240
X47975 5 4 6207 6195 1526 DFRQ_5VX1 $T=539960 -161280 1 180 $X=524970 $Y=-161920
X47976 5 4 6208 6176 6167 DFRQ_5VX1 $T=539960 -98560 1 180 $X=524970 $Y=-99200
X47977 5 4 7912 6195 7899 DFRQ_5VX1 $T=540520 -170240 0 180 $X=525530 $Y=-175360
X47978 5 4 6226 6176 7908 DFRQ_5VX1 $T=540520 -125440 1 180 $X=525530 $Y=-126080
X47979 5 4 6210 6176 8106 DFRQ_5VX1 $T=541640 -134400 1 180 $X=526650 $Y=-135040
X47980 5 4 6780 3228 IN_5VX0 $T=-133160 -35840 1 180 $X=-135270 $Y=-36480
X47981 5 4 6904 3514 623 3515 MU2_5VX1 $T=-56440 -80640 1 180 $X=-63590 $Y=-81280
X47982 5 4 6938 1484 595 663 MU2_5VX1 $T=-41880 -268800 0 0 $X=-42310 $Y=-269440
X47983 5 4 7001 3646 632 717 MU2_5VX1 $T=-8280 -268800 0 0 $X=-8710 $Y=-269440
X47984 5 4 3251 6782 3213 3258 6774 OA22_5VX1 $T=-130920 -98560 0 180 $X=-137510 $Y=-103680
X47985 5 4 542 7924 3376 NA2_5VX0 $T=-96200 -26880 0 0 $X=-96630 $Y=-27520
D0 4 5 p_dnw5 AREA=6.09229e-09 PJ=0.00246355 perimeter=0.00246355 $X=-611830 $Y=-266820 $dt=1
D1 4 5 p_dnw5 AREA=6.07841e-09 PJ=0.00246553 perimeter=0.00246553 $X=-611830 $Y=-257860 $dt=1
D2 4 5 p_dnw5 AREA=6.07024e-09 PJ=0.00246779 perimeter=0.00246779 $X=-611830 $Y=-248900 $dt=1
D3 4 5 p_dnw5 AREA=6.07862e-09 PJ=0.00246438 perimeter=0.00246438 $X=-611830 $Y=-239940 $dt=1
D4 4 5 p_dnw5 AREA=6.07737e-09 PJ=0.0024642 perimeter=0.0024642 $X=-611830 $Y=-230980 $dt=1
D5 4 5 p_dnw5 AREA=6.08764e-09 PJ=0.00246308 perimeter=0.00246308 $X=-611830 $Y=-222020 $dt=1
D6 4 5 p_dnw5 AREA=6.07454e-09 PJ=0.00246553 perimeter=0.00246553 $X=-611830 $Y=-213060 $dt=1
D7 4 5 p_dnw5 AREA=6.07002e-09 PJ=0.00246637 perimeter=0.00246637 $X=-611830 $Y=-204100 $dt=1
D8 4 5 p_dnw5 AREA=6.07289e-09 PJ=0.00246658 perimeter=0.00246658 $X=-611830 $Y=-195140 $dt=1
D9 4 5 p_dnw5 AREA=6.0668e-09 PJ=0.00246796 perimeter=0.00246796 $X=-611830 $Y=-186180 $dt=1
D10 4 5 p_dnw5 AREA=6.07735e-09 PJ=0.00246356 perimeter=0.00246356 $X=-611830 $Y=-177220 $dt=1
D11 4 5 p_dnw5 AREA=6.07142e-09 PJ=0.00246756 perimeter=0.00246756 $X=-611830 $Y=-168260 $dt=1
D12 4 5 p_dnw5 AREA=6.06493e-09 PJ=0.00246764 perimeter=0.00246764 $X=-611830 $Y=-159300 $dt=1
D13 4 5 p_dnw5 AREA=6.06527e-09 PJ=0.00246582 perimeter=0.00246582 $X=-611830 $Y=-150340 $dt=1
D14 4 5 p_dnw5 AREA=6.06316e-09 PJ=0.00246887 perimeter=0.00246887 $X=-611830 $Y=-141380 $dt=1
D15 4 5 p_dnw5 AREA=6.06833e-09 PJ=0.00246888 perimeter=0.00246888 $X=-611830 $Y=-132420 $dt=1
D16 4 5 p_dnw5 AREA=6.07789e-09 PJ=0.00246652 perimeter=0.00246652 $X=-611830 $Y=-123460 $dt=1
D17 4 5 p_dnw5 AREA=6.05951e-09 PJ=0.00246883 perimeter=0.00246883 $X=-611830 $Y=-114500 $dt=1
D18 4 5 p_dnw5 AREA=6.06842e-09 PJ=0.00246802 perimeter=0.00246802 $X=-611830 $Y=-105540 $dt=1
D19 4 5 p_dnw5 AREA=6.05541e-09 PJ=0.0024678 perimeter=0.0024678 $X=-611830 $Y=-96580 $dt=1
D20 4 5 p_dnw5 AREA=6.07515e-09 PJ=0.00246695 perimeter=0.00246695 $X=-611830 $Y=-87620 $dt=1
D21 4 5 p_dnw5 AREA=6.07816e-09 PJ=0.00246628 perimeter=0.00246628 $X=-611830 $Y=-78660 $dt=1
D22 4 5 p_dnw5 AREA=6.0726e-09 PJ=0.00246808 perimeter=0.00246808 $X=-611830 $Y=-69700 $dt=1
D23 4 5 p_dnw5 AREA=6.05938e-09 PJ=0.00246961 perimeter=0.00246961 $X=-611830 $Y=-60740 $dt=1
D24 4 5 p_dnw5 AREA=6.06153e-09 PJ=0.00246838 perimeter=0.00246838 $X=-611830 $Y=-51780 $dt=1
D25 4 5 p_dnw5 AREA=6.0724e-09 PJ=0.00246573 perimeter=0.00246573 $X=-611830 $Y=-42820 $dt=1
D26 4 5 p_dnw5 AREA=6.0652e-09 PJ=0.00246581 perimeter=0.00246581 $X=-611830 $Y=-33860 $dt=1
D27 4 5 p_dnw5 AREA=6.07418e-09 PJ=0.0024666 perimeter=0.0024666 $X=-611830 $Y=-24900 $dt=1
D28 4 5 p_dnw5 AREA=6.07623e-09 PJ=0.00246421 perimeter=0.00246421 $X=-611830 $Y=-15940 $dt=1
D29 4 5 p_dnw5 AREA=6.07119e-09 PJ=0.00246626 perimeter=0.00246626 $X=-611830 $Y=-6980 $dt=1
D30 4 5 p_dnw5 AREA=6.06406e-09 PJ=0.00246704 perimeter=0.00246704 $X=-611830 $Y=1980 $dt=1
.ends MASCO__P2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX6                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX6 vdd5! gnd! A Q
** N=5 EP=4 FDC=16
M0 5 A gnd! gnd! ne5 L=5e-07 W=7.3e-07 AD=1.971e-13 AS=5.938e-13 PD=1.27e-06 PS=3.52e-06 $X=660 $Y=820 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=7.3e-07 AD=7.04808e-13 AS=1.971e-13 PD=2.39993e-06 PS=1.27e-06 $X=1700 $Y=820 $dt=2
M2 Q 5 gnd! gnd! ne5 L=5e-07 W=8e-07 AD=2.16e-13 AS=7.72392e-13 PD=1.34e-06 PS=2.63007e-06 $X=3475 $Y=750 $dt=2
M3 gnd! 5 Q gnd! ne5 L=5e-07 W=8e-07 AD=3.683e-13 AS=2.16e-13 PD=1.905e-06 PS=1.34e-06 $X=4515 $Y=750 $dt=2
M4 Q 5 gnd! gnd! ne5 L=5e-07 W=8e-07 AD=2.16e-13 AS=3.683e-13 PD=1.34e-06 PS=1.905e-06 $X=5680 $Y=750 $dt=2
M5 gnd! 5 Q gnd! ne5 L=5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=6720 $Y=750 $dt=2
M6 Q 5 gnd! gnd! ne5 L=5e-07 W=8e-07 AD=3.84e-13 AS=3.404e-13 PD=2.56e-06 PS=1.86e-06 $X=7840 $Y=750 $dt=2
M7 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=5.40138e-13 PD=1.86506e-06 PS=3.69506e-06 $X=620 $Y=2410 $dt=5
M8 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1370 $Y=2410 $dt=5
M9 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=3.11856e-13 AS=2.43675e-13 PD=1.90691e-06 PS=1.86506e-06 $X=2410 $Y=2410 $dt=5
M10 Q 5 vdd5! vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=2.71738e-13 AS=3.09219e-13 PD=1.88263e-06 PS=1.89079e-06 $X=3215 $Y=2410 $dt=5
M11 vdd5! 5 Q vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=3.03362e-13 AS=2.71738e-13 PD=1.88263e-06 PS=1.88263e-06 $X=4255 $Y=2410 $dt=5
M12 Q 5 vdd5! vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=2.71738e-13 AS=3.03362e-13 PD=1.88263e-06 PS=1.88263e-06 $X=5065 $Y=2410 $dt=5
M13 vdd5! 5 Q vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=3.03362e-13 AS=2.71738e-13 PD=1.88263e-06 PS=1.88263e-06 $X=6105 $Y=2410 $dt=5
M14 Q 5 vdd5! vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=2.71737e-13 AS=3.03362e-13 PD=1.88263e-06 PS=1.88263e-06 $X=6915 $Y=2410 $dt=5
M15 vdd5! 5 Q vdd5! pe5 L=5.00228e-07 W=1.45763e-06 AD=5.99462e-13 AS=2.71737e-13 PD=3.71263e-06 PS=1.88263e-06 $X=7955 $Y=2410 $dt=5
.ends BU_5VX6

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BU_5VX8                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BU_5VX8 vdd5! gnd! A Q
** N=5 EP=4 FDC=21
M0 5 A gnd! gnd! ne5 L=5e-07 W=6.75e-07 AD=1.8225e-13 AS=5.883e-13 PD=1.215e-06 PS=3.52e-06 $X=660 $Y=875 $dt=2
M1 gnd! A 5 gnd! ne5 L=5e-07 W=6.75e-07 AD=3.279e-13 AS=1.8225e-13 PD=1.86e-06 PS=1.215e-06 $X=1700 $Y=875 $dt=2
M2 5 A gnd! gnd! ne5 L=5e-07 W=6.75e-07 AD=3.24e-13 AS=3.279e-13 PD=2.31e-06 PS=1.86e-06 $X=2820 $Y=875 $dt=2
M3 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=4.224e-13 PD=1.86e-06 PS=2.72e-06 $X=4720 $Y=670 $dt=2
M4 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=5840 $Y=670 $dt=2
M5 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=6880 $Y=670 $dt=2
M6 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=2.376e-13 AS=3.484e-13 PD=1.42e-06 PS=1.86e-06 $X=8000 $Y=670 $dt=2
M7 gnd! 5 Q gnd! ne5 L=5e-07 W=8.8e-07 AD=3.484e-13 AS=2.376e-13 PD=1.86e-06 PS=1.42e-06 $X=9040 $Y=670 $dt=2
M8 Q 5 gnd! gnd! ne5 L=5e-07 W=8.8e-07 AD=4.224e-13 AS=3.484e-13 PD=2.72e-06 PS=1.86e-06 $X=10160 $Y=670 $dt=2
M9 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=5.79287e-13 PD=1.86506e-06 PS=3.69506e-06 $X=475 $Y=2410 $dt=5
M10 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.82825e-13 AS=2.43675e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1515 $Y=2410 $dt=5
M11 5 A vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.43675e-13 AS=2.82825e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2265 $Y=2410 $dt=5
M12 vdd5! A 5 vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.9769e-13 AS=2.43675e-13 PD=1.88741e-06 PS=1.86506e-06 $X=3305 $Y=2410 $dt=5
M13 Q 5 vdd5! vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=2.81737e-13 AS=2.94335e-13 PD=1.88849e-06 PS=1.86614e-06 $X=4095 $Y=2410 $dt=5
M14 vdd5! 5 Q vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=3.09563e-13 AS=2.81737e-13 PD=1.88849e-06 PS=1.88849e-06 $X=5135 $Y=2410 $dt=5
M15 Q 5 vdd5! vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=2.81737e-13 AS=3.09563e-13 PD=1.88849e-06 PS=1.88849e-06 $X=5965 $Y=2410 $dt=5
M16 vdd5! 5 Q vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=3.09563e-13 AS=2.81737e-13 PD=1.88849e-06 PS=1.88849e-06 $X=7005 $Y=2410 $dt=5
M17 Q 5 vdd5! vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=2.81737e-13 AS=3.09563e-13 PD=1.88849e-06 PS=1.88849e-06 $X=7835 $Y=2410 $dt=5
M18 vdd5! 5 Q vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=3.09563e-13 AS=2.81737e-13 PD=1.88849e-06 PS=1.88849e-06 $X=8875 $Y=2410 $dt=5
M19 Q 5 vdd5! vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=2.81737e-13 AS=3.09563e-13 PD=1.88849e-06 PS=1.88849e-06 $X=9705 $Y=2410 $dt=5
M20 vdd5! 5 Q vdd5! pe5 L=5.00209e-07 W=1.45349e-06 AD=6.05662e-13 AS=2.81737e-13 PD=3.71849e-06 PS=1.88849e-06 $X=10745 $Y=2410 $dt=5
.ends BU_5VX8

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN211_5VX1                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN211_5VX1 vdd5! gnd! B A Q C D
** N=10 EP=7 FDC=8
M0 8 B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=1.1125e-13 AS=7.896e-13 PD=1.14e-06 PS=3.81e-06 $X=805 $Y=660 $dt=2
M1 Q A 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.77124e-13 AS=1.1125e-13 PD=1.63537e-06 PS=1.14e-06 $X=1555 $Y=660 $dt=2
M2 gnd! C Q gnd! ne5 L=5e-07 W=7.1e-07 AD=4.337e-13 AS=2.21076e-13 PD=2.025e-06 PS=1.30463e-06 $X=2635 $Y=840 $dt=2
M3 Q D gnd! gnd! ne5 L=5e-07 W=7.1e-07 AD=3.408e-13 AS=4.337e-13 PD=2.38e-06 PS=2.025e-06 $X=3920 $Y=840 $dt=2
M4 vdd5! B 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.106e-13 AS=6.768e-13 PD=2.38e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M5 9 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.106e-13 PD=1.95e-06 PS=2.38e-06 $X=1740 $Y=2410 $dt=5
M6 10 C 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=3.807e-13 PD=1.66e-06 PS=1.95e-06 $X=2780 $Y=2410 $dt=5
M7 Q D 10 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=3530 $Y=2410 $dt=5
.ends AN211_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO3_5VX2                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO3_5VX2 vdd5! gnd! C B A Q
** N=17 EP=6 FDC=26
M0 7 C gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=5.728e-13 PD=1.06e-06 PS=3.52e-06 $X=660 $Y=1030 $dt=2
M1 gnd! B 7 gnd! ne5 L=5e-07 W=5.2e-07 AD=4.1245e-13 AS=1.404e-13 PD=1.9e-06 PS=1.06e-06 $X=1700 $Y=1030 $dt=2
M2 10 C gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=7.54e-14 AS=4.1245e-13 PD=8.1e-07 PS=1.9e-06 $X=3210 $Y=1030 $dt=2
M3 8 B 10 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=7.54e-14 PD=1.06e-06 PS=8.1e-07 $X=4000 $Y=1030 $dt=2
M4 gnd! 7 8 gnd! ne5 L=5e-07 W=5.2e-07 AD=7.216e-13 AS=1.404e-13 PD=2.52e-06 PS=1.06e-06 $X=5040 $Y=1030 $dt=2
M5 9 8 gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=7.216e-13 PD=1.06e-06 PS=2.52e-06 $X=6820 $Y=1030 $dt=2
M6 gnd! A 9 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.9795e-13 AS=1.404e-13 PD=1.315e-06 PS=1.06e-06 $X=7860 $Y=1030 $dt=2
M7 11 A gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=6.5e-14 AS=1.9795e-13 PD=7.7e-07 PS=1.315e-06 $X=8980 $Y=1030 $dt=2
M8 Q 8 11 gnd! ne5 L=5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=9730 $Y=1030 $dt=2
M9 gnd! 9 Q gnd! ne5 L=5e-07 W=5.2e-07 AD=5.456e-13 AS=1.404e-13 PD=2.225e-06 PS=1.06e-06 $X=10770 $Y=1030 $dt=2
M10 Q 9 gnd! gnd! ne5 L=5e-07 W=5.2e-07 AD=1.612e-13 AS=5.456e-13 PD=1.14e-06 PS=2.225e-06 $X=12645 $Y=1030 $dt=2
M11 12 8 Q gnd! ne5 L=5e-07 W=5.2e-07 AD=6.63e-14 AS=1.612e-13 PD=7.75e-07 PS=1.14e-06 $X=13765 $Y=1030 $dt=2
M12 gnd! A 12 gnd! ne5 L=5e-07 W=5.2e-07 AD=5.728e-13 AS=6.63e-14 PD=3.52e-06 PS=7.75e-07 $X=14520 $Y=1030 $dt=2
M13 15 C vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=6.806e-13 PD=1.66e-06 PS=3.8e-06 $X=620 $Y=2410 $dt=5
M14 7 B 15 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.184e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=1370 $Y=2410 $dt=5
M15 vdd5! C 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.8775e-13 AS=5.512e-13 PD=1.96e-06 PS=3.78e-06 $X=2950 $Y=2410 $dt=5
M16 13 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=3.8775e-13 PD=1.95e-06 PS=1.96e-06 $X=4000 $Y=2410 $dt=5
M17 8 7 13 vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=5040 $Y=2410 $dt=5
M18 16 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=8.802e-13 PD=1.66e-06 PS=4.56e-06 $X=6820 $Y=2410 $dt=5
M19 9 A 16 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.6195e-13 AS=1.7625e-13 PD=3.75071e-06 PS=1.66e-06 $X=7570 $Y=2410 $dt=5
M20 vdd5! A 14 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.106e-13 AS=5.1715e-13 PD=2.38e-06 PS=3.75071e-06 $X=9150 $Y=2410 $dt=5
M21 14 8 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.84225e-13 AS=5.106e-13 PD=1.955e-06 PS=2.38e-06 $X=10270 $Y=2410 $dt=5
M22 Q 9 14 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.12425e-13 AS=3.84225e-13 PD=1.995e-06 PS=1.955e-06 $X=11315 $Y=2410 $dt=5
M23 17 9 Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=4.12425e-13 PD=1.95e-06 PS=1.995e-06 $X=12400 $Y=2410 $dt=5
M24 vdd5! 8 17 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.106e-13 AS=3.807e-13 PD=2.38e-06 PS=1.95e-06 $X=13440 $Y=2410 $dt=5
M25 17 A vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=6.768e-13 AS=5.106e-13 PD=3.78e-06 PS=2.38e-06 $X=14560 $Y=2410 $dt=5
.ends EO3_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AO22_5VX1                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AO22_5VX1 vdd5! gnd! B A C D Q
** N=11 EP=7 FDC=10
M0 8 B gnd! gnd! ne5 L=5e-07 W=4.8e-07 AD=6e-14 AS=6.618e-13 PD=7.3e-07 PS=3.67e-06 $X=735 $Y=1070 $dt=2
M1 10 A 8 gnd! ne5 L=5e-07 W=4.8e-07 AD=1.296e-13 AS=6e-14 PD=1.02e-06 PS=7.3e-07 $X=1485 $Y=1070 $dt=2
M2 9 C 10 gnd! ne5 L=5e-07 W=4.8e-07 AD=6e-14 AS=1.296e-13 PD=7.3e-07 PS=1.02e-06 $X=2525 $Y=1070 $dt=2
M3 gnd! D 9 gnd! ne5 L=5e-07 W=4.8e-07 AD=5.10692e-13 AS=6e-14 PD=1.75533e-06 PS=7.3e-07 $X=3275 $Y=1070 $dt=2
M4 Q 10 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=9.46908e-13 PD=2.74e-06 PS=3.25467e-06 $X=5040 $Y=660 $dt=2
M5 vdd5! B 11 vdd5! pe5 L=5e-07 W=7.6e-07 AD=2.052e-13 AS=6.35575e-13 PD=1.3e-06 PS=4.145e-06 $X=490 $Y=2500 $dt=5
M6 vdd5! A 11 vdd5! pe5 L=5e-07 W=7.6e-07 AD=2.052e-13 AS=6.35575e-13 PD=1.3e-06 PS=4.145e-06 $X=1530 $Y=2500 $dt=5
M7 11 C 10 vdd5! pe5 L=5e-07 W=7.6e-07 AD=6.35575e-13 AS=2.052e-13 PD=4.145e-06 PS=1.3e-06 $X=2480 $Y=2410 $dt=5
M8 11 D 10 vdd5! pe5 L=5e-07 W=7.6e-07 AD=6.35575e-13 AS=2.052e-13 PD=4.145e-06 PS=1.3e-06 $X=3520 $Y=2410 $dt=5
M9 Q 10 vdd5! vdd5! pe5 L=5.00257e-07 W=1.46385e-06 AD=5.5785e-13 AS=7.8855e-13 PD=3.70385e-06 PS=4.48385e-06 $X=5040 $Y=2410 $dt=5
.ends AO22_5VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2_5VX2                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2_5VX2 vdd5! gnd! B Q A
** N=7 EP=5 FDC=8
M0 Q B gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=2
M1 gnd! A Q gnd! ne5 L=5e-07 W=8.9e-07 AD=3.618e-13 AS=2.403e-13 PD=1.88e-06 PS=1.43e-06 $X=1700 $Y=660 $dt=2
M2 Q A gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.618e-13 PD=1.43e-06 PS=1.88e-06 $X=2840 $Y=660 $dt=2
M3 gnd! B Q gnd! ne5 L=5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=3880 $Y=660 $dt=2
M4 6 B vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=1.3906e-12 PD=1.66e-06 PS=5.14e-06 $X=950 $Y=2410 $dt=5
M5 Q A 6 vdd5! pe5 L=5e-07 W=1.41e-06 AD=4.512e-13 AS=1.7625e-13 PD=2.05e-06 PS=1.66e-06 $X=1700 $Y=2410 $dt=5
M6 7 A Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.7625e-13 AS=4.512e-13 PD=1.66e-06 PS=2.05e-06 $X=2840 $Y=2410 $dt=5
M7 vdd5! B 7 vdd5! pe5 L=5e-07 W=1.41e-06 AD=1.3906e-12 AS=1.7625e-13 PD=5.14e-06 PS=1.66e-06 $X=3590 $Y=2410 $dt=5
.ends NO2_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND2_5VX2                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND2_5VX2 vdd5! gnd! A B Q
** N=7 EP=5 FDC=8
M0 7 A 6 gnd! ne5 L=5e-07 W=8.9e-07 AD=1.2015e-13 AS=4.272e-13 PD=1.16e-06 PS=2.74e-06 $X=930 $Y=660 $dt=2
M1 gnd! B 7 gnd! ne5 L=5e-07 W=8.9e-07 AD=3.618e-13 AS=1.2015e-13 PD=1.88e-06 PS=1.16e-06 $X=1700 $Y=660 $dt=2
M2 Q 6 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=3.618e-13 PD=1.43e-06 PS=1.88e-06 $X=2840 $Y=660 $dt=2
M3 gnd! 6 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=3880 $Y=660 $dt=2
M4 6 A vdd5! vdd5! pe5 L=5e-07 W=1.1e-06 AD=2.97e-13 AS=8.492e-13 PD=1.64e-06 PS=4.56e-06 $X=660 $Y=2410 $dt=5
M5 vdd5! B 6 vdd5! pe5 L=5e-07 W=1.1e-06 AD=4.49378e-13 AS=2.97e-13 PD=2.10359e-06 PS=1.64e-06 $X=1700 $Y=2410 $dt=5
M6 Q 6 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=5.76022e-13 PD=1.95e-06 PS=2.69641e-06 $X=2840 $Y=2410 $dt=5
M7 vdd5! 6 Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=8.802e-13 AS=3.807e-13 PD=4.56e-06 PS=1.95e-06 $X=3880 $Y=2410 $dt=5
.ends AND2_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRQ_5VX2                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRQ_5VX2 vdd5! gnd! D C Q
** N=19 EP=5 FDC=28
M0 gnd! 6 9 gnd! ne5 L=5e-07 W=6.6e-07 AD=2.03133e-13 AS=3.168e-13 PD=1.46667e-06 PS=2.28e-06 $X=620 $Y=720 $dt=2
M1 10 9 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.29267e-13 PD=6.7e-07 PS=9.33333e-07 $X=1660 $Y=960 $dt=2
M2 6 13 10 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.3125e-13 AS=5.25e-14 PD=9.3e-07 PS=6.7e-07 $X=2410 $Y=960 $dt=2
M3 12 14 6 gnd! ne5 L=5e-07 W=7e-07 AD=8.75e-14 AS=2.1875e-13 PD=9.5e-07 PS=1.55e-06 $X=3450 $Y=960 $dt=2
M4 gnd! D 12 gnd! ne5 L=5e-07 W=7e-07 AD=2.1875e-13 AS=8.75e-14 PD=1.55e-06 PS=9.5e-07 $X=4200 $Y=960 $dt=2
M5 13 14 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=1.3125e-13 PD=1.8e-06 PS=9.3e-07 $X=5240 $Y=960 $dt=2
M6 gnd! C 14 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.63782e-13 AS=2.016e-13 PD=1.08316e-06 PS=1.8e-06 $X=6980 $Y=1130 $dt=2
M7 15 9 gnd! gnd! ne5 L=5e-07 W=7.2e-07 AD=9e-14 AS=2.80768e-13 PD=9.7e-07 PS=1.85684e-06 $X=8060 $Y=660 $dt=2
M8 7 13 15 gnd! ne5 L=5e-07 W=7.2e-07 AD=2.26611e-13 AS=9e-14 PD=1.59158e-06 PS=9.7e-07 $X=8810 $Y=660 $dt=2
M9 11 14 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.32189e-13 PD=6.7e-07 PS=9.28421e-07 $X=9850 $Y=960 $dt=2
M10 gnd! 8 11 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.45833e-13 AS=5.25e-14 PD=9.95556e-07 PS=6.7e-07 $X=10600 $Y=960 $dt=2
M11 8 7 gnd! gnd! ne5 L=5e-07 W=6.6e-07 AD=3.122e-13 AS=2.29167e-13 PD=2.28e-06 PS=1.56444e-06 $X=11720 $Y=890 $dt=2
M12 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=5.988e-13 PD=1.43e-06 PS=3.52e-06 $X=13480 $Y=660 $dt=2
M13 gnd! 7 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=14520 $Y=660 $dt=2
M14 vdd5! 6 9 vdd5! pe5 L=5e-07 W=1e-06 AD=3.39437e-13 AS=4.8e-13 PD=2.16901e-06 PS=2.96e-06 $X=620 $Y=2650 $dt=5
M15 16 9 vdd5! vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.42563e-13 PD=6.7e-07 PS=9.10986e-07 $X=1660 $Y=3230 $dt=5
M16 6 14 16 vdd5! pe5 L=5e-07 W=4.2e-07 AD=1.45342e-13 AS=5.25e-14 PD=9.06316e-07 PS=6.7e-07 $X=2410 $Y=3230 $dt=5
M17 18 13 6 vdd5! pe5 L=5e-07 W=1.1e-06 AD=1.375e-13 AS=3.80658e-13 PD=1.35e-06 PS=2.37368e-06 $X=3450 $Y=2720 $dt=5
M18 vdd5! D 18 vdd5! pe5 L=5e-07 W=1.1e-06 AD=3.89231e-13 AS=1.375e-13 PD=2.07912e-06 PS=1.35e-06 $X=4200 $Y=2720 $dt=5
M19 13 14 vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.9635e-13 AS=2.54769e-13 PD=2.37071e-06 PS=1.36088e-06 $X=5320 $Y=2720 $dt=5
M20 vdd5! C 14 vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.88539e-13 AS=3.92688e-13 PD=1.63251e-06 PS=2.78435e-06 $X=6980 $Y=2800 $dt=5
M21 19 9 vdd5! vdd5! pe5 L=5e-07 W=1.15e-06 AD=1.4375e-13 AS=4.60861e-13 PD=1.4e-06 PS=2.60749e-06 $X=8060 $Y=2670 $dt=5
M22 7 14 19 vdd5! pe5 L=5e-07 W=1.15e-06 AD=3.37236e-13 AS=1.4375e-13 PD=2.4758e-06 PS=1.4e-06 $X=8810 $Y=2670 $dt=5
M23 17 13 7 vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.23164e-13 PD=6.7e-07 PS=9.04204e-07 $X=9850 $Y=3150 $dt=5
M24 vdd5! 8 17 vdd5! pe5 L=5e-07 W=4.2e-07 AD=2.60637e-13 AS=5.25e-14 PD=1.40789e-06 PS=6.7e-07 $X=10600 $Y=3150 $dt=5
M25 8 7 vdd5! vdd5! pe5 L=5e-07 W=1e-06 AD=4.689e-13 AS=6.20563e-13 PD=2.96e-06 PS=3.35211e-06 $X=11720 $Y=2410 $dt=5
M26 Q 7 vdd5! vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.807e-13 AS=8.612e-13 PD=1.95e-06 PS=4.56e-06 $X=13480 $Y=2410 $dt=5
M27 vdd5! 7 Q vdd5! pe5 L=5e-07 W=1.41e-06 AD=8.802e-13 AS=3.807e-13 PD=4.56e-06 PS=1.95e-06 $X=14520 $Y=2410 $dt=5
.ends DFRQ_5VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRQ_5VX4                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRQ_5VX4 vdd5! gnd! D C Q
** N=19 EP=5 FDC=31
M0 gnd! 6 8 gnd! ne5 L=5e-07 W=8.9e-07 AD=2.94583e-13 AS=4.272e-13 PD=1.94305e-06 PS=2.74e-06 $X=620 $Y=660 $dt=2
M1 10 8 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.39017e-13 PD=6.7e-07 PS=9.16947e-07 $X=1660 $Y=960 $dt=2
M2 6 13 10 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.3125e-13 AS=5.25e-14 PD=9.3e-07 PS=6.7e-07 $X=2410 $Y=960 $dt=2
M3 12 14 6 gnd! ne5 L=5e-07 W=7e-07 AD=8.75e-14 AS=2.1875e-13 PD=9.5e-07 PS=1.55e-06 $X=3450 $Y=960 $dt=2
M4 gnd! D 12 gnd! ne5 L=5e-07 W=7e-07 AD=2.1875e-13 AS=8.75e-14 PD=1.55e-06 PS=9.5e-07 $X=4200 $Y=960 $dt=2
M5 13 14 gnd! gnd! ne5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=1.3125e-13 PD=1.8e-06 PS=9.3e-07 $X=5240 $Y=960 $dt=2
M6 gnd! C 14 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.63782e-13 AS=2.016e-13 PD=1.08316e-06 PS=1.8e-06 $X=6980 $Y=1130 $dt=2
M7 15 8 gnd! gnd! ne5 L=5e-07 W=7.2e-07 AD=9e-14 AS=2.80768e-13 PD=9.7e-07 PS=1.85684e-06 $X=8060 $Y=660 $dt=2
M8 7 13 15 gnd! ne5 L=5e-07 W=7.2e-07 AD=2.26611e-13 AS=9e-14 PD=1.59158e-06 PS=9.7e-07 $X=8810 $Y=660 $dt=2
M9 11 14 7 gnd! ne5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.32189e-13 PD=6.7e-07 PS=9.28421e-07 $X=9850 $Y=960 $dt=2
M10 gnd! 9 11 gnd! ne5 L=5e-07 W=4.2e-07 AD=1.59119e-13 AS=5.25e-14 PD=9.68244e-07 PS=6.7e-07 $X=10600 $Y=960 $dt=2
M11 9 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=3.37181e-13 PD=2.74e-06 PS=2.05176e-06 $X=11720 $Y=660 $dt=2
M12 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=2.403e-13 AS=6.3285e-13 PD=1.43e-06 PS=3.56e-06 $X=13520 $Y=660 $dt=2
M13 gnd! 7 Q gnd! ne5 L=5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=14560 $Y=660 $dt=2
M14 Q 7 gnd! gnd! ne5 L=5e-07 W=8.9e-07 AD=4.272e-13 AS=3.494e-13 PD=2.74e-06 PS=1.86e-06 $X=15680 $Y=660 $dt=2
M15 vdd5! 6 8 vdd5! pe5 L=5e-07 W=1.41e-06 AD=5.10374e-13 AS=6.768e-13 PD=3.00492e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=5
M16 16 8 vdd5! vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.52026e-13 PD=6.7e-07 PS=8.95082e-07 $X=1660 $Y=3400 $dt=5
M17 6 14 16 vdd5! pe5 L=5e-07 W=4.2e-07 AD=1.45342e-13 AS=5.25e-14 PD=9.06316e-07 PS=6.7e-07 $X=2410 $Y=3400 $dt=5
M18 18 13 6 vdd5! pe5 L=5e-07 W=1.1e-06 AD=1.375e-13 AS=3.80658e-13 PD=1.35e-06 PS=2.37368e-06 $X=3450 $Y=2720 $dt=5
M19 vdd5! D 18 vdd5! pe5 L=5e-07 W=1.1e-06 AD=3.89231e-13 AS=1.375e-13 PD=2.07912e-06 PS=1.35e-06 $X=4200 $Y=2720 $dt=5
M20 13 14 vdd5! vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.9635e-13 AS=2.54769e-13 PD=2.37071e-06 PS=1.36088e-06 $X=5320 $Y=2720 $dt=5
M21 vdd5! C 14 vdd5! pe5 L=5e-07 W=7.2e-07 AD=2.02678e-13 AS=3.24287e-13 PD=1.30139e-06 PS=2.34435e-06 $X=6940 $Y=3100 $dt=5
M22 19 8 vdd5! vdd5! pe5 L=5e-07 W=1.15e-06 AD=1.4375e-13 AS=3.23722e-13 PD=1.4e-06 PS=2.07861e-06 $X=7980 $Y=2670 $dt=5
M23 7 14 19 vdd5! pe5 L=5e-07 W=1.15e-06 AD=3.4793e-13 AS=1.4375e-13 PD=2.4758e-06 PS=1.4e-06 $X=8730 $Y=2670 $dt=5
M24 17 13 7 vdd5! pe5 L=5e-07 W=4.2e-07 AD=5.25e-14 AS=1.2707e-13 PD=6.7e-07 PS=9.04204e-07 $X=9770 $Y=3400 $dt=5
M25 vdd5! 9 17 vdd5! pe5 L=5e-07 W=4.2e-07 AD=2.016e-13 AS=5.25e-14 PD=1.8e-06 PS=6.7e-07 $X=10520 $Y=3400 $dt=5
M26 vdd5! 7 9 vdd5! pe5 L=5e-07 W=1.41e-06 AD=3.22892e-13 AS=5.344e-13 PD=1.86775e-06 PS=3.78e-06 $X=12100 $Y=2410 $dt=5
M27 Q 7 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.47663e-13 AS=3.36646e-13 PD=1.86506e-06 PS=1.94731e-06 $X=12995 $Y=2410 $dt=5
M28 vdd5! 7 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.78838e-13 AS=2.47663e-13 PD=1.86506e-06 PS=1.86506e-06 $X=14035 $Y=2410 $dt=5
M29 Q 7 vdd5! vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=2.47663e-13 AS=2.78838e-13 PD=1.86506e-06 PS=1.86506e-06 $X=14785 $Y=2410 $dt=5
M30 vdd5! 7 Q vdd5! pe5 L=5.00285e-07 W=1.47006e-06 AD=5.78737e-13 AS=2.47663e-13 PD=3.71506e-06 PS=1.86506e-06 $X=15825 $Y=2410 $dt=5
.ends DFRQ_5VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__P3                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__P3 1 2 3 4 5 6 7 8 9 10
+ 11 12 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30
+ 31 32 33 34 35 36 38 39 40 41
+ 42 43 44 45 46 47 48 49 50 51
+ 52 53 54 55 56 57 58 59 60 61
+ 62 63 64 65 66 67 68 69 70 71
+ 72 73 74 75 76 77 78 79 80 81
+ 82 83 84 85 86 87 88 89 90 91
+ 92 93 94 95 96 97 98 99 100 101
+ 102 103 104 105 106 107 108 109 110 111
+ 112 113 114 115 116 117 118 119 120 121
+ 122 123 124 125 126 127 128 129 130 131
+ 132 133 134 135 136 137 138 139 140 141
+ 142 143 144 145 146 147 148 149 150 151
+ 152 153 154 155 156 157 158 159 160 161
+ 162 163 164 165 166 167 168 169 170 171
+ 172 173 174 175 176 177 178 179 180 181
+ 182 183 184 185 186 187 188 189 190 191
+ 192 193 194 195 196 197 198 199 200 201
+ 202 203 204 205 206 207 208 209 210 211
+ 212 213 214 215 216 217 218 219 220 221
+ 222 223 224 225 226 227 228 229 230 231
+ 232 233 234 235 236 237 238 239 240 241
+ 242 243 244 245 246 247 248 249 250 251
+ 252 253 254 255 256 257 258 259 260 261
+ 262 263 264 265 266 267 268 269 270 271
+ 272 273 274 275 276 277 278 279 280 281
+ 282 283 284 285 286 287 288 289 290 291
+ 292 293 294 295 296 297 298 299 300 301
+ 302 303 304 305 306 307 308 309 310 311
+ 313 314 315 316 317 318 319 320 321 322
+ 323 324 325 326 327 328 329 330 331 332
+ 333 334 335 336 337 338 339 340 341 342
+ 343 344 345 346 347 348 349 350 351 352
+ 353 354 355 356 357 358 359 360 361 362
+ 363 364 365 366 367 368 369 370 371 372
+ 373 374 375 376 377 378 379 380 381 383
+ 384 385 386 387 388 389 390 391 392 393
+ 394 395 396 397 398 399 400 401 402 403
+ 404 405 406 407 408 409 410 411 412 413
+ 414 415 416 417 418 419 420 421 422 423
+ 424 425 426 427 428 429 430 431 432 433
+ 434 435 436 437 438 439 440 441 442 443
+ 444 445 446 447 448 449 450 451 452 453
+ 454 455 456 457 458 459 460 461 462 463
+ 464 465 466 467 468 469 470 471 472 473
+ 474 475 476 477 478 479 480 481 482 483
+ 484 485 486 487 488 489 490 492 493 494
+ 495 496 497 498 499 500 501 502 503 504
+ 505 506 507 508 509 510 511 512 513 514
+ 515 516 517 518 519 520 521 522 523 524
+ 525 526 527 528 529 530 531 532 533 534
+ 535 536 537 538 539 540 541 542 543 544
+ 545 546 547 548 549 550 551 552 553 554
+ 555 556 557 558 559 560 561 562 563 564
+ 565 566 567 568 569 570 571 572 574 575
+ 576 577 578 579 580 581 582 583 584 585
+ 586 587 588 589 590 591 592 593 594 595
+ 596 597 598 599 600 601 602 603 604 605
+ 606 607 608 609 610 611 612 613 614 615
+ 616 617 618 619 620 621 622 623 624 625
+ 626 627 628 629 630 631 632 633 634 635
+ 636 637 638 639 640 641 642 643 644 645
+ 646 647 648 649 650 651 652 653 654 655
+ 656 657 658 659 660 661 662 663 664 665
+ 666 667 668 669 670 671 672 673 674 675
+ 676 677 678 679 680 681 682 683 684 685
+ 686 687 688 689 690 691 692 693 694 695
+ 696 697 698 699 700 701 702 703 704
** N=9986 EP=699 FDC=123612
X56670 1 2 809 9809 BU_5VX1 $T=-597960 224000 0 0 $X=-598390 $Y=223360
X56671 1 2 814 7934 BU_5VX1 $T=-595720 152320 1 0 $X=-596150 $Y=147200
X56672 1 2 817 827 BU_5VX1 $T=-595720 259840 0 0 $X=-596150 $Y=259200
X56673 1 2 7933 836 BU_5VX1 $T=-594040 161280 1 0 $X=-594470 $Y=156160
X56674 1 2 833 835 BU_5VX1 $T=-590680 125440 1 0 $X=-591110 $Y=120320
X56675 1 2 963 968 BU_5VX1 $T=-555960 134400 1 0 $X=-556390 $Y=129280
X56676 1 2 998 1088 BU_5VX1 $T=-548680 62720 0 0 $X=-549110 $Y=62080
X56677 1 2 1015 1022 BU_5VX1 $T=-544760 98560 0 0 $X=-545190 $Y=97920
X56678 1 2 1014 1025 BU_5VX1 $T=-544200 62720 1 0 $X=-544630 $Y=57600
X56679 1 2 1024 7976 BU_5VX1 $T=-541960 44800 0 0 $X=-542390 $Y=44160
X56680 1 2 1043 1024 BU_5VX1 $T=-539160 53760 0 0 $X=-539590 $Y=53120
X56681 1 2 1022 1034 BU_5VX1 $T=-538600 107520 1 0 $X=-539030 $Y=102400
X56682 1 2 1050 7982 BU_5VX1 $T=-538040 116480 0 0 $X=-538470 $Y=115840
X56683 1 2 1078 1066 BU_5VX1 $T=-535800 44800 1 0 $X=-536230 $Y=39680
X56684 1 2 1064 9792 BU_5VX1 $T=-535240 295680 1 0 $X=-535670 $Y=290560
X56685 1 2 1068 1078 BU_5VX1 $T=-533560 53760 1 0 $X=-533990 $Y=48640
X56686 1 2 7990 8025 BU_5VX1 $T=-533000 44800 1 0 $X=-533430 $Y=39680
X56687 1 2 1163 1096 BU_5VX1 $T=-530200 44800 1 0 $X=-530630 $Y=39680
X56688 1 2 1101 7990 BU_5VX1 $T=-527400 44800 1 0 $X=-527830 $Y=39680
X56689 1 2 1124 1119 BU_5VX1 $T=-523480 107520 0 0 $X=-523910 $Y=106880
X56690 1 2 1148 1124 BU_5VX1 $T=-521800 98560 1 0 $X=-522230 $Y=93440
X56691 1 2 1142 8017 BU_5VX1 $T=-520120 116480 1 0 $X=-520550 $Y=111360
X56692 1 2 1144 1126 BU_5VX1 $T=-519560 107520 1 0 $X=-519990 $Y=102400
X56693 1 2 1159 8028 BU_5VX1 $T=-515640 26880 0 0 $X=-516070 $Y=26240
X56694 1 2 1162 1175 BU_5VX1 $T=-515080 26880 1 0 $X=-515510 $Y=21760
X56695 1 2 1178 1162 BU_5VX1 $T=-512840 26880 0 0 $X=-513270 $Y=26240
X56696 1 2 8028 9814 BU_5VX1 $T=-511720 17920 0 0 $X=-512150 $Y=17280
X56697 1 2 1203 1208 BU_5VX1 $T=-508920 17920 0 0 $X=-509350 $Y=17280
X56698 1 2 1220 1203 BU_5VX1 $T=-506120 17920 0 0 $X=-506550 $Y=17280
X56699 1 2 1198 1193 BU_5VX1 $T=-505000 80640 0 0 $X=-505430 $Y=80000
X56700 1 2 8053 8052 BU_5VX1 $T=-498280 89600 1 0 $X=-498710 $Y=84480
X56701 1 2 1278 1285 BU_5VX1 $T=-497160 89600 0 0 $X=-497590 $Y=88960
X56702 1 2 1330 1298 BU_5VX1 $T=-494920 152320 0 0 $X=-495350 $Y=151680
X56703 1 2 8067 1332 BU_5VX1 $T=-491000 241920 1 0 $X=-491430 $Y=236800
X56704 1 2 8079 8081 BU_5VX1 $T=-482600 71680 0 0 $X=-483030 $Y=71040
X56705 1 2 1327 1393 BU_5VX1 $T=-475880 98560 0 0 $X=-476310 $Y=97920
X56706 1 2 1482 1477 BU_5VX1 $T=-463560 143360 1 0 $X=-463990 $Y=138240
X56707 1 2 1341 1525 BU_5VX1 $T=-454600 241920 0 0 $X=-455030 $Y=241280
X56708 1 2 1544 8125 BU_5VX1 $T=-454600 304640 0 0 $X=-455030 $Y=304000
X56709 1 2 1545 1535 BU_5VX1 $T=-454600 340480 0 0 $X=-455030 $Y=339840
X56710 1 2 8131 8133 BU_5VX1 $T=-451240 367360 1 0 $X=-451670 $Y=362240
X56711 1 2 1656 1586 BU_5VX1 $T=-450120 62720 0 0 $X=-450550 $Y=62080
X56712 1 2 1580 1591 BU_5VX1 $T=-444520 349440 1 0 $X=-444950 $Y=344320
X56713 1 2 8153 9822 BU_5VX1 $T=-436680 161280 1 0 $X=-437110 $Y=156160
X56714 1 2 1672 8159 BU_5VX1 $T=-436680 349440 0 0 $X=-437110 $Y=348800
X56715 1 2 1686 1700 BU_5VX1 $T=-435000 313600 0 0 $X=-435430 $Y=312960
X56716 1 2 1701 1708 BU_5VX1 $T=-433320 322560 0 0 $X=-433750 $Y=321920
X56717 1 2 8171 1734 BU_5VX1 $T=-429960 313600 1 0 $X=-430390 $Y=308480
X56718 1 2 1744 8181 BU_5VX1 $T=-426040 188160 1 0 $X=-426470 $Y=183040
X56719 1 2 1862 1772 BU_5VX1 $T=-424920 304640 1 0 $X=-425350 $Y=299520
X56720 1 2 8186 1795 BU_5VX1 $T=-422120 26880 1 0 $X=-422550 $Y=21760
X56721 1 2 1792 1809 BU_5VX1 $T=-420440 295680 0 0 $X=-420870 $Y=295040
X56722 1 2 1799 1811 BU_5VX1 $T=-419880 349440 1 0 $X=-420310 $Y=344320
X56723 1 2 1837 1850 BU_5VX1 $T=-414840 367360 0 0 $X=-415270 $Y=366720
X56724 1 2 1842 1849 BU_5VX1 $T=-414280 349440 0 0 $X=-414710 $Y=348800
X56725 1 2 1873 8218 BU_5VX1 $T=-410360 197120 0 0 $X=-410790 $Y=196480
X56726 1 2 3078 1912 BU_5VX1 $T=-408120 340480 0 0 $X=-408550 $Y=339840
X56727 1 2 1904 8217 BU_5VX1 $T=-407000 188160 1 0 $X=-407430 $Y=183040
X56728 1 2 8218 1852 BU_5VX1 $T=-403640 197120 1 0 $X=-404070 $Y=192000
X56729 1 2 1963 1971 BU_5VX1 $T=-400840 250880 1 0 $X=-401270 $Y=245760
X56730 1 2 1964 2166 BU_5VX1 $T=-400280 277760 1 0 $X=-400710 $Y=272640
X56731 1 2 1845 1686 BU_5VX1 $T=-399720 322560 0 0 $X=-400150 $Y=321920
X56732 1 2 1984 8306 BU_5VX1 $T=-397480 394240 1 0 $X=-397910 $Y=389120
X56733 1 2 2029 2041 BU_5VX1 $T=-391880 403200 1 0 $X=-392310 $Y=398080
X56734 1 2 2045 2027 BU_5VX1 $T=-389640 188160 1 0 $X=-390070 $Y=183040
X56735 1 2 2054 2072 BU_5VX1 $T=-389080 403200 1 0 $X=-389510 $Y=398080
X56736 1 2 8249 2037 BU_5VX1 $T=-388520 376320 0 0 $X=-388950 $Y=375680
X56737 1 2 2064 2077 BU_5VX1 $T=-387960 268800 0 0 $X=-388390 $Y=268160
X56738 1 2 2083 2079 BU_5VX1 $T=-385720 376320 0 0 $X=-386150 $Y=375680
X56739 1 2 2093 2121 BU_5VX1 $T=-385160 403200 0 0 $X=-385590 $Y=402560
X56740 1 2 2102 2119 BU_5VX1 $T=-384040 215040 0 0 $X=-384470 $Y=214400
X56741 1 2 8262 8265 BU_5VX1 $T=-380120 232960 0 0 $X=-380550 $Y=232320
X56742 1 2 2134 2144 BU_5VX1 $T=-380120 376320 1 0 $X=-380550 $Y=371200
X56743 1 2 2150 1837 BU_5VX1 $T=-378440 367360 0 0 $X=-378870 $Y=366720
X56744 1 2 2182 2170 BU_5VX1 $T=-375640 376320 1 0 $X=-376070 $Y=371200
X56745 1 2 2001 1964 BU_5VX1 $T=-370600 268800 0 0 $X=-371030 $Y=268160
X56746 1 2 2140 2197 BU_5VX1 $T=-364440 215040 0 0 $X=-364870 $Y=214400
X56747 1 2 2243 8292 BU_5VX1 $T=-364440 241920 1 0 $X=-364870 $Y=236800
X56748 1 2 2273 2225 BU_5VX1 $T=-348200 286720 1 0 $X=-348630 $Y=281600
X56749 1 2 2288 2093 BU_5VX1 $T=-348200 385280 1 0 $X=-348630 $Y=380160
X56750 1 2 2304 1984 BU_5VX1 $T=-347080 376320 0 0 $X=-347510 $Y=375680
X56751 1 2 2309 2054 BU_5VX1 $T=-346520 394240 1 0 $X=-346950 $Y=389120
X56752 1 2 2310 2324 BU_5VX1 $T=-346520 394240 0 0 $X=-346950 $Y=393600
X56753 1 2 3071 2325 BU_5VX1 $T=-346520 403200 0 0 $X=-346950 $Y=402560
X56754 1 2 2311 9799 BU_5VX1 $T=-346520 412160 1 0 $X=-346950 $Y=407040
X56755 1 2 2318 9828 BU_5VX1 $T=-345400 385280 1 0 $X=-345830 $Y=380160
X56756 1 2 2332 8305 BU_5VX1 $T=-343720 259840 0 0 $X=-344150 $Y=259200
X56757 1 2 2041 2348 BU_5VX1 $T=-343720 394240 0 0 $X=-344150 $Y=393600
X56758 1 2 2360 2370 BU_5VX1 $T=-340920 394240 0 0 $X=-341350 $Y=393600
X56759 1 2 2380 2393 BU_5VX1 $T=-338120 421120 1 0 $X=-338550 $Y=416000
X56760 1 2 2422 2444 BU_5VX1 $T=-333080 403200 0 0 $X=-333510 $Y=402560
X56761 1 2 2423 2437 BU_5VX1 $T=-333080 412160 1 0 $X=-333510 $Y=407040
X56762 1 2 8322 2377 BU_5VX1 $T=-332520 304640 0 0 $X=-332950 $Y=304000
X56763 1 2 2439 2382 BU_5VX1 $T=-330280 161280 0 0 $X=-330710 $Y=160640
X56764 1 2 2448 2480 BU_5VX1 $T=-327480 197120 1 0 $X=-327910 $Y=192000
X56765 1 2 2326 2341 BU_5VX1 $T=-326360 259840 0 0 $X=-326790 $Y=259200
X56766 1 2 8336 2468 BU_5VX1 $T=-325240 241920 0 0 $X=-325670 $Y=241280
X56767 1 2 2491 2283 BU_5VX1 $T=-324680 304640 1 0 $X=-325110 $Y=299520
X56768 1 2 2323 9829 BU_5VX1 $T=-323560 331520 1 0 $X=-323990 $Y=326400
X56769 1 2 2505 2673 BU_5VX1 $T=-323000 421120 0 0 $X=-323430 $Y=420480
X56770 1 2 2526 8346 BU_5VX1 $T=-320760 340480 0 0 $X=-321190 $Y=339840
X56771 1 2 2527 2547 BU_5VX1 $T=-320200 421120 0 0 $X=-320630 $Y=420480
X56772 1 2 2557 720 BU_5VX1 $T=-315720 134400 0 0 $X=-316150 $Y=133760
X56773 1 2 2566 2575 BU_5VX1 $T=-315160 179200 0 0 $X=-315590 $Y=178560
X56774 1 2 2571 2579 BU_5VX1 $T=-315160 259840 0 0 $X=-315590 $Y=259200
X56775 1 2 2322 2299 BU_5VX1 $T=-311240 313600 0 0 $X=-311670 $Y=312960
X56776 1 2 2649 2750 BU_5VX1 $T=-310680 259840 1 0 $X=-311110 $Y=254720
X56777 1 2 8364 2615 BU_5VX1 $T=-308440 241920 0 0 $X=-308870 $Y=241280
X56778 1 2 2558 2567 BU_5VX1 $T=-307320 215040 1 0 $X=-307750 $Y=209920
X56779 1 2 2620 2633 BU_5VX1 $T=-306760 376320 0 0 $X=-307190 $Y=375680
X56780 1 2 8374 2610 BU_5VX1 $T=-300600 215040 1 0 $X=-301030 $Y=209920
X56781 1 2 2494 2645 BU_5VX1 $T=-300040 385280 1 0 $X=-300470 $Y=380160
X56782 1 2 2568 2385 BU_5VX1 $T=-297800 376320 1 0 $X=-298230 $Y=371200
X56783 1 2 2731 8392 BU_5VX1 $T=-293320 241920 1 0 $X=-293750 $Y=236800
X56784 1 2 2734 9831 BU_5VX1 $T=-292760 385280 1 0 $X=-293190 $Y=380160
X56785 1 2 2688 2670 BU_5VX1 $T=-286040 179200 0 0 $X=-286470 $Y=178560
X56786 1 2 2777 9897 BU_5VX1 $T=-286040 206080 0 0 $X=-286470 $Y=205440
X56787 1 2 2784 8427 BU_5VX1 $T=-285480 304640 0 0 $X=-285910 $Y=304000
X56788 1 2 2757 2768 BU_5VX1 $T=-283240 259840 0 0 $X=-283670 $Y=259200
X56789 1 2 2846 2818 BU_5VX1 $T=-277080 394240 0 0 $X=-277510 $Y=393600
X56790 1 2 2858 2871 BU_5VX1 $T=-274840 322560 1 0 $X=-275270 $Y=317440
X56791 1 2 2851 2845 BU_5VX1 $T=-270360 241920 0 0 $X=-270790 $Y=241280
X56792 1 2 8471 3024 BU_5VX1 $T=-253000 188160 0 0 $X=-253430 $Y=187520
X56793 1 2 8474 3027 BU_5VX1 $T=-252440 62720 0 0 $X=-252870 $Y=62080
X56794 1 2 2870 3037 BU_5VX1 $T=-251880 259840 0 0 $X=-252310 $Y=259200
X56795 1 2 159 162 BU_5VX1 $T=-249640 17920 0 0 $X=-250070 $Y=17280
X56796 1 2 3053 3014 BU_5VX1 $T=-247960 277760 1 0 $X=-248390 $Y=272640
X56797 1 2 8489 8491 BU_5VX1 $T=-245720 268800 1 0 $X=-246150 $Y=263680
X56798 1 2 3073 3085 BU_5VX1 $T=-245720 349440 1 0 $X=-246150 $Y=344320
X56799 1 2 3060 3063 BU_5VX1 $T=-244600 215040 1 0 $X=-245030 $Y=209920
X56800 1 2 3080 2952 BU_5VX1 $T=-244600 277760 0 0 $X=-245030 $Y=277120
X56801 1 2 3002 3108 BU_5VX1 $T=-242360 206080 1 0 $X=-242790 $Y=200960
X56802 1 2 2904 2875 BU_5VX1 $T=-242360 421120 0 0 $X=-242790 $Y=420480
X56803 1 2 3067 8512 BU_5VX1 $T=-238440 304640 0 0 $X=-238870 $Y=304000
X56804 1 2 734 3152 BU_5VX1 $T=-236760 26880 0 0 $X=-237190 $Y=26240
X56805 1 2 8506 8524 BU_5VX1 $T=-236200 188160 0 0 $X=-236630 $Y=187520
X56806 1 2 8514 3138 BU_5VX1 $T=-235080 215040 0 0 $X=-235510 $Y=214400
X56807 1 2 3185 61 BU_5VX1 $T=-230600 125440 0 180 $X=-233830 $Y=120320
X56808 1 2 8502 3181 BU_5VX1 $T=-231160 304640 0 0 $X=-231590 $Y=304000
X56809 1 2 2849 3208 BU_5VX1 $T=-230600 26880 1 0 $X=-231030 $Y=21760
X56810 1 2 3191 3201 BU_5VX1 $T=-230600 322560 1 0 $X=-231030 $Y=317440
X56811 1 2 3011 3225 BU_5VX1 $T=-227240 268800 0 0 $X=-227670 $Y=268160
X56812 1 2 3217 3228 BU_5VX1 $T=-227240 331520 1 0 $X=-227670 $Y=326400
X56813 1 2 2620 3160 BU_5VX1 $T=-226120 412160 0 0 $X=-226550 $Y=411520
X56814 1 2 8535 8538 BU_5VX1 $T=-225560 241920 1 0 $X=-225990 $Y=236800
X56815 1 2 8539 3248 BU_5VX1 $T=-223880 304640 0 0 $X=-224310 $Y=304000
X56816 1 2 3241 8544 BU_5VX1 $T=-223320 206080 1 0 $X=-223750 $Y=200960
X56817 1 2 3259 3241 BU_5VX1 $T=-221080 179200 1 0 $X=-221510 $Y=174080
X56818 1 2 3265 3275 BU_5VX1 $T=-220520 295680 0 0 $X=-220950 $Y=295040
X56819 1 2 3249 3276 BU_5VX1 $T=-219960 331520 1 0 $X=-220390 $Y=326400
X56820 1 2 3294 3205 BU_5VX1 $T=-215480 259840 1 0 $X=-215910 $Y=254720
X56821 1 2 3301 3259 BU_5VX1 $T=-214360 188160 0 0 $X=-214790 $Y=187520
X56822 1 2 3336 3384 BU_5VX1 $T=-204840 179200 0 0 $X=-205270 $Y=178560
X56823 1 2 3400 3407 BU_5VX1 $T=-202040 98560 1 0 $X=-202470 $Y=93440
X56824 1 2 3416 3441 BU_5VX1 $T=-199800 349440 0 0 $X=-200230 $Y=348800
X56825 1 2 3391 3432 BU_5VX1 $T=-199240 107520 0 0 $X=-199670 $Y=106880
X56826 1 2 8604 3443 BU_5VX1 $T=-195320 215040 1 0 $X=-195750 $Y=209920
X56827 1 2 3594 3513 BU_5VX1 $T=-182440 80640 1 0 $X=-182870 $Y=75520
X56828 1 2 8631 8637 BU_5VX1 $T=-182440 232960 0 0 $X=-182870 $Y=232320
X56829 1 2 3502 3511 BU_5VX1 $T=-181880 412160 1 0 $X=-182310 $Y=407040
X56830 1 2 3650 3654 BU_5VX1 $T=-176840 322560 1 0 $X=-177270 $Y=317440
X56831 1 2 3661 8677 BU_5VX1 $T=-175720 277760 1 0 $X=-176150 $Y=272640
X56832 1 2 3552 3590 BU_5VX1 $T=-175720 331520 1 0 $X=-176150 $Y=326400
X56833 1 2 3362 3709 BU_5VX1 $T=-172920 98560 0 0 $X=-173350 $Y=97920
X56834 1 2 3666 3728 BU_5VX1 $T=-171240 313600 1 0 $X=-171670 $Y=308480
X56835 1 2 3723 9845 BU_5VX1 $T=-170120 98560 1 0 $X=-170550 $Y=93440
X56836 1 2 3800 3820 BU_5VX1 $T=-160040 125440 1 0 $X=-160470 $Y=120320
X56837 1 2 3831 3863 BU_5VX1 $T=-157800 206080 0 0 $X=-158230 $Y=205440
X56838 1 2 9898 3862 BU_5VX1 $T=-156680 385280 1 0 $X=-157110 $Y=380160
X56839 1 2 8701 9847 BU_5VX1 $T=-155000 313600 1 0 $X=-155430 $Y=308480
X56840 1 2 3871 3751 BU_5VX1 $T=-153320 197120 0 0 $X=-153750 $Y=196480
X56841 1 2 3863 3871 BU_5VX1 $T=-152200 241920 0 0 $X=-152630 $Y=241280
X56842 1 2 8706 8709 BU_5VX1 $T=-149400 304640 0 0 $X=-149830 $Y=304000
X56843 1 2 3582 3933 BU_5VX1 $T=-148840 179200 0 0 $X=-149270 $Y=178560
X56844 1 2 3775 3940 BU_5VX1 $T=-148280 134400 1 0 $X=-148710 $Y=129280
X56845 1 2 740 8731 BU_5VX1 $T=-139880 188160 1 0 $X=-140310 $Y=183040
X56846 1 2 3970 3969 BU_5VX1 $T=-139880 295680 1 0 $X=-140310 $Y=290560
X56847 1 2 3690 3858 BU_5VX1 $T=-139320 125440 1 0 $X=-139750 $Y=120320
X56848 1 2 3933 3934 BU_5VX1 $T=-137640 197120 1 0 $X=-138070 $Y=192000
X56849 1 2 8732 8739 BU_5VX1 $T=-137640 304640 0 0 $X=-138070 $Y=304000
X56850 1 2 3891 3537 BU_5VX1 $T=-136520 394240 0 0 $X=-136950 $Y=393600
X56851 1 2 3936 4081 BU_5VX1 $T=-132040 358400 0 0 $X=-132470 $Y=357760
X56852 1 2 3852 3892 BU_5VX1 $T=-130360 71680 1 0 $X=-130790 $Y=66560
X56853 1 2 4088 4107 BU_5VX1 $T=-129240 358400 0 0 $X=-129670 $Y=357760
X56854 1 2 3937 4068 BU_5VX1 $T=-127000 89600 0 0 $X=-127430 $Y=88960
X56855 1 2 4112 4122 BU_5VX1 $T=-127000 313600 0 0 $X=-127430 $Y=312960
X56856 1 2 4123 4130 BU_5VX1 $T=-125320 367360 1 0 $X=-125750 $Y=362240
X56857 1 2 4159 4170 BU_5VX1 $T=-125320 376320 1 0 $X=-125750 $Y=371200
X56858 1 2 3814 3930 BU_5VX1 $T=-119720 286720 1 0 $X=-120150 $Y=281600
X56859 1 2 4172 9899 BU_5VX1 $T=-119160 179200 1 0 $X=-119590 $Y=174080
X56860 1 2 3777 8791 BU_5VX1 $T=-117480 403200 1 0 $X=-117910 $Y=398080
X56861 1 2 4165 4177 BU_5VX1 $T=-115240 385280 0 0 $X=-115670 $Y=384640
X56862 1 2 3874 4229 BU_5VX1 $T=-114680 268800 1 0 $X=-115110 $Y=263680
X56863 1 2 2789 3790 BU_5VX1 $T=-106280 62720 1 0 $X=-106710 $Y=57600
X56864 1 2 4244 156 BU_5VX1 $T=-106280 179200 1 0 $X=-106710 $Y=174080
X56865 1 2 3647 3842 BU_5VX1 $T=-106280 250880 1 0 $X=-106710 $Y=245760
X56866 1 2 8794 4195 BU_5VX1 $T=-106280 250880 0 0 $X=-106710 $Y=250240
X56867 1 2 3285 3505 BU_5VX1 $T=-106280 268800 1 0 $X=-106710 $Y=263680
X56868 1 2 4103 4268 BU_5VX1 $T=-106280 268800 0 0 $X=-106710 $Y=268160
X56869 1 2 4675 4314 BU_5VX1 $T=-106280 277760 0 0 $X=-106710 $Y=277120
X56870 1 2 4250 3542 BU_5VX1 $T=-106280 286720 1 0 $X=-106710 $Y=281600
X56871 1 2 748 4175 BU_5VX1 $T=-106280 304640 0 0 $X=-106710 $Y=304000
X56872 1 2 4251 748 BU_5VX1 $T=-106280 313600 1 0 $X=-106710 $Y=308480
X56873 1 2 4189 4234 BU_5VX1 $T=-106280 322560 1 0 $X=-106710 $Y=317440
X56874 1 2 8801 8804 BU_5VX1 $T=-106280 322560 0 0 $X=-106710 $Y=321920
X56875 1 2 4122 4152 BU_5VX1 $T=-106280 331520 1 0 $X=-106710 $Y=326400
X56876 1 2 2627 4309 BU_5VX1 $T=-106280 331520 0 0 $X=-106710 $Y=330880
X56877 1 2 4255 8802 BU_5VX1 $T=-106280 412160 1 0 $X=-106710 $Y=407040
X56878 1 2 4256 4286 BU_5VX1 $T=-106280 421120 1 0 $X=-106710 $Y=416000
X56879 1 2 4235 4287 BU_5VX1 $T=-106280 421120 0 0 $X=-106710 $Y=420480
X56880 1 2 3548 8638 BU_5VX1 $T=-97880 232960 0 0 $X=-98310 $Y=232320
X56881 1 2 3834 3913 BU_5VX1 $T=-97880 241920 0 0 $X=-98310 $Y=241280
X56882 1 2 5215 4319 BU_5VX1 $T=-97880 394240 1 0 $X=-98310 $Y=389120
X56883 1 2 8803 4297 BU_5VX1 $T=-97320 215040 1 0 $X=-97750 $Y=209920
X56884 1 2 4281 9852 BU_5VX1 $T=-97320 322560 0 0 $X=-97750 $Y=321920
X56885 1 2 4409 8841 BU_5VX1 $T=-83320 421120 0 0 $X=-83750 $Y=420480
X56886 1 2 2476 4431 BU_5VX1 $T=-82760 376320 1 0 $X=-83190 $Y=371200
X56887 1 2 4231 8801 BU_5VX1 $T=-79960 322560 0 0 $X=-80390 $Y=321920
X56888 1 2 329 335 BU_5VX1 $T=-72120 71680 1 0 $X=-72550 $Y=66560
X56889 1 2 4526 4534 BU_5VX1 $T=-69880 304640 1 0 $X=-70310 $Y=299520
X56890 1 2 4656 4672 BU_5VX1 $T=-54200 80640 0 0 $X=-54630 $Y=80000
X56891 1 2 5121 4256 BU_5VX1 $T=-51400 421120 0 0 $X=-51830 $Y=420480
X56892 1 2 4706 4235 BU_5VX1 $T=-48600 421120 0 0 $X=-49030 $Y=420480
X56893 1 2 4762 4703 BU_5VX1 $T=-40200 295680 0 0 $X=-40630 $Y=295040
X56894 1 2 4829 4748 BU_5VX1 $T=-32920 313600 1 0 $X=-33350 $Y=308480
X56895 1 2 4893 378 BU_5VX1 $T=-25640 107520 1 0 $X=-26070 $Y=102400
X56896 1 2 4957 4849 BU_5VX1 $T=-17800 107520 1 0 $X=-18230 $Y=102400
X56897 1 2 4854 4739 BU_5VX1 $T=-16120 170240 1 0 $X=-16550 $Y=165120
X56898 1 2 4811 4829 BU_5VX1 $T=2920 322560 1 0 $X=2490 $Y=317440
X56899 1 2 4715 4869 BU_5VX1 $T=11320 385280 0 0 $X=10890 $Y=384640
X56900 1 2 5239 5252 BU_5VX1 $T=19720 340480 0 0 $X=19290 $Y=339840
X56901 1 2 5247 5255 BU_5VX1 $T=21400 35840 0 0 $X=20970 $Y=35200
X56902 1 2 9042 9065 BU_5VX1 $T=22520 340480 0 0 $X=22090 $Y=339840
X56903 1 2 5265 5285 BU_5VX1 $T=22520 367360 1 0 $X=22090 $Y=362240
X56904 1 2 5233 9861 BU_5VX1 $T=23640 241920 0 0 $X=23210 $Y=241280
X56905 1 2 5284 5299 BU_5VX1 $T=24200 349440 0 0 $X=23770 $Y=348800
X56906 1 2 9046 5295 BU_5VX1 $T=24760 322560 1 0 $X=24330 $Y=317440
X56907 1 2 9045 768 BU_5VX1 $T=33160 412160 1 0 $X=32730 $Y=407040
X56908 1 2 5411 5446 BU_5VX1 $T=41560 385280 1 0 $X=41130 $Y=380160
X56909 1 2 5049 5239 BU_5VX1 $T=42120 340480 1 0 $X=41690 $Y=335360
X56910 1 2 5335 4503 BU_5VX1 $T=43800 331520 1 0 $X=43370 $Y=326400
X56911 1 2 5476 5493 BU_5VX1 $T=46600 385280 1 0 $X=46170 $Y=380160
X56912 1 2 5473 5077 BU_5VX1 $T=47160 224000 1 0 $X=46730 $Y=218880
X56913 1 2 5169 5480 BU_5VX1 $T=47720 206080 0 0 $X=47290 $Y=205440
X56914 1 2 4634 5398 BU_5VX1 $T=48840 277760 0 0 $X=48410 $Y=277120
X56915 1 2 5060 5665 BU_5VX1 $T=51080 421120 0 0 $X=50650 $Y=420480
X56916 1 2 9105 5273 BU_5VX1 $T=51640 277760 0 0 $X=51210 $Y=277120
X56917 1 2 5571 5577 BU_5VX1 $T=57800 125440 0 0 $X=57370 $Y=124800
X56918 1 2 9141 5663 BU_5VX1 $T=66200 349440 1 0 $X=65770 $Y=344320
X56919 1 2 5512 9156 BU_5VX1 $T=67880 340480 0 0 $X=67450 $Y=339840
X56920 1 2 5500 5700 BU_5VX1 $T=70120 125440 0 0 $X=69690 $Y=124800
X56921 1 2 5561 5633 BU_5VX1 $T=73480 394240 0 0 $X=73050 $Y=393600
X56922 1 2 5683 5732 BU_5VX1 $T=76280 250880 1 0 $X=75850 $Y=245760
X56923 1 2 5789 5779 BU_5VX1 $T=81880 349440 0 0 $X=81450 $Y=348800
X56924 1 2 5438 9187 BU_5VX1 $T=93080 340480 0 0 $X=92650 $Y=339840
X56925 1 2 5470 5953 BU_5VX1 $T=103160 340480 1 0 $X=102730 $Y=335360
X56926 1 2 5575 5986 BU_5VX1 $T=103160 403200 0 0 $X=102730 $Y=402560
X56927 1 2 5967 6010 BU_5VX1 $T=105960 340480 1 0 $X=105530 $Y=335360
X56928 1 2 9237 6126 BU_5VX1 $T=118840 188160 0 0 $X=118410 $Y=187520
X56929 1 2 6212 5459 BU_5VX1 $T=129480 394240 0 0 $X=129050 $Y=393600
X56930 1 2 6240 9267 BU_5VX1 $T=135080 412160 0 0 $X=134650 $Y=411520
X56931 1 2 6236 6245 BU_5VX1 $T=135640 35840 1 0 $X=135210 $Y=30720
X56932 1 2 9271 9274 BU_5VX1 $T=135640 170240 1 0 $X=135210 $Y=165120
X56933 1 2 9267 6138 BU_5VX1 $T=135640 403200 1 0 $X=135210 $Y=398080
X56934 1 2 5409 6266 BU_5VX1 $T=135640 403200 0 0 $X=135210 $Y=402560
X56935 1 2 5443 6249 BU_5VX1 $T=135640 412160 1 0 $X=135210 $Y=407040
X56936 1 2 6257 6265 BU_5VX1 $T=152440 376320 0 0 $X=152010 $Y=375680
X56937 1 2 6271 6291 BU_5VX1 $T=153000 188160 0 0 $X=152570 $Y=187520
X56938 1 2 6209 6281 BU_5VX1 $T=153000 259840 1 0 $X=152570 $Y=254720
X56939 1 2 9275 6294 BU_5VX1 $T=153000 394240 1 0 $X=152570 $Y=389120
X56940 1 2 6070 9874 BU_5VX1 $T=153560 232960 1 0 $X=153130 $Y=227840
X56941 1 2 5317 6304 BU_5VX1 $T=153560 385280 0 0 $X=153130 $Y=384640
X56942 1 2 6110 6373 BU_5VX1 $T=157480 268800 1 0 $X=157050 $Y=263680
X56943 1 2 5511 6343 BU_5VX1 $T=159720 376320 0 0 $X=159290 $Y=375680
X56944 1 2 6358 6368 BU_5VX1 $T=161400 286720 0 0 $X=160970 $Y=286080
X56945 1 2 6223 6301 BU_5VX1 $T=161960 322560 0 0 $X=161530 $Y=321920
X56946 1 2 6369 6379 BU_5VX1 $T=162520 367360 0 0 $X=162090 $Y=366720
X56947 1 2 6368 6263 BU_5VX1 $T=164760 286720 1 0 $X=164330 $Y=281600
X56948 1 2 6390 6311 BU_5VX1 $T=166440 340480 1 0 $X=166010 $Y=335360
X56949 1 2 5815 6303 BU_5VX1 $T=167000 367360 1 0 $X=166570 $Y=362240
X56950 1 2 6411 9880 BU_5VX1 $T=174840 349440 1 0 $X=174410 $Y=344320
X56951 1 2 9900 6428 BU_5VX1 $T=177080 215040 1 0 $X=176650 $Y=209920
X56952 1 2 5307 6392 BU_5VX1 $T=177080 412160 0 0 $X=176650 $Y=411520
X56953 1 2 4336 6483 BU_5VX1 $T=177640 421120 0 0 $X=177210 $Y=420480
X56954 1 2 6446 6466 BU_5VX1 $T=181000 26880 1 0 $X=180570 $Y=21760
X56955 1 2 5692 6537 BU_5VX1 $T=183800 340480 0 0 $X=183370 $Y=339840
X56956 1 2 9354 6519 BU_5VX1 $T=188280 385280 1 0 $X=187850 $Y=380160
X56957 1 2 6553 6691 BU_5VX1 $T=206760 385280 0 0 $X=206330 $Y=384640
X56958 1 2 6632 6739 BU_5VX1 $T=209560 313600 0 0 $X=209130 $Y=312960
X56959 1 2 9400 6749 BU_5VX1 $T=211240 295680 1 0 $X=210810 $Y=290560
X56960 1 2 6042 9400 BU_5VX1 $T=214040 295680 1 0 $X=213610 $Y=290560
X56961 1 2 9419 6744 BU_5VX1 $T=220760 376320 1 0 $X=220330 $Y=371200
X56962 1 2 9422 6814 BU_5VX1 $T=222440 385280 0 0 $X=222010 $Y=384640
X56963 1 2 6762 9422 BU_5VX1 $T=225240 385280 0 0 $X=224810 $Y=384640
X56964 1 2 6860 6833 BU_5VX1 $T=226920 232960 0 0 $X=226490 $Y=232320
X56965 1 2 6752 6822 BU_5VX1 $T=234200 358400 0 0 $X=233770 $Y=357760
X56966 1 2 9448 5988 BU_5VX1 $T=235880 376320 1 0 $X=235450 $Y=371200
X56967 1 2 5998 6723 BU_5VX1 $T=238120 358400 1 0 $X=237690 $Y=353280
X56968 1 2 6922 5625 BU_5VX1 $T=251560 358400 1 0 $X=251130 $Y=353280
X56969 1 2 5866 6943 BU_5VX1 $T=255480 340480 1 0 $X=255050 $Y=335360
X56970 1 2 6984 6920 BU_5VX1 $T=258280 340480 1 0 $X=257850 $Y=335360
X56971 1 2 5850 7080 BU_5VX1 $T=263320 331520 0 0 $X=262890 $Y=330880
X56972 1 2 6941 9472 BU_5VX1 $T=266120 331520 1 0 $X=265690 $Y=326400
X56973 1 2 7025 6977 BU_5VX1 $T=266680 215040 1 0 $X=266250 $Y=209920
X56974 1 2 7001 6976 BU_5VX1 $T=268920 331520 1 0 $X=268490 $Y=326400
X56975 1 2 7080 7008 BU_5VX1 $T=275640 340480 1 0 $X=275210 $Y=335360
X56976 1 2 545 7099 BU_5VX1 $T=277320 197120 1 0 $X=276890 $Y=192000
X56977 1 2 6947 7146 BU_5VX1 $T=285160 313600 1 0 $X=284730 $Y=308480
X56978 1 2 9901 9502 BU_5VX1 $T=287400 331520 1 0 $X=286970 $Y=326400
X56979 1 2 6133 7140 BU_5VX1 $T=287960 313600 1 0 $X=287530 $Y=308480
X56980 1 2 7153 6967 BU_5VX1 $T=294120 295680 0 0 $X=293690 $Y=295040
X56981 1 2 6957 7205 BU_5VX1 $T=296920 295680 0 0 $X=296490 $Y=295040
X56982 1 2 7146 7026 BU_5VX1 $T=298600 313600 0 0 $X=298170 $Y=312960
X56983 1 2 7168 6963 BU_5VX1 $T=299720 295680 0 0 $X=299290 $Y=295040
X56984 1 2 7224 7161 BU_5VX1 $T=302520 295680 0 0 $X=302090 $Y=295040
X56985 1 2 6904 7160 BU_5VX1 $T=303640 206080 1 0 $X=303210 $Y=200960
X56986 1 2 6233 7236 BU_5VX1 $T=306440 206080 1 0 $X=306010 $Y=200960
X56987 1 2 7205 7196 BU_5VX1 $T=307000 304640 0 0 $X=306570 $Y=304000
X56988 1 2 7245 7233 BU_5VX1 $T=307560 179200 0 0 $X=307130 $Y=178560
X56989 1 2 9536 6927 BU_5VX1 $T=307560 286720 1 0 $X=307130 $Y=281600
X56990 1 2 6987 7238 BU_5VX1 $T=309800 286720 0 0 $X=309370 $Y=286080
X56991 1 2 7125 6427 BU_5VX1 $T=310360 286720 1 0 $X=309930 $Y=281600
X56992 1 2 7163 6006 BU_5VX1 $T=310920 304640 1 0 $X=310490 $Y=299520
X56993 1 2 6454 7167 BU_5VX1 $T=312600 286720 0 0 $X=312170 $Y=286080
X56994 1 2 7052 7232 BU_5VX1 $T=313160 215040 1 0 $X=312730 $Y=209920
X56995 1 2 9291 9902 BU_5VX1 $T=316520 295680 1 0 $X=316090 $Y=290560
X56996 1 2 6469 7259 BU_5VX1 $T=317640 215040 0 0 $X=317210 $Y=214400
X56997 1 2 9902 7299 BU_5VX1 $T=319320 295680 1 0 $X=318890 $Y=290560
X56998 1 2 6855 7336 BU_5VX1 $T=320440 215040 0 0 $X=320010 $Y=214400
X56999 1 2 7295 7301 BU_5VX1 $T=320440 224000 1 0 $X=320010 $Y=218880
X57000 1 2 7107 7302 BU_5VX1 $T=320440 277760 1 0 $X=320010 $Y=272640
X57001 1 2 7291 7252 BU_5VX1 $T=322120 277760 0 0 $X=321690 $Y=277120
X57002 1 2 7307 7284 BU_5VX1 $T=323240 224000 1 0 $X=322810 $Y=218880
X57003 1 2 6134 7221 BU_5VX1 $T=323240 277760 1 0 $X=322810 $Y=272640
X57004 1 2 7296 6821 BU_5VX1 $T=324920 277760 0 0 $X=324490 $Y=277120
X57005 1 2 7302 7210 BU_5VX1 $T=327160 286720 0 0 $X=326730 $Y=286080
X57006 1 2 9236 7134 BU_5VX1 $T=327720 277760 0 0 $X=327290 $Y=277120
X57007 1 2 7336 7269 BU_5VX1 $T=329960 197120 0 0 $X=329530 $Y=196480
X57008 1 2 7357 7285 BU_5VX1 $T=333880 232960 1 0 $X=333450 $Y=227840
X57009 1 2 7353 7202 BU_5VX1 $T=334440 277760 1 0 $X=334010 $Y=272640
X57010 1 2 7331 7156 BU_5VX1 $T=338920 62720 0 0 $X=338490 $Y=62080
X57011 1 2 6929 7162 BU_5VX1 $T=340040 268800 0 0 $X=339610 $Y=268160
X57012 1 2 7403 7142 BU_5VX1 $T=344520 224000 1 0 $X=344090 $Y=218880
X57013 1 2 6503 7223 BU_5VX1 $T=347880 241920 0 0 $X=347450 $Y=241280
X57014 1 2 615 7366 BU_5VX1 $T=348440 170240 1 0 $X=348010 $Y=165120
X57015 1 2 6394 7219 BU_5VX1 $T=360200 232960 0 0 $X=359770 $Y=232320
X57016 1 2 7583 7581 BU_5VX1 $T=396600 89600 0 180 $X=393370 $Y=84480
X57017 1 2 7584 9649 BU_5VX1 $T=396600 188160 1 180 $X=393370 $Y=187520
X57018 1 2 7592 9893 BU_5VX1 $T=402200 232960 1 0 $X=401770 $Y=227840
X57019 1 2 7629 7637 BU_5VX1 $T=412840 89600 1 0 $X=412410 $Y=84480
X57020 1 2 7271 7687 BU_5VX1 $T=427400 134400 1 0 $X=426970 $Y=129280
X57021 1 2 7414 7928 BU_5VX1 $T=524840 44800 1 0 $X=524410 $Y=39680
X57022 1 2 7928 7920 BU_5VX1 $T=527640 44800 1 0 $X=527210 $Y=39680
X57023 1 2 7942 908 BU_5VX2 $T=-566600 179200 0 0 $X=-567030 $Y=178560
X57024 1 2 7946 7949 BU_5VX2 $T=-564920 98560 0 0 $X=-565350 $Y=97920
X57025 1 2 923 7945 BU_5VX2 $T=-557080 89600 1 0 $X=-557510 $Y=84480
X57026 1 2 888 7959 BU_5VX2 $T=-555960 241920 1 0 $X=-556390 $Y=236800
X57027 1 2 1285 1297 BU_5VX2 $T=-494920 107520 0 0 $X=-495350 $Y=106880
X57028 1 2 8074 1746 BU_5VX2 $T=-487080 143360 1 0 $X=-487510 $Y=138240
X57029 1 2 1351 8079 BU_5VX2 $T=-484840 71680 1 0 $X=-485270 $Y=66560
X57030 1 2 1596 1489 BU_5VX2 $T=-446200 215040 1 0 $X=-446630 $Y=209920
X57031 1 2 1641 8155 BU_5VX2 $T=-439480 35840 1 0 $X=-439910 $Y=30720
X57032 1 2 1696 1717 BU_5VX2 $T=-433880 277760 1 0 $X=-434310 $Y=272640
X57033 1 2 1793 2154 BU_5VX2 $T=-421560 313600 1 0 $X=-421990 $Y=308480
X57034 1 2 2112 1792 BU_5VX2 $T=-382920 277760 0 0 $X=-383350 $Y=277120
X57035 1 2 8277 2155 BU_5VX2 $T=-371160 44800 1 0 $X=-371590 $Y=39680
X57036 1 2 2291 8300 BU_5VX2 $T=-348200 197120 1 0 $X=-348630 $Y=192000
X57037 1 2 2295 8320 BU_5VX2 $T=-347640 349440 0 0 $X=-348070 $Y=348800
X57038 1 2 2303 2323 BU_5VX2 $T=-347080 367360 1 0 $X=-347510 $Y=362240
X57039 1 2 2308 2322 BU_5VX2 $T=-346520 286720 0 0 $X=-346950 $Y=286080
X57040 1 2 2316 2326 BU_5VX2 $T=-345960 277760 1 0 $X=-346390 $Y=272640
X57041 1 2 8300 8308 BU_5VX2 $T=-344840 206080 1 0 $X=-345270 $Y=200960
X57042 1 2 2356 2373 BU_5VX2 $T=-340360 250880 1 0 $X=-340790 $Y=245760
X57043 1 2 2385 2403 BU_5VX2 $T=-337560 394240 1 0 $X=-337990 $Y=389120
X57044 1 2 8321 2448 BU_5VX2 $T=-332520 215040 1 0 $X=-332950 $Y=209920
X57045 1 2 2402 2450 BU_5VX2 $T=-331400 331520 1 0 $X=-331830 $Y=326400
X57046 1 2 2441 8336 BU_5VX2 $T=-328040 215040 0 0 $X=-328470 $Y=214400
X57047 1 2 2401 2492 BU_5VX2 $T=-323000 322560 0 0 $X=-323430 $Y=321920
X57048 1 2 2510 2530 BU_5VX2 $T=-322440 188160 1 0 $X=-322870 $Y=183040
X57049 1 2 43 118 BU_5VX2 $T=-308440 143360 1 0 $X=-308870 $Y=138240
X57050 1 2 8367 2595 BU_5VX2 $T=-298920 376320 0 0 $X=-299350 $Y=375680
X57051 1 2 2699 2526 BU_5VX2 $T=-297800 349440 0 0 $X=-298230 $Y=348800
X57052 1 2 2706 4149 BU_5VX2 $T=-297240 250880 1 0 $X=-297670 $Y=245760
X57053 1 2 2615 2730 BU_5VX2 $T=-295000 215040 0 0 $X=-295430 $Y=214400
X57054 1 2 8428 1897 BU_5VX2 $T=-273160 206080 0 0 $X=-273590 $Y=205440
X57055 1 2 2728 2784 BU_5VX2 $T=-270920 313600 1 0 $X=-271350 $Y=308480
X57056 1 2 2924 151 BU_5VX2 $T=-265320 98560 0 0 $X=-265750 $Y=97920
X57057 1 2 2898 152 BU_5VX2 $T=-263080 179200 0 0 $X=-263510 $Y=178560
X57058 1 2 3049 1875 BU_5VX2 $T=-248520 125440 0 0 $X=-248950 $Y=124800
X57059 1 2 3051 2135 BU_5VX2 $T=-248520 250880 0 0 $X=-248950 $Y=250240
X57060 1 2 3054 3067 BU_5VX2 $T=-247960 304640 0 0 $X=-248390 $Y=304000
X57061 1 2 3059 3079 BU_5VX2 $T=-246840 241920 1 0 $X=-247270 $Y=236800
X57062 1 2 3072 3089 BU_5VX2 $T=-245160 250880 1 0 $X=-245590 $Y=245760
X57063 1 2 2192 3142 BU_5VX2 $T=-238440 268800 1 0 $X=-238870 $Y=263680
X57064 1 2 3126 3143 BU_5VX2 $T=-238440 277760 1 0 $X=-238870 $Y=272640
X57065 1 2 2065 3149 BU_5VX2 $T=-238440 322560 1 0 $X=-238870 $Y=317440
X57066 1 2 3162 2950 BU_5VX2 $T=-235080 232960 1 0 $X=-235510 $Y=227840
X57067 1 2 2810 185 BU_5VX2 $T=-217720 26880 1 0 $X=-218150 $Y=21760
X57068 1 2 2963 3454 BU_5VX2 $T=-200920 206080 1 0 $X=-201350 $Y=200960
X57069 1 2 3437 1981 BU_5VX2 $T=-198120 295680 1 0 $X=-198550 $Y=290560
X57070 1 2 3381 8489 BU_5VX2 $T=-196440 268800 1 0 $X=-196870 $Y=263680
X57071 1 2 3149 3472 BU_5VX2 $T=-196440 376320 1 0 $X=-196870 $Y=371200
X57072 1 2 3534 3553 BU_5VX2 $T=-187480 53760 0 0 $X=-187910 $Y=53120
X57073 1 2 3569 3265 BU_5VX2 $T=-184120 277760 1 0 $X=-184550 $Y=272640
X57074 1 2 3617 3647 BU_5VX2 $T=-178520 250880 1 0 $X=-178950 $Y=245760
X57075 1 2 3732 3650 BU_5VX2 $T=-169000 286720 1 0 $X=-169430 $Y=281600
X57076 1 2 3530 3217 BU_5VX2 $T=-167880 322560 0 0 $X=-168310 $Y=321920
X57077 1 2 3651 2108 BU_5VX2 $T=-167320 358400 1 0 $X=-167750 $Y=353280
X57078 1 2 3771 3785 BU_5VX2 $T=-163960 304640 0 0 $X=-164390 $Y=304000
X57079 1 2 17 3803 BU_5VX2 $T=-161720 313600 1 0 $X=-162150 $Y=308480
X57080 1 2 4317 4588 BU_5VX2 $T=-160600 358400 1 0 $X=-161030 $Y=353280
X57081 1 2 3802 3834 BU_5VX2 $T=-160040 241920 0 0 $X=-160470 $Y=241280
X57082 1 2 3829 3849 BU_5VX2 $T=-157800 394240 1 0 $X=-158230 $Y=389120
X57083 1 2 1661 2963 BU_5VX2 $T=-147720 215040 1 0 $X=-148150 $Y=209920
X57084 1 2 3991 4006 BU_5VX2 $T=-141000 107520 0 0 $X=-141430 $Y=106880
X57085 1 2 8724 8732 BU_5VX2 $T=-139320 322560 0 0 $X=-139750 $Y=321920
X57086 1 2 4051 3629 BU_5VX2 $T=-134280 340480 0 0 $X=-134710 $Y=339840
X57087 1 2 4043 4103 BU_5VX2 $T=-132040 241920 1 0 $X=-132470 $Y=236800
X57088 1 2 4145 4164 BU_5VX2 $T=-122520 358400 1 0 $X=-122950 $Y=353280
X57089 1 2 4201 3771 BU_5VX2 $T=-116360 277760 1 0 $X=-116790 $Y=272640
X57090 1 2 3843 4185 BU_5VX2 $T=-115800 26880 0 0 $X=-116230 $Y=26240
X57091 1 2 4300 4317 BU_5VX2 $T=-97880 358400 0 0 $X=-98310 $Y=357760
X57092 1 2 4261 4298 BU_5VX2 $T=-88920 224000 1 0 $X=-89350 $Y=218880
X57093 1 2 3923 4426 BU_5VX2 $T=-83880 80640 0 0 $X=-84310 $Y=80000
X57094 1 2 3785 3437 BU_5VX2 $T=-83320 376320 0 0 $X=-83750 $Y=375680
X57095 1 2 4657 318 BU_5VX2 $T=-81640 89600 1 0 $X=-82070 $Y=84480
X57096 1 2 4283 4254 BU_5VX2 $T=-68760 412160 1 0 $X=-69190 $Y=407040
X57097 1 2 4588 8865 BU_5VX2 $T=-62600 385280 1 0 $X=-63030 $Y=380160
X57098 1 2 357 4257 BU_5VX2 $T=-53080 17920 0 0 $X=-53510 $Y=17280
X57099 1 2 320 360 BU_5VX2 $T=-50840 62720 1 0 $X=-51270 $Y=57600
X57100 1 2 4709 4253 BU_5VX2 $T=-46920 394240 0 0 $X=-47350 $Y=393600
X57101 1 2 4718 4236 BU_5VX2 $T=-45240 107520 1 0 $X=-45670 $Y=102400
X57102 1 2 3314 4292 BU_5VX2 $T=-36840 80640 1 0 $X=-37270 $Y=75520
X57103 1 2 4582 4541 BU_5VX2 $T=-19480 152320 1 0 $X=-19910 $Y=147200
X57104 1 2 4293 4964 BU_5VX2 $T=-18920 116480 0 0 $X=-19350 $Y=115840
X57105 1 2 4435 4799 BU_5VX2 $T=-15000 152320 0 0 $X=-15430 $Y=151680
X57106 1 2 754 4627 BU_5VX2 $T=-15000 161280 1 0 $X=-15430 $Y=156160
X57107 1 2 4157 4248 BU_5VX2 $T=-9960 215040 0 0 $X=-10390 $Y=214400
X57108 1 2 4670 5038 BU_5VX2 $T=-8840 412160 1 0 $X=-9270 $Y=407040
X57109 1 2 4294 386 BU_5VX2 $T=-8280 116480 0 0 $X=-8710 $Y=115840
X57110 1 2 4276 4205 BU_5VX2 $T=-7720 107520 0 0 $X=-8150 $Y=106880
X57111 1 2 4100 4260 BU_5VX2 $T=-3800 161280 0 0 $X=-4230 $Y=160640
X57112 1 2 4614 4013 BU_5VX2 $T=-1560 250880 0 0 $X=-1990 $Y=250240
X57113 1 2 4006 4242 BU_5VX2 $T=2920 179200 1 0 $X=2490 $Y=174080
X57114 1 2 5123 769 BU_5VX2 $T=4600 44800 1 0 $X=4170 $Y=39680
X57115 1 2 4037 4239 BU_5VX2 $T=8520 107520 0 0 $X=8090 $Y=106880
X57116 1 2 9011 4595 BU_5VX2 $T=9080 421120 1 0 $X=8650 $Y=416000
X57117 1 2 4182 4300 BU_5VX2 $T=9640 188160 1 0 $X=9210 $Y=183040
X57118 1 2 4304 3072 BU_5VX2 $T=18040 161280 0 0 $X=17610 $Y=160640
X57119 1 2 4426 4241 BU_5VX2 $T=19160 143360 1 0 $X=18730 $Y=138240
X57120 1 2 4214 4194 BU_5VX2 $T=27560 188160 1 0 $X=27130 $Y=183040
X57121 1 2 5341 5222 BU_5VX2 $T=30360 322560 0 0 $X=29930 $Y=321920
X57122 1 2 3089 3051 BU_5VX2 $T=41000 241920 0 0 $X=40570 $Y=241280
X57123 1 2 5368 9087 BU_5VX2 $T=42680 304640 0 0 $X=42250 $Y=304000
X57124 1 2 5430 9866 BU_5VX2 $T=60600 313600 1 0 $X=60170 $Y=308480
X57125 1 2 5742 5591 BU_5VX2 $T=76280 322560 0 0 $X=75850 $Y=321920
X57126 1 2 5836 5908 BU_5VX2 $T=94200 125440 1 0 $X=93770 $Y=120320
X57127 1 2 6093 6231 BU_5VX2 $T=134520 224000 1 0 $X=134090 $Y=218880
X57128 1 2 443 6360 BU_5VX2 $T=162520 44800 0 0 $X=162090 $Y=44160
X57129 1 2 6814 6438 BU_5VX2 $T=218520 385280 0 0 $X=218090 $Y=384640
X57130 1 2 5449 6753 BU_5VX2 $T=231960 376320 0 0 $X=231530 $Y=375680
X57131 1 2 5667 6936 BU_5VX2 $T=254360 358400 1 0 $X=253930 $Y=353280
X57132 1 2 5668 7015 BU_5VX2 $T=264440 349440 1 0 $X=264010 $Y=344320
X57133 1 2 7123 7025 BU_5VX2 $T=269480 206080 1 0 $X=269050 $Y=200960
X57134 1 2 9533 7247 BU_5VX2 $T=306440 295680 1 0 $X=306010 $Y=290560
X57135 1 2 7183 7243 BU_5VX2 $T=315960 286720 1 0 $X=315530 $Y=281600
X57136 1 2 7157 9533 BU_5VX2 $T=322120 295680 1 0 $X=321690 $Y=290560
X57137 1 2 7337 7036 BU_5VX2 $T=330520 277760 0 0 $X=330090 $Y=277120
X57138 1 2 7165 9536 BU_5VX2 $T=330520 286720 1 0 $X=330090 $Y=281600
X57139 1 2 7360 6462 BU_5VX2 $T=334440 277760 0 0 $X=334010 $Y=277120
X57140 1 2 7637 7632 BU_5VX2 $T=424600 98560 1 0 $X=424170 $Y=93440
X57141 1 2 9562 7674 BU_5VX2 $T=439160 44800 0 0 $X=438730 $Y=44160
X57142 1 2 828 814 BU_5VX0 $T=-592920 152320 1 0 $X=-593350 $Y=147200
X57143 1 2 832 7933 BU_5VX0 $T=-591240 161280 1 0 $X=-591670 $Y=156160
X57144 1 2 875 833 BU_5VX0 $T=-578920 125440 0 0 $X=-579350 $Y=124800
X57145 1 2 917 1001 BU_5VX0 $T=-549800 268800 1 0 $X=-550230 $Y=263680
X57146 1 2 7982 7991 BU_5VX0 $T=-538040 116480 1 0 $X=-538470 $Y=111360
X57147 1 2 1155 1163 BU_5VX0 $T=-516200 44800 1 0 $X=-516630 $Y=39680
X57148 1 2 1176 998 BU_5VX0 $T=-513400 98560 1 0 $X=-513830 $Y=93440
X57149 1 2 1210 1014 BU_5VX0 $T=-507800 80640 0 0 $X=-508230 $Y=80000
X57150 1 2 1319 8067 BU_5VX0 $T=-491000 232960 1 0 $X=-491430 $Y=227840
X57151 1 2 1525 1542 BU_5VX0 $T=-456840 232960 1 0 $X=-457270 $Y=227840
X57152 1 2 1557 1580 BU_5VX0 $T=-451800 358400 0 0 $X=-452230 $Y=357760
X57153 1 2 8130 1545 BU_5VX0 $T=-451240 349440 1 0 $X=-451670 $Y=344320
X57154 1 2 1590 8131 BU_5VX0 $T=-448440 367360 1 0 $X=-448870 $Y=362240
X57155 1 2 1642 1656 BU_5VX0 $T=-439480 62720 1 0 $X=-439910 $Y=57600
X57156 1 2 1675 1691 BU_5VX0 $T=-436680 331520 1 0 $X=-437110 $Y=326400
X57157 1 2 1738 1657 BU_5VX0 $T=-427160 107520 1 0 $X=-427590 $Y=102400
X57158 1 2 8195 1787 BU_5VX0 $T=-418200 134400 0 0 $X=-418630 $Y=133760
X57159 1 2 1855 1862 BU_5VX0 $T=-413160 304640 1 0 $X=-413590 $Y=299520
X57160 1 2 1946 9825 BU_5VX0 $T=-401960 376320 0 0 $X=-402390 $Y=375680
X57161 1 2 1969 1701 BU_5VX0 $T=-399720 331520 0 0 $X=-400150 $Y=330880
X57162 1 2 2486 1963 BU_5VX0 $T=-398040 250880 1 0 $X=-398470 $Y=245760
X57163 1 2 1924 8249 BU_5VX0 $T=-389080 376320 1 0 $X=-389510 $Y=371200
X57164 1 2 1927 2045 BU_5VX0 $T=-386280 197120 1 0 $X=-386710 $Y=192000
X57165 1 2 2127 8171 BU_5VX0 $T=-381240 322560 0 0 $X=-381670 $Y=321920
X57166 1 2 2119 2159 BU_5VX0 $T=-379000 179200 0 0 $X=-379430 $Y=178560
X57167 1 2 8265 2161 BU_5VX0 $T=-379000 232960 1 0 $X=-379430 $Y=227840
X57168 1 2 2155 2177 BU_5VX0 $T=-377320 62720 0 0 $X=-377750 $Y=62080
X57169 1 2 8289 2263 BU_5VX0 $T=-364440 125440 0 0 $X=-364870 $Y=124800
X57170 1 2 2244 2273 BU_5VX0 $T=-364440 277760 0 0 $X=-364870 $Y=277120
X57171 1 2 2317 2491 BU_5VX0 $T=-346520 295680 1 0 $X=-346950 $Y=290560
X57172 1 2 2429 8322 BU_5VX0 $T=-332520 313600 0 0 $X=-332950 $Y=312960
X57173 1 2 2481 2494 BU_5VX0 $T=-326360 412160 0 0 $X=-326790 $Y=411520
X57174 1 2 2484 8339 BU_5VX0 $T=-325240 125440 1 0 $X=-325670 $Y=120320
X57175 1 2 3010 2311 BU_5VX0 $T=-323560 412160 0 0 $X=-323990 $Y=411520
X57176 1 2 2553 2380 BU_5VX0 $T=-320760 412160 0 0 $X=-321190 $Y=411520
X57177 1 2 2567 2455 BU_5VX0 $T=-315720 206080 0 0 $X=-316150 $Y=205440
X57178 1 2 2586 2836 BU_5VX0 $T=-312360 161280 1 0 $X=-312790 $Y=156160
X57179 1 2 2610 3223 BU_5VX0 $T=-308440 224000 1 0 $X=-308870 $Y=218880
X57180 1 2 2674 2688 BU_5VX0 $T=-300040 170240 0 0 $X=-300470 $Y=169600
X57181 1 2 2648 2674 BU_5VX0 $T=-296680 179200 1 0 $X=-297110 $Y=174080
X57182 1 2 2744 2757 BU_5VX0 $T=-289960 241920 0 0 $X=-290390 $Y=241280
X57183 1 2 2755 2766 BU_5VX0 $T=-288840 188160 0 0 $X=-289270 $Y=187520
X57184 1 2 9897 8410 BU_5VX0 $T=-283240 206080 0 0 $X=-283670 $Y=205440
X57185 1 2 2631 2700 BU_5VX0 $T=-282680 412160 1 0 $X=-283110 $Y=407040
X57186 1 2 2826 2734 BU_5VX0 $T=-279880 394240 0 0 $X=-280310 $Y=393600
X57187 1 2 2598 2849 BU_5VX0 $T=-277640 188160 0 0 $X=-278070 $Y=187520
X57188 1 2 1930 8754 BU_5VX0 $T=-275960 125440 1 0 $X=-276390 $Y=120320
X57189 1 2 142 2883 BU_5VX0 $T=-272600 71680 1 0 $X=-273030 $Y=66560
X57190 1 2 145 2902 BU_5VX0 $T=-270360 143360 0 0 $X=-270790 $Y=142720
X57191 1 2 2889 2566 BU_5VX0 $T=-270360 188160 0 0 $X=-270790 $Y=187520
X57192 1 2 2892 2904 BU_5VX0 $T=-270360 394240 0 0 $X=-270790 $Y=393600
X57193 1 2 2903 2915 BU_5VX0 $T=-268680 188160 1 0 $X=-269110 $Y=183040
X57194 1 2 2952 2964 BU_5VX0 $T=-261960 286720 1 0 $X=-262390 $Y=281600
X57195 1 2 3014 2943 BU_5VX0 $T=-253000 277760 0 0 $X=-253430 $Y=277120
X57196 1 2 160 3055 BU_5VX0 $T=-249080 80640 0 0 $X=-249510 $Y=80000
X57197 1 2 39 3070 BU_5VX0 $T=-247400 107520 1 0 $X=-247830 $Y=102400
X57198 1 2 39 2736 BU_5VX0 $T=-245720 134400 0 0 $X=-246150 $Y=133760
X57199 1 2 3172 2906 BU_5VX0 $T=-233400 152320 0 0 $X=-233830 $Y=151680
X57200 1 2 2473 181 BU_5VX0 $T=-231720 71680 0 0 $X=-232150 $Y=71040
X57201 1 2 1982 3216 BU_5VX0 $T=-228920 161280 0 0 $X=-229350 $Y=160640
X57202 1 2 2906 4250 BU_5VX0 $T=-227240 232960 1 0 $X=-227670 $Y=227840
X57203 1 2 1030 3237 BU_5VX0 $T=-226120 116480 1 0 $X=-226550 $Y=111360
X57204 1 2 3231 3239 BU_5VX0 $T=-225000 152320 0 0 $X=-225430 $Y=151680
X57205 1 2 3240 8607 BU_5VX0 $T=-223880 170240 1 0 $X=-224310 $Y=165120
X57206 1 2 3157 8535 BU_5VX0 $T=-221080 241920 1 0 $X=-221510 $Y=236800
X57207 1 2 3268 3073 BU_5VX0 $T=-221080 340480 1 0 $X=-221510 $Y=335360
X57208 1 2 3055 3314 BU_5VX0 $T=-213800 107520 1 0 $X=-214230 $Y=102400
X57209 1 2 2803 734 BU_5VX0 $T=-212680 17920 0 0 $X=-213110 $Y=17280
X57210 1 2 3326 3336 BU_5VX0 $T=-211560 179200 0 0 $X=-211990 $Y=178560
X57211 1 2 3341 3411 BU_5VX0 $T=-208760 358400 1 0 $X=-209190 $Y=353280
X57212 1 2 3352 3367 BU_5VX0 $T=-206520 170240 1 0 $X=-206950 $Y=165120
X57213 1 2 3407 3376 BU_5VX0 $T=-205960 125440 0 0 $X=-206390 $Y=124800
X57214 1 2 3359 3377 BU_5VX0 $T=-205960 197120 0 0 $X=-206390 $Y=196480
X57215 1 2 8579 3391 BU_5VX0 $T=-204280 62720 0 0 $X=-204710 $Y=62080
X57216 1 2 2530 3403 BU_5VX0 $T=-202600 206080 0 0 $X=-203030 $Y=205440
X57217 1 2 2222 3458 BU_5VX0 $T=-198120 385280 1 0 $X=-198550 $Y=380160
X57218 1 2 3027 8579 BU_5VX0 $T=-196440 62720 0 0 $X=-196870 $Y=62080
X57219 1 2 8600 8604 BU_5VX0 $T=-196440 232960 1 0 $X=-196870 $Y=227840
X57220 1 2 3477 3490 BU_5VX0 $T=-194200 125440 1 0 $X=-194630 $Y=120320
X57221 1 2 8607 3491 BU_5VX0 $T=-194200 170240 1 0 $X=-194630 $Y=165120
X57222 1 2 3185 3189 BU_5VX0 $T=-193080 206080 1 0 $X=-193510 $Y=200960
X57223 1 2 3499 3126 BU_5VX0 $T=-191960 304640 1 0 $X=-192390 $Y=299520
X57224 1 2 3458 3687 BU_5VX0 $T=-190840 385280 1 0 $X=-191270 $Y=380160
X57225 1 2 3511 3532 BU_5VX0 $T=-189720 412160 1 0 $X=-190150 $Y=407040
X57226 1 2 3384 3536 BU_5VX0 $T=-189160 161280 0 0 $X=-189590 $Y=160640
X57227 1 2 3490 8649 BU_5VX0 $T=-188600 152320 1 0 $X=-189030 $Y=147200
X57228 1 2 3528 3551 BU_5VX0 $T=-188040 295680 1 0 $X=-188470 $Y=290560
X57229 1 2 3431 3552 BU_5VX0 $T=-188040 331520 0 0 $X=-188470 $Y=330880
X57230 1 2 3537 8636 BU_5VX0 $T=-187480 367360 0 0 $X=-187910 $Y=366720
X57231 1 2 3557 736 BU_5VX0 $T=-186920 250880 0 0 $X=-187350 $Y=250240
X57232 1 2 3542 3541 BU_5VX0 $T=-186920 277760 1 0 $X=-187350 $Y=272640
X57233 1 2 3568 3597 BU_5VX0 $T=-184120 250880 0 0 $X=-184550 $Y=250240
X57234 1 2 3573 3593 BU_5VX0 $T=-183560 53760 0 0 $X=-183990 $Y=53120
X57235 1 2 3588 8631 BU_5VX0 $T=-182440 206080 0 0 $X=-182870 $Y=205440
X57236 1 2 3589 3605 BU_5VX0 $T=-182440 215040 0 0 $X=-182870 $Y=214400
X57237 1 2 3536 8640 BU_5VX0 $T=-181880 179200 1 0 $X=-182310 $Y=174080
X57238 1 2 2876 3589 BU_5VX0 $T=-181880 224000 0 0 $X=-182310 $Y=223360
X57239 1 2 8636 3630 BU_5VX0 $T=-180760 367360 0 0 $X=-181190 $Y=366720
X57240 1 2 227 8657 BU_5VX0 $T=-180200 17920 1 0 $X=-180630 $Y=12800
X57241 1 2 3620 3568 BU_5VX0 $T=-179080 412160 1 0 $X=-179510 $Y=407040
X57242 1 2 3623 2562 BU_5VX0 $T=-178520 116480 0 0 $X=-178950 $Y=115840
X57243 1 2 3629 3651 BU_5VX0 $T=-178520 367360 1 0 $X=-178950 $Y=362240
X57244 1 2 3491 3633 BU_5VX0 $T=-177400 161280 1 0 $X=-177830 $Y=156160
X57245 1 2 8648 3612 BU_5VX0 $T=-176280 143360 0 0 $X=-176710 $Y=142720
X57246 1 2 8646 8648 BU_5VX0 $T=-175720 116480 0 0 $X=-176150 $Y=115840
X57247 1 2 3143 3528 BU_5VX0 $T=-175720 313600 1 0 $X=-176150 $Y=308480
X57248 1 2 3630 8664 BU_5VX0 $T=-175720 376320 1 0 $X=-176150 $Y=371200
X57249 1 2 3662 3620 BU_5VX0 $T=-175160 412160 0 0 $X=-175590 $Y=411520
X57250 1 2 3671 1986 BU_5VX0 $T=-174040 107520 0 0 $X=-174470 $Y=106880
X57251 1 2 3681 8652 BU_5VX0 $T=-173480 116480 1 0 $X=-173910 $Y=111360
X57252 1 2 3472 3499 BU_5VX0 $T=-173480 304640 0 0 $X=-173910 $Y=304000
X57253 1 2 3687 3706 BU_5VX0 $T=-173480 385280 0 0 $X=-173910 $Y=384640
X57254 1 2 233 8659 BU_5VX0 $T=-172920 17920 0 0 $X=-173350 $Y=17280
X57255 1 2 8652 9903 BU_5VX0 $T=-172920 125440 0 0 $X=-173350 $Y=124800
X57256 1 2 3692 3200 BU_5VX0 $T=-172920 206080 1 0 $X=-173350 $Y=200960
X57257 1 2 8655 9904 BU_5VX0 $T=-170680 116480 1 0 $X=-171110 $Y=111360
X57258 1 2 8664 8689 BU_5VX0 $T=-170120 376320 1 0 $X=-170550 $Y=371200
X57259 1 2 3605 3588 BU_5VX0 $T=-167320 215040 0 0 $X=-167750 $Y=214400
X57260 1 2 3593 3730 BU_5VX0 $T=-166760 62720 0 0 $X=-167190 $Y=62080
X57261 1 2 3751 3614 BU_5VX0 $T=-166760 170240 0 0 $X=-167190 $Y=169600
X57262 1 2 3754 3733 BU_5VX0 $T=-166200 35840 1 0 $X=-166630 $Y=30720
X57263 1 2 3706 8703 BU_5VX0 $T=-165080 394240 1 0 $X=-165510 $Y=389120
X57264 1 2 9905 3791 BU_5VX0 $T=-163400 215040 1 0 $X=-163830 $Y=209920
X57265 1 2 3792 3801 BU_5VX0 $T=-161160 232960 0 0 $X=-161590 $Y=232320
X57266 1 2 8689 3804 BU_5VX0 $T=-161160 376320 1 0 $X=-161590 $Y=371200
X57267 1 2 1939 3812 BU_5VX0 $T=-160600 206080 0 0 $X=-161030 $Y=205440
X57268 1 2 9906 3838 BU_5VX0 $T=-159480 152320 1 0 $X=-159910 $Y=147200
X57269 1 2 2275 3744 BU_5VX0 $T=-159480 215040 0 0 $X=-159910 $Y=214400
X57270 1 2 3819 3758 BU_5VX0 $T=-158360 80640 1 0 $X=-158790 $Y=75520
X57271 1 2 3725 3691 BU_5VX0 $T=-156120 161280 0 0 $X=-156550 $Y=160640
X57272 1 2 3840 8701 BU_5VX0 $T=-156120 313600 0 0 $X=-156550 $Y=312960
X57273 1 2 8700 3819 BU_5VX0 $T=-155560 98560 0 0 $X=-155990 $Y=97920
X57274 1 2 3393 3831 BU_5VX0 $T=-155560 179200 0 0 $X=-155990 $Y=178560
X57275 1 2 3853 3950 BU_5VX0 $T=-155560 206080 1 0 $X=-155990 $Y=200960
X57276 1 2 3788 3868 BU_5VX0 $T=-155000 62720 0 0 $X=-155430 $Y=62080
X57277 1 2 3858 3702 BU_5VX0 $T=-155000 143360 1 0 $X=-155430 $Y=138240
X57278 1 2 8703 3890 BU_5VX0 $T=-153880 331520 0 0 $X=-154310 $Y=330880
X57279 1 2 3878 261 BU_5VX0 $T=-152760 98560 0 0 $X=-153190 $Y=97920
X57280 1 2 3892 3773 BU_5VX0 $T=-151080 53760 1 0 $X=-151510 $Y=48640
X57281 1 2 3726 3640 BU_5VX0 $T=-149960 224000 1 0 $X=-150390 $Y=218880
X57282 1 2 3930 3813 BU_5VX0 $T=-147720 277760 0 0 $X=-148150 $Y=277120
X57283 1 2 8709 8717 BU_5VX0 $T=-146600 295680 1 0 $X=-147030 $Y=290560
X57284 1 2 2165 3963 BU_5VX0 $T=-146600 322560 0 0 $X=-147030 $Y=321920
X57285 1 2 3804 8719 BU_5VX0 $T=-144920 376320 0 0 $X=-145350 $Y=375680
X57286 1 2 8719 3984 BU_5VX0 $T=-143800 376320 1 0 $X=-144230 $Y=371200
X57287 1 2 4003 4015 BU_5VX0 $T=-139880 250880 1 0 $X=-140310 $Y=245760
X57288 1 2 3079 3797 BU_5VX0 $T=-138760 232960 0 0 $X=-139190 $Y=232320
X57289 1 2 4081 3983 BU_5VX0 $T=-138760 358400 0 0 $X=-139190 $Y=357760
X57290 1 2 2993 2911 BU_5VX0 $T=-137640 215040 1 0 $X=-138070 $Y=209920
X57291 1 2 4045 4059 BU_5VX0 $T=-134280 349440 0 0 $X=-134710 $Y=348800
X57292 1 2 3644 275 BU_5VX0 $T=-133720 125440 0 0 $X=-134150 $Y=124800
X57293 1 2 3938 8759 BU_5VX0 $T=-133160 107520 0 0 $X=-133590 $Y=106880
X57294 1 2 4056 8763 BU_5VX0 $T=-133160 250880 1 0 $X=-133590 $Y=245760
X57295 1 2 4071 8755 BU_5VX0 $T=-132040 376320 1 0 $X=-132470 $Y=371200
X57296 1 2 8754 4083 BU_5VX0 $T=-131480 125440 1 0 $X=-131910 $Y=120320
X57297 1 2 8755 4090 BU_5VX0 $T=-131480 385280 1 0 $X=-131910 $Y=380160
X57298 1 2 3984 4071 BU_5VX0 $T=-129800 367360 0 0 $X=-130230 $Y=366720
X57299 1 2 3796 4055 BU_5VX0 $T=-126440 179200 0 0 $X=-126870 $Y=178560
X57300 1 2 279 3534 BU_5VX0 $T=-125320 80640 1 0 $X=-125750 $Y=75520
X57301 1 2 3553 4082 BU_5VX0 $T=-123640 71680 0 0 $X=-124070 $Y=71040
X57302 1 2 4108 4046 BU_5VX0 $T=-123640 206080 1 0 $X=-124070 $Y=200960
X57303 1 2 4146 4123 BU_5VX0 $T=-122520 367360 1 0 $X=-122950 $Y=362240
X57304 1 2 4681 4159 BU_5VX0 $T=-122520 376320 1 0 $X=-122950 $Y=371200
X57305 1 2 4147 4165 BU_5VX0 $T=-122520 394240 1 0 $X=-122950 $Y=389120
X57306 1 2 4151 4174 BU_5VX0 $T=-121960 286720 0 0 $X=-122390 $Y=286080
X57307 1 2 4163 4051 BU_5VX0 $T=-120840 206080 0 0 $X=-121270 $Y=205440
X57308 1 2 8783 9851 BU_5VX0 $T=-118600 241920 1 0 $X=-119030 $Y=236800
X57309 1 2 4144 8794 BU_5VX0 $T=-116920 259840 0 0 $X=-117350 $Y=259200
X57310 1 2 4205 4111 BU_5VX0 $T=-115800 107520 0 0 $X=-116230 $Y=106880
X57311 1 2 4212 4211 BU_5VX0 $T=-114680 152320 1 0 $X=-115110 $Y=147200
X57312 1 2 4213 294 BU_5VX0 $T=-114680 215040 1 0 $X=-115110 $Y=209920
X57313 1 2 8795 300 BU_5VX0 $T=-106280 26880 0 0 $X=-106710 $Y=26240
X57314 1 2 296 4266 BU_5VX0 $T=-106280 53760 1 0 $X=-106710 $Y=48640
X57315 1 2 747 3671 BU_5VX0 $T=-106280 62720 0 0 $X=-106710 $Y=62080
X57316 1 2 8796 747 BU_5VX0 $T=-106280 71680 1 0 $X=-106710 $Y=66560
X57317 1 2 297 4132 BU_5VX0 $T=-106280 71680 0 0 $X=-106710 $Y=71040
X57318 1 2 298 3172 BU_5VX0 $T=-106280 80640 1 0 $X=-106710 $Y=75520
X57319 1 2 3070 8796 BU_5VX0 $T=-106280 80640 0 0 $X=-106710 $Y=80000
X57320 1 2 4236 4275 BU_5VX0 $T=-106280 89600 1 0 $X=-106710 $Y=84480
X57321 1 2 4237 4240 BU_5VX0 $T=-106280 89600 0 0 $X=-106710 $Y=88960
X57322 1 2 3541 1973 BU_5VX0 $T=-106280 98560 1 0 $X=-106710 $Y=93440
X57323 1 2 4238 3975 BU_5VX0 $T=-106280 98560 0 0 $X=-106710 $Y=97920
X57324 1 2 4257 8809 BU_5VX0 $T=-106280 107520 1 0 $X=-106710 $Y=102400
X57325 1 2 4239 4276 BU_5VX0 $T=-106280 107520 0 0 $X=-106710 $Y=106880
X57326 1 2 4258 4291 BU_5VX0 $T=-106280 116480 1 0 $X=-106710 $Y=111360
X57327 1 2 3893 4304 BU_5VX0 $T=-106280 116480 0 0 $X=-106710 $Y=115840
X57328 1 2 4083 4120 BU_5VX0 $T=-106280 125440 1 0 $X=-106710 $Y=120320
X57329 1 2 299 4293 BU_5VX0 $T=-106280 125440 0 0 $X=-106710 $Y=124800
X57330 1 2 4964 303 BU_5VX0 $T=-106280 134400 1 0 $X=-106710 $Y=129280
X57331 1 2 1973 4238 BU_5VX0 $T=-106280 134400 0 0 $X=-106710 $Y=133760
X57332 1 2 4240 4294 BU_5VX0 $T=-106280 143360 1 0 $X=-106710 $Y=138240
X57333 1 2 5388 4201 BU_5VX0 $T=-106280 143360 0 0 $X=-106710 $Y=142720
X57334 1 2 4241 304 BU_5VX0 $T=-106280 152320 1 0 $X=-106710 $Y=147200
X57335 1 2 4242 4312 BU_5VX0 $T=-106280 152320 0 0 $X=-106710 $Y=151680
X57336 1 2 4275 4259 BU_5VX0 $T=-106280 161280 1 0 $X=-106710 $Y=156160
X57337 1 2 3284 754 BU_5VX0 $T=-106280 161280 0 0 $X=-106710 $Y=160640
X57338 1 2 4243 4643 BU_5VX0 $T=-106280 170240 1 0 $X=-106710 $Y=165120
X57339 1 2 4260 4129 BU_5VX0 $T=-106280 170240 0 0 $X=-106710 $Y=169600
X57340 1 2 8797 301 BU_5VX0 $T=-106280 179200 0 0 $X=-106710 $Y=178560
X57341 1 2 8798 4213 BU_5VX0 $T=-106280 188160 1 0 $X=-106710 $Y=183040
X57342 1 2 8799 302 BU_5VX0 $T=-106280 188160 0 0 $X=-106710 $Y=187520
X57343 1 2 8793 4191 BU_5VX0 $T=-106280 197120 1 0 $X=-106710 $Y=192000
X57344 1 2 4245 5319 BU_5VX0 $T=-106280 197120 0 0 $X=-106710 $Y=196480
X57345 1 2 4246 8803 BU_5VX0 $T=-106280 206080 1 0 $X=-106710 $Y=200960
X57346 1 2 8800 4277 BU_5VX0 $T=-106280 206080 0 0 $X=-106710 $Y=205440
X57347 1 2 4140 749 BU_5VX0 $T=-106280 215040 1 0 $X=-106710 $Y=209920
X57348 1 2 4247 4267 BU_5VX0 $T=-106280 215040 0 0 $X=-106710 $Y=214400
X57349 1 2 4248 4163 BU_5VX0 $T=-106280 224000 1 0 $X=-106710 $Y=218880
X57350 1 2 4249 4062 BU_5VX0 $T=-106280 224000 0 0 $X=-106710 $Y=223360
X57351 1 2 2963 4145 BU_5VX0 $T=-106280 232960 1 0 $X=-106710 $Y=227840
X57352 1 2 3803 4244 BU_5VX0 $T=-106280 232960 0 0 $X=-106710 $Y=232320
X57353 1 2 3142 4243 BU_5VX0 $T=-106280 241920 1 0 $X=-106710 $Y=236800
X57354 1 2 3978 3967 BU_5VX0 $T=-106280 241920 0 0 $X=-106710 $Y=241280
X57355 1 2 4262 5079 BU_5VX0 $T=-106280 259840 1 0 $X=-106710 $Y=254720
X57356 1 2 4090 4279 BU_5VX0 $T=-106280 259840 0 0 $X=-106710 $Y=259200
X57357 1 2 4174 4133 BU_5VX0 $T=-106280 277760 1 0 $X=-106710 $Y=272640
X57358 1 2 3551 4151 BU_5VX0 $T=-106280 304640 1 0 $X=-106710 $Y=299520
X57359 1 2 4252 4281 BU_5VX0 $T=-106280 313600 0 0 $X=-106710 $Y=312960
X57360 1 2 2260 4310 BU_5VX0 $T=-106280 340480 1 0 $X=-106710 $Y=335360
X57361 1 2 3890 4045 BU_5VX0 $T=-106280 340480 0 0 $X=-106710 $Y=339840
X57362 1 2 4253 4283 BU_5VX0 $T=-106280 349440 0 0 $X=-106710 $Y=348800
X57363 1 2 4254 3829 BU_5VX0 $T=-106280 358400 1 0 $X=-106710 $Y=353280
X57364 1 2 3849 4284 BU_5VX0 $T=-106280 358400 0 0 $X=-106710 $Y=357760
X57365 1 2 8791 4278 BU_5VX0 $T=-106280 403200 1 0 $X=-106710 $Y=398080
X57366 1 2 4292 4349 BU_5VX0 $T=-97880 116480 0 0 $X=-98310 $Y=115840
X57367 1 2 4149 4011 BU_5VX0 $T=-97880 241920 1 0 $X=-98310 $Y=236800
X57368 1 2 8809 4321 BU_5VX0 $T=-97320 107520 0 0 $X=-97750 $Y=106880
X57369 1 2 4284 4328 BU_5VX0 $T=-97320 232960 1 0 $X=-97750 $Y=227840
X57370 1 2 4310 4323 BU_5VX0 $T=-97320 340480 0 0 $X=-97750 $Y=339840
X57371 1 2 4209 4396 BU_5VX0 $T=-87240 197120 1 0 $X=-87670 $Y=192000
X57372 1 2 4408 4318 BU_5VX0 $T=-83320 403200 0 0 $X=-83750 $Y=402560
X57373 1 2 4421 4435 BU_5VX0 $T=-81640 170240 0 0 $X=-82070 $Y=169600
X57374 1 2 4430 4446 BU_5VX0 $T=-81080 304640 1 0 $X=-81510 $Y=299520
X57375 1 2 317 4258 BU_5VX0 $T=-80520 134400 1 0 $X=-80950 $Y=129280
X57376 1 2 4415 4451 BU_5VX0 $T=-79960 143360 1 0 $X=-80390 $Y=138240
X57377 1 2 4453 4462 BU_5VX0 $T=-78840 259840 0 0 $X=-79270 $Y=259200
X57378 1 2 4422 4566 BU_5VX0 $T=-68200 313600 1 0 $X=-68630 $Y=308480
X57379 1 2 4544 4558 BU_5VX0 $T=-67640 331520 1 0 $X=-68070 $Y=326400
X57380 1 2 4579 8883 BU_5VX0 $T=-64280 331520 0 0 $X=-64710 $Y=330880
X57381 1 2 4593 4573 BU_5VX0 $T=-62040 188160 1 0 $X=-62470 $Y=183040
X57382 1 2 4595 4614 BU_5VX0 $T=-62040 358400 1 0 $X=-62470 $Y=353280
X57383 1 2 4627 4341 BU_5VX0 $T=-58680 188160 0 0 $X=-59110 $Y=187520
X57384 1 2 4639 4544 BU_5VX0 $T=-56440 358400 1 0 $X=-56870 $Y=353280
X57385 1 2 4647 356 BU_5VX0 $T=-55320 35840 1 0 $X=-55750 $Y=30720
X57386 1 2 8871 4526 BU_5VX0 $T=-55320 295680 1 0 $X=-55750 $Y=290560
X57387 1 2 4650 8882 BU_5VX0 $T=-55320 313600 1 0 $X=-55750 $Y=308480
X57388 1 2 4660 4670 BU_5VX0 $T=-54760 376320 1 0 $X=-55190 $Y=371200
X57389 1 2 8878 4639 BU_5VX0 $T=-50840 349440 0 0 $X=-51270 $Y=348800
X57390 1 2 4697 4660 BU_5VX0 $T=-48040 358400 1 0 $X=-48470 $Y=353280
X57391 1 2 8882 4714 BU_5VX0 $T=-47480 313600 1 0 $X=-47910 $Y=308480
X57392 1 2 8883 4650 BU_5VX0 $T=-46920 331520 0 0 $X=-47350 $Y=330880
X57393 1 2 4711 4709 BU_5VX0 $T=-46360 403200 1 0 $X=-46790 $Y=398080
X57394 1 2 4714 4212 BU_5VX0 $T=-42440 322560 1 0 $X=-42870 $Y=317440
X57395 1 2 8895 4818 BU_5VX0 $T=-42440 358400 0 0 $X=-42870 $Y=357760
X57396 1 2 4754 4600 BU_5VX0 $T=-41320 152320 0 0 $X=-41750 $Y=151680
X57397 1 2 8904 4762 BU_5VX0 $T=-36840 277760 0 0 $X=-37270 $Y=277120
X57398 1 2 4799 4350 BU_5VX0 $T=-36280 179200 1 0 $X=-36710 $Y=174080
X57399 1 2 4694 4776 BU_5VX0 $T=-35160 241920 1 0 $X=-35590 $Y=236800
X57400 1 2 4827 4843 BU_5VX0 $T=-33480 295680 0 0 $X=-33910 $Y=295040
X57401 1 2 4817 8878 BU_5VX0 $T=-33480 349440 0 0 $X=-33910 $Y=348800
X57402 1 2 8914 4697 BU_5VX0 $T=-33480 358400 0 0 $X=-33910 $Y=357760
X57403 1 2 4818 8914 BU_5VX0 $T=-32920 385280 0 0 $X=-33350 $Y=384640
X57404 1 2 4867 4711 BU_5VX0 $T=-29000 412160 1 0 $X=-29430 $Y=407040
X57405 1 2 4869 4884 BU_5VX0 $T=-28440 394240 1 0 $X=-28870 $Y=389120
X57406 1 2 4882 4817 BU_5VX0 $T=-26760 358400 0 0 $X=-27190 $Y=357760
X57407 1 2 761 4922 BU_5VX0 $T=-24520 125440 1 0 $X=-24950 $Y=120320
X57408 1 2 4919 4882 BU_5VX0 $T=-23400 367360 1 0 $X=-23830 $Y=362240
X57409 1 2 4941 8895 BU_5VX0 $T=-20040 358400 0 0 $X=-20470 $Y=357760
X57410 1 2 5076 4867 BU_5VX0 $T=-19480 412160 1 0 $X=-19910 $Y=407040
X57411 1 2 4952 5071 BU_5VX0 $T=-18920 421120 1 0 $X=-19350 $Y=416000
X57412 1 2 4989 5004 BU_5VX0 $T=-12200 206080 0 0 $X=-12630 $Y=205440
X57413 1 2 5011 4941 BU_5VX0 $T=-9960 349440 1 0 $X=-10390 $Y=344320
X57414 1 2 4164 8970 BU_5VX0 $T=-9960 349440 0 0 $X=-10390 $Y=348800
X57415 1 2 4884 8971 BU_5VX0 $T=-9960 394240 0 0 $X=-10390 $Y=393600
X57416 1 2 385 4128 BU_5VX0 $T=-8280 17920 1 0 $X=-8710 $Y=12800
X57417 1 2 8966 8973 BU_5VX0 $T=-7720 385280 1 0 $X=-8150 $Y=380160
X57418 1 2 5027 8966 BU_5VX0 $T=-7720 394240 1 0 $X=-8150 $Y=389120
X57419 1 2 8970 5043 BU_5VX0 $T=-7160 331520 0 0 $X=-7590 $Y=330880
X57420 1 2 8971 5027 BU_5VX0 $T=-7160 403200 0 0 $X=-7590 $Y=402560
X57421 1 2 8973 4919 BU_5VX0 $T=-6040 367360 0 0 $X=-6470 $Y=366720
X57422 1 2 353 5081 BU_5VX0 $T=-3800 143360 1 0 $X=-4230 $Y=138240
X57423 1 2 5071 5076 BU_5VX0 $T=-2680 412160 0 0 $X=-3110 $Y=411520
X57424 1 2 8865 4952 BU_5VX0 $T=-2120 421120 0 0 $X=-2550 $Y=420480
X57425 1 2 5105 5114 BU_5VX0 $T=1240 134400 1 0 $X=810 $Y=129280
X57426 1 2 5032 4977 BU_5VX0 $T=7400 152320 1 0 $X=6970 $Y=147200
X57427 1 2 4558 4579 BU_5VX0 $T=7400 331520 1 0 $X=6970 $Y=326400
X57428 1 2 5043 5011 BU_5VX0 $T=11320 340480 1 0 $X=10890 $Y=335360
X57429 1 2 351 5207 BU_5VX0 $T=15240 116480 1 0 $X=14810 $Y=111360
X57430 1 2 359 5310 BU_5VX0 $T=15240 116480 0 0 $X=14810 $Y=115840
X57431 1 2 5594 5249 BU_5VX0 $T=19720 89600 1 0 $X=19290 $Y=84480
X57432 1 2 366 5032 BU_5VX0 $T=22520 152320 1 0 $X=22090 $Y=147200
X57433 1 2 5269 5287 BU_5VX0 $T=23080 80640 0 0 $X=22650 $Y=80000
X57434 1 2 5310 5165 BU_5VX0 $T=27560 125440 0 0 $X=27130 $Y=124800
X57435 1 2 5351 408 BU_5VX0 $T=32600 125440 1 0 $X=32170 $Y=120320
X57436 1 2 5356 5371 BU_5VX0 $T=33160 80640 1 0 $X=32730 $Y=75520
X57437 1 2 5031 5411 BU_5VX0 $T=37080 385280 1 0 $X=36650 $Y=380160
X57438 1 2 4767 5410 BU_5VX0 $T=48840 358400 1 0 $X=48410 $Y=353280
X57439 1 2 5539 4237 BU_5VX0 $T=53880 116480 1 0 $X=53450 $Y=111360
X57440 1 2 5287 5478 BU_5VX0 $T=56120 80640 1 0 $X=55690 $Y=75520
X57441 1 2 5355 5476 BU_5VX0 $T=56120 385280 0 0 $X=55690 $Y=384640
X57442 1 2 5562 5542 BU_5VX0 $T=57240 62720 1 0 $X=56810 $Y=57600
X57443 1 2 5560 5265 BU_5VX0 $T=57240 358400 1 0 $X=56810 $Y=353280
X57444 1 2 5633 5642 BU_5VX0 $T=64520 403200 1 0 $X=64090 $Y=398080
X57445 1 2 5400 9141 BU_5VX0 $T=65080 331520 1 0 $X=64650 $Y=326400
X57446 1 2 5792 5657 BU_5VX0 $T=66200 107520 0 0 $X=65770 $Y=106880
X57447 1 2 5716 5728 BU_5VX0 $T=73480 107520 0 0 $X=73050 $Y=106880
X57448 1 2 5785 5501 BU_5VX0 $T=81880 17920 1 0 $X=81450 $Y=12800
X57449 1 2 5547 5789 BU_5VX0 $T=83000 367360 1 0 $X=82570 $Y=362240
X57450 1 2 5728 5836 BU_5VX0 $T=86360 116480 1 0 $X=85930 $Y=111360
X57451 1 2 5920 6094 BU_5VX0 $T=95880 89600 1 0 $X=95450 $Y=84480
X57452 1 2 5447 5562 BU_5VX0 $T=96440 71680 0 0 $X=96010 $Y=71040
X57453 1 2 5944 5958 BU_5VX0 $T=99800 89600 0 0 $X=99370 $Y=88960
X57454 1 2 5778 5967 BU_5VX0 $T=100360 340480 1 0 $X=99930 $Y=335360
X57455 1 2 6001 4617 BU_5VX0 $T=105960 71680 1 0 $X=105530 $Y=66560
X57456 1 2 457 6044 BU_5VX0 $T=111000 62720 0 0 $X=110570 $Y=62080
X57457 1 2 6036 6050 BU_5VX0 $T=111560 53760 0 0 $X=111130 $Y=53120
X57458 1 2 5908 462 BU_5VX0 $T=115480 35840 1 0 $X=115050 $Y=30720
X57459 1 2 460 6036 BU_5VX0 $T=115480 44800 1 0 $X=115050 $Y=39680
X57460 1 2 6091 4593 BU_5VX0 $T=116600 71680 0 0 $X=116170 $Y=71040
X57461 1 2 6094 6091 BU_5VX0 $T=117160 89600 1 0 $X=116730 $Y=84480
X57462 1 2 5958 6141 BU_5VX0 $T=120520 89600 0 0 $X=120090 $Y=88960
X57463 1 2 6140 6154 BU_5VX0 $T=122760 53760 0 0 $X=122330 $Y=53120
X57464 1 2 6157 5716 BU_5VX0 $T=124440 143360 0 0 $X=124010 $Y=142720
X57465 1 2 6154 6200 BU_5VX0 $T=127240 71680 1 0 $X=126810 $Y=66560
X57466 1 2 6187 4754 BU_5VX0 $T=127240 80640 0 0 $X=126810 $Y=80000
X57467 1 2 6217 6187 BU_5VX0 $T=131160 89600 0 0 $X=130730 $Y=88960
X57468 1 2 6050 5920 BU_5VX0 $T=131720 71680 1 0 $X=131290 $Y=66560
X57469 1 2 478 479 BU_5VX0 $T=135640 17920 1 0 $X=135210 $Y=12800
X57470 1 2 6259 5944 BU_5VX0 $T=151880 89600 1 0 $X=151450 $Y=84480
X57471 1 2 6141 6217 BU_5VX0 $T=151880 98560 0 0 $X=151450 $Y=97920
X57472 1 2 6247 6358 BU_5VX0 $T=151880 286720 0 0 $X=151450 $Y=286080
X57473 1 2 6299 9297 BU_5VX0 $T=155800 188160 0 0 $X=155370 $Y=187520
X57474 1 2 6354 9306 BU_5VX0 $T=161400 80640 0 0 $X=160970 $Y=80000
X57475 1 2 9306 5356 BU_5VX0 $T=161960 53760 0 0 $X=161530 $Y=53120
X57476 1 2 9165 6369 BU_5VX0 $T=168680 376320 0 0 $X=168250 $Y=375680
X57477 1 2 6385 5351 BU_5VX0 $T=170360 295680 1 0 $X=169930 $Y=290560
X57478 1 2 6502 6515 BU_5VX0 $T=179880 53760 0 0 $X=179450 $Y=53120
X57479 1 2 6531 6553 BU_5VX0 $T=184360 358400 1 0 $X=183930 $Y=353280
X57480 1 2 6328 9354 BU_5VX0 $T=185480 385280 1 0 $X=185050 $Y=380160
X57481 1 2 6611 6568 BU_5VX0 $T=192760 179200 0 0 $X=192330 $Y=178560
X57482 1 2 5360 6632 BU_5VX0 $T=196120 331520 1 0 $X=195690 $Y=326400
X57483 1 2 6740 6752 BU_5VX0 $T=211800 331520 0 0 $X=211370 $Y=330880
X57484 1 2 6389 9419 BU_5VX0 $T=217960 376320 1 0 $X=217530 $Y=371200
X57485 1 2 5893 6865 BU_5VX0 $T=230280 259840 1 0 $X=229850 $Y=254720
X57486 1 2 6340 6857 BU_5VX0 $T=241480 349440 0 0 $X=241050 $Y=348800
X57487 1 2 6431 7001 BU_5VX0 $T=260520 331520 0 0 $X=260090 $Y=330880
X57488 1 2 6930 6984 BU_5VX0 $T=263320 331520 1 0 $X=262890 $Y=326400
X57489 1 2 7014 7114 BU_5VX0 $T=263880 215040 1 0 $X=263450 $Y=209920
X57490 1 2 7027 7039 BU_5VX0 $T=267240 80640 0 0 $X=266810 $Y=80000
X57491 1 2 7129 9901 BU_5VX0 $T=284600 331520 1 0 $X=284170 $Y=326400
X57492 1 2 7138 7234 BU_5VX0 $T=313160 286720 1 0 $X=312730 $Y=281600
X57493 1 2 7276 7291 BU_5VX0 $T=317080 232960 0 0 $X=316650 $Y=232320
X57494 1 2 9555 7283 BU_5VX0 $T=323800 206080 1 0 $X=323370 $Y=200960
X57495 1 2 7309 9559 BU_5VX0 $T=323800 215040 0 0 $X=323370 $Y=214400
X57496 1 2 7112 7357 BU_5VX0 $T=328280 224000 0 0 $X=327850 $Y=223360
X57497 1 2 7354 7388 BU_5VX0 $T=341720 224000 1 0 $X=341290 $Y=218880
X57498 1 2 7339 7116 BU_5VX0 $T=343400 89600 1 0 $X=342970 $Y=84480
X57499 1 2 7938 911 DLY2_5VX1 $T=-571080 98560 1 0 $X=-571510 $Y=93440
X57500 1 2 908 884 DLY2_5VX1 $T=-571080 179200 1 0 $X=-571510 $Y=174080
X57501 1 2 7945 950 DLY2_5VX1 $T=-564920 89600 1 0 $X=-565350 $Y=84480
X57502 1 2 931 941 DLY2_5VX1 $T=-564360 89600 0 0 $X=-564790 $Y=88960
X57503 1 2 7959 959 DLY2_5VX1 $T=-554840 241920 0 0 $X=-555270 $Y=241280
X57504 1 2 1021 1191 DLY2_5VX1 $T=-543640 304640 1 0 $X=-544070 $Y=299520
X57505 1 2 1001 1064 DLY2_5VX1 $T=-540840 268800 1 0 $X=-541270 $Y=263680
X57506 1 2 1121 1132 DLY2_5VX1 $T=-523480 26880 0 0 $X=-523910 $Y=26240
X57507 1 2 8021 1112 DLY2_5VX1 $T=-516200 331520 0 0 $X=-516630 $Y=330880
X57508 1 2 8023 1151 DLY2_5VX1 $T=-515080 322560 0 0 $X=-515510 $Y=321920
X57509 1 2 1223 1262 DLY2_5VX1 $T=-505560 116480 0 0 $X=-505990 $Y=115840
X57510 1 2 17 1334 DLY2_5VX1 $T=-495480 295680 1 0 $X=-495910 $Y=290560
X57511 1 2 1320 1358 DLY2_5VX1 $T=-490440 179200 1 0 $X=-490870 $Y=174080
X57512 1 2 1297 1378 DLY2_5VX1 $T=-486520 107520 1 0 $X=-486950 $Y=102400
X57513 1 2 1343 2013 DLY2_5VX1 $T=-482600 116480 0 0 $X=-483030 $Y=115840
X57514 1 2 2044 8101 DLY2_5VX1 $T=-474200 125440 1 0 $X=-474630 $Y=120320
X57515 1 2 8094 1460 DLY2_5VX1 $T=-473640 17920 0 0 $X=-474070 $Y=17280
X57516 1 2 1520 2635 DLY2_5VX1 $T=-457960 259840 1 0 $X=-458390 $Y=254720
X57517 1 2 8125 8138 DLY2_5VX1 $T=-454040 295680 0 0 $X=-454470 $Y=295040
X57518 1 2 1522 2601 DLY2_5VX1 $T=-447320 304640 1 0 $X=-447750 $Y=299520
X57519 1 2 1636 1695 DLY2_5VX1 $T=-440600 268800 1 0 $X=-441030 $Y=263680
X57520 1 2 1818 1801 DLY2_5VX1 $T=-426600 268800 0 0 $X=-427030 $Y=268160
X57521 1 2 1735 2903 DLY2_5VX1 $T=-424360 367360 0 0 $X=-424790 $Y=366720
X57522 1 2 1788 1839 DLY2_5VX1 $T=-421560 241920 1 0 $X=-421990 $Y=236800
X57523 1 2 1882 1675 DLY2_5VX1 $T=-409800 358400 1 0 $X=-410230 $Y=353280
X57524 1 2 1909 1962 DLY2_5VX1 $T=-406440 71680 1 0 $X=-406870 $Y=66560
X57525 1 2 1952 2004 DLY2_5VX1 $T=-401400 107520 0 0 $X=-401830 $Y=106880
X57526 1 2 1957 2005 DLY2_5VX1 $T=-401400 224000 1 0 $X=-401830 $Y=218880
X57527 1 2 1983 9797 DLY2_5VX1 $T=-396920 44800 1 0 $X=-397350 $Y=39680
X57528 1 2 1971 2106 DLY2_5VX1 $T=-390760 250880 1 0 $X=-391190 $Y=245760
X57529 1 2 1772 2113 DLY2_5VX1 $T=-389640 304640 1 0 $X=-390070 $Y=299520
X57530 1 2 2084 2145 DLY2_5VX1 $T=-386280 403200 1 0 $X=-386710 $Y=398080
X57531 1 2 1734 2162 DLY2_5VX1 $T=-384040 313600 0 0 $X=-384470 $Y=312960
X57532 1 2 2104 2115 DLY2_5VX1 $T=-384040 394240 1 0 $X=-384470 $Y=389120
X57533 1 2 2108 8269 DLY2_5VX1 $T=-383480 412160 0 0 $X=-383910 $Y=411520
X57534 1 2 2135 2192 DLY2_5VX1 $T=-380120 412160 1 0 $X=-380550 $Y=407040
X57535 1 2 8280 2369 DLY2_5VX1 $T=-369480 277760 1 0 $X=-369910 $Y=272640
X57536 1 2 2225 2282 DLY2_5VX1 $T=-369480 295680 1 0 $X=-369910 $Y=290560
X57537 1 2 8237 2256 DLY2_5VX1 $T=-369480 367360 0 0 $X=-369910 $Y=366720
X57538 1 2 3488 2275 DLY2_5VX1 $T=-369480 412160 0 0 $X=-369910 $Y=411520
X57539 1 2 2269 2290 DLY2_5VX1 $T=-348200 26880 0 0 $X=-348630 $Y=26240
X57540 1 2 2299 2358 DLY2_5VX1 $T=-347080 304640 1 0 $X=-347510 $Y=299520
X57541 1 2 8297 2364 DLY2_5VX1 $T=-346520 340480 1 0 $X=-346950 $Y=335360
X57542 1 2 2450 2627 DLY2_5VX1 $T=-345960 322560 1 0 $X=-346390 $Y=317440
X57543 1 2 8295 3444 DLY2_5VX1 $T=-345960 421120 1 0 $X=-346390 $Y=416000
X57544 1 2 8302 2384 DLY2_5VX1 $T=-344280 376320 0 0 $X=-344710 $Y=375680
X57545 1 2 8304 2388 DLY2_5VX1 $T=-343160 367360 1 0 $X=-343590 $Y=362240
X57546 1 2 2341 2449 DLY2_5VX1 $T=-342040 277760 1 0 $X=-342470 $Y=272640
X57547 1 2 8307 2395 DLY2_5VX1 $T=-342040 358400 0 0 $X=-342470 $Y=357760
X57548 1 2 2361 2425 DLY2_5VX1 $T=-339800 80640 0 0 $X=-340230 $Y=80000
X57549 1 2 2397 2459 DLY2_5VX1 $T=-335880 385280 0 0 $X=-336310 $Y=384640
X57550 1 2 8319 2464 DLY2_5VX1 $T=-333640 394240 1 0 $X=-334070 $Y=389120
X57551 1 2 8320 2476 DLY2_5VX1 $T=-333080 349440 0 0 $X=-333510 $Y=348800
X57552 1 2 2455 2507 DLY2_5VX1 $T=-329160 179200 1 0 $X=-329590 $Y=174080
X57553 1 2 2468 2434 DLY2_5VX1 $T=-327480 224000 0 0 $X=-327910 $Y=223360
X57554 1 2 2469 2516 DLY2_5VX1 $T=-327480 394240 0 0 $X=-327910 $Y=393600
X57555 1 2 2328 2537 DLY2_5VX1 $T=-325800 358400 1 0 $X=-326230 $Y=353280
X57556 1 2 2492 2501 DLY2_5VX1 $T=-325240 313600 0 0 $X=-325670 $Y=312960
X57557 1 2 8337 2545 DLY2_5VX1 $T=-324120 403200 0 0 $X=-324550 $Y=402560
X57558 1 2 2480 2400 DLY2_5VX1 $T=-323560 206080 0 0 $X=-323990 $Y=205440
X57559 1 2 9829 3098 DLY2_5VX1 $T=-320760 367360 1 0 $X=-321190 $Y=362240
X57560 1 2 9799 2580 DLY2_5VX1 $T=-319640 412160 1 0 $X=-320070 $Y=407040
X57561 1 2 8348 2603 DLY2_5VX1 $T=-316280 403200 0 0 $X=-316710 $Y=402560
X57562 1 2 2576 2500 DLY2_5VX1 $T=-313480 304640 1 0 $X=-313910 $Y=299520
X57563 1 2 2403 2628 DLY2_5VX1 $T=-313480 385280 0 0 $X=-313910 $Y=384640
X57564 1 2 2393 2619 DLY2_5VX1 $T=-311800 412160 0 0 $X=-312230 $Y=411520
X57565 1 2 2595 2620 DLY2_5VX1 $T=-311240 394240 1 0 $X=-311670 $Y=389120
X57566 1 2 2645 2693 DLY2_5VX1 $T=-303960 412160 0 0 $X=-304390 $Y=411520
X57567 1 2 8383 2681 DLY2_5VX1 $T=-297240 394240 1 0 $X=-297670 $Y=389120
X57568 1 2 2998 2513 DLY2_5VX1 $T=-295000 206080 1 0 $X=-295430 $Y=200960
X57569 1 2 8388 2658 DLY2_5VX1 $T=-294440 403200 1 0 $X=-294870 $Y=398080
X57570 1 2 2241 2354 DLY2_5VX1 $T=-293320 152320 1 0 $X=-293750 $Y=147200
X57571 1 2 9831 2786 DLY2_5VX1 $T=-291640 403200 0 0 $X=-292070 $Y=402560
X57572 1 2 2730 2773 DLY2_5VX1 $T=-290520 224000 0 0 $X=-290950 $Y=223360
X57573 1 2 2808 3069 DLY2_5VX1 $T=-282680 394240 1 0 $X=-283110 $Y=389120
X57574 1 2 8422 2508 DLY2_5VX1 $T=-275960 295680 0 0 $X=-276390 $Y=295040
X57575 1 2 2937 3227 DLY2_5VX1 $T=-265320 385280 0 0 $X=-265750 $Y=384640
X57576 1 2 2983 3025 DLY2_5VX1 $T=-256920 215040 1 0 $X=-257350 $Y=209920
X57577 1 2 3048 3100 DLY2_5VX1 $T=-248520 71680 0 0 $X=-248950 $Y=71040
X57578 1 2 3057 2926 DLY2_5VX1 $T=-241240 197120 1 0 $X=-241670 $Y=192000
X57579 1 2 3132 3179 DLY2_5VX1 $T=-237880 152320 1 0 $X=-238310 $Y=147200
X57580 1 2 3085 3226 DLY2_5VX1 $T=-233400 340480 0 0 $X=-233830 $Y=339840
X57581 1 2 3223 2664 DLY2_5VX1 $T=-225560 224000 0 0 $X=-225990 $Y=223360
X57582 1 2 3409 3470 DLY2_5VX1 $T=-200920 250880 1 0 $X=-201350 $Y=245760
X57583 1 2 2256 3550 DLY2_5VX1 $T=-193080 259840 1 0 $X=-193510 $Y=254720
X57584 1 2 3635 3473 DLY2_5VX1 $T=-170680 385280 1 0 $X=-171110 $Y=380160
X57585 1 2 3518 3579 DLY2_5VX1 $T=-163400 394240 0 0 $X=-163830 $Y=393600
X57586 1 2 1965 3903 DLY2_5VX1 $T=-156680 224000 0 0 $X=-157110 $Y=223360
X57587 1 2 9847 3931 DLY2_5VX1 $T=-153320 313600 0 0 $X=-153750 $Y=312960
X57588 1 2 3897 4325 DLY2_5VX1 $T=-151080 259840 1 0 $X=-151510 $Y=254720
X57589 1 2 3659 3724 DLY2_5VX1 $T=-148280 107520 1 0 $X=-148710 $Y=102400
X57590 1 2 3282 3632 DLY2_5VX1 $T=-148280 412160 1 0 $X=-148710 $Y=407040
X57591 1 2 3935 8727 DLY2_5VX1 $T=-147160 206080 0 0 $X=-147590 $Y=205440
X57592 1 2 4046 4327 DLY2_5VX1 $T=-134280 188160 0 0 $X=-134710 $Y=187520
X57593 1 2 3857 4156 DLY2_5VX1 $T=-127000 125440 0 0 $X=-127430 $Y=124800
X57594 1 2 4152 4202 DLY2_5VX1 $T=-124200 331520 1 0 $X=-124630 $Y=326400
X57595 1 2 3921 3062 DLY2_5VX1 $T=-120840 80640 1 0 $X=-121270 $Y=75520
X57596 1 2 4175 8874 DLY2_5VX1 $T=-119720 313600 0 0 $X=-120150 $Y=312960
X57597 1 2 4130 8805 DLY2_5VX1 $T=-119720 367360 1 0 $X=-120150 $Y=362240
X57598 1 2 4170 4270 DLY2_5VX1 $T=-119720 376320 1 0 $X=-120150 $Y=371200
X57599 1 2 4177 4272 DLY2_5VX1 $T=-119720 394240 1 0 $X=-120150 $Y=389120
X57600 1 2 3532 3510 DLY2_5VX1 $T=-119720 412160 1 0 $X=-120150 $Y=407040
X57601 1 2 3887 4745 DLY2_5VX1 $T=-97880 80640 0 0 $X=-98310 $Y=80000
X57602 1 2 4297 4361 DLY2_5VX1 $T=-97880 206080 1 0 $X=-98310 $Y=200960
X57603 1 2 4306 4351 DLY2_5VX1 $T=-97320 179200 1 0 $X=-97750 $Y=174080
X57604 1 2 4314 4363 DLY2_5VX1 $T=-96760 277760 0 0 $X=-97190 $Y=277120
X57605 1 2 9852 4364 DLY2_5VX1 $T=-96200 313600 0 0 $X=-96630 $Y=312960
X57606 1 2 3876 4372 DLY2_5VX1 $T=-95640 331520 1 0 $X=-96070 $Y=326400
X57607 1 2 4332 4381 DLY2_5VX1 $T=-93960 358400 0 0 $X=-94390 $Y=357760
X57608 1 2 3915 3658 DLY2_5VX1 $T=-92840 80640 1 0 $X=-93270 $Y=75520
X57609 1 2 4655 4265 DLY2_5VX1 $T=-88920 62720 1 0 $X=-89350 $Y=57600
X57610 1 2 4406 4467 DLY2_5VX1 $T=-83880 340480 1 0 $X=-84310 $Y=335360
X57611 1 2 4338 4485 DLY2_5VX1 $T=-81080 349440 0 0 $X=-81510 $Y=348800
X57612 1 2 3585 4646 DLY2_5VX1 $T=-80520 403200 0 0 $X=-80950 $Y=402560
X57613 1 2 4345 4489 DLY2_5VX1 $T=-79960 331520 1 0 $X=-80390 $Y=326400
X57614 1 2 4510 4570 DLY2_5VX1 $T=-71000 134400 0 0 $X=-71430 $Y=133760
X57615 1 2 4487 4586 DLY2_5VX1 $T=-69320 295680 1 0 $X=-69750 $Y=290560
X57616 1 2 4456 4597 DLY2_5VX1 $T=-67640 412160 0 0 $X=-68070 $Y=411520
X57617 1 2 4534 4607 DLY2_5VX1 $T=-62600 295680 0 0 $X=-63030 $Y=295040
X57618 1 2 9858 4554 DLY2_5VX1 $T=-59800 367360 0 0 $X=-60230 $Y=366720
X57619 1 2 9857 4630 DLY2_5VX1 $T=-58680 349440 0 0 $X=-59110 $Y=348800
X57620 1 2 4629 4690 DLY2_5VX1 $T=-52520 304640 1 0 $X=-52950 $Y=299520
X57621 1 2 4703 4752 DLY2_5VX1 $T=-47480 277760 1 0 $X=-47910 $Y=272640
X57622 1 2 4712 4773 DLY2_5VX1 $T=-45240 125440 0 0 $X=-45670 $Y=124800
X57623 1 2 4527 4845 DLY2_5VX1 $T=-37960 268800 0 0 $X=-38390 $Y=268160
X57624 1 2 4797 8918 DLY2_5VX1 $T=-36840 286720 1 0 $X=-37270 $Y=281600
X57625 1 2 372 376 DLY2_5VX1 $T=-34040 17920 1 0 $X=-34470 $Y=12800
X57626 1 2 4672 4581 DLY2_5VX1 $T=-25640 89600 0 0 $X=-26070 $Y=88960
X57627 1 2 4905 4954 DLY2_5VX1 $T=-16120 188160 1 0 $X=-16550 $Y=183040
X57628 1 2 6300 4708 DLY2_5VX1 $T=-9400 134400 1 0 $X=-9830 $Y=129280
X57629 1 2 5019 4981 DLY2_5VX1 $T=-8280 421120 1 0 $X=-8710 $Y=416000
X57630 1 2 390 4492 DLY2_5VX1 $T=-1000 89600 1 0 $X=-1430 $Y=84480
X57631 1 2 5115 4883 DLY2_5VX1 $T=2920 376320 1 0 $X=2490 $Y=371200
X57632 1 2 5166 5178 DLY2_5VX1 $T=9080 340480 0 0 $X=8650 $Y=339840
X57633 1 2 5170 5213 DLY2_5VX1 $T=10200 152320 0 0 $X=9770 $Y=151680
X57634 1 2 5629 5236 DLY2_5VX1 $T=12440 80640 1 0 $X=12010 $Y=75520
X57635 1 2 4830 4757 DLY2_5VX1 $T=19720 385280 1 0 $X=19290 $Y=380160
X57636 1 2 5254 4870 DLY2_5VX1 $T=21400 403200 0 0 $X=20970 $Y=402560
X57637 1 2 5703 4769 DLY2_5VX1 $T=24760 349440 1 0 $X=24330 $Y=344320
X57638 1 2 5300 4988 DLY2_5VX1 $T=25880 421120 0 0 $X=25450 $Y=420480
X57639 1 2 4720 4728 DLY2_5VX1 $T=32600 170240 1 0 $X=32170 $Y=165120
X57640 1 2 5398 4801 DLY2_5VX1 $T=37640 268800 0 0 $X=37210 $Y=268160
X57641 1 2 5427 8931 DLY2_5VX1 $T=37640 376320 0 0 $X=37210 $Y=375680
X57642 1 2 5410 4768 DLY2_5VX1 $T=38760 358400 0 0 $X=38330 $Y=357760
X57643 1 2 4861 4874 DLY2_5VX1 $T=41000 143360 1 0 $X=40570 $Y=138240
X57644 1 2 5624 5648 DLY2_5VX1 $T=63960 197120 1 0 $X=63530 $Y=192000
X57645 1 2 422 429 DLY2_5VX1 $T=64520 80640 0 0 $X=64090 $Y=80000
X57646 1 2 5721 5586 DLY2_5VX1 $T=74600 134400 1 0 $X=74170 $Y=129280
X57647 1 2 4233 4378 DLY2_5VX1 $T=86360 259840 1 0 $X=85930 $Y=254720
X57648 1 2 5881 4429 DLY2_5VX1 $T=91960 304640 1 0 $X=91530 $Y=299520
X57649 1 2 4379 4445 DLY2_5VX1 $T=96440 206080 1 0 $X=96010 $Y=200960
X57650 1 2 5960 6013 DLY2_5VX1 $T=101480 116480 0 0 $X=101050 $Y=115840
X57651 1 2 6149 6202 DLY2_5VX1 $T=123320 134400 0 0 $X=122890 $Y=133760
X57652 1 2 6175 5170 DLY2_5VX1 $T=126120 331520 0 0 $X=125690 $Y=330880
X57653 1 2 6214 480 DLY2_5VX1 $T=130040 161280 0 0 $X=129610 $Y=160640
X57654 1 2 6246 5596 DLY2_5VX1 $T=130040 304640 0 0 $X=129610 $Y=304000
X57655 1 2 482 6323 DLY2_5VX1 $T=151880 62720 0 0 $X=151450 $Y=62080
X57656 1 2 789 6405 DLY2_5VX1 $T=151880 143360 0 0 $X=151450 $Y=142720
X57657 1 2 6262 485 DLY2_5VX1 $T=151880 161280 1 0 $X=151450 $Y=156160
X57658 1 2 9286 6272 DLY2_5VX1 $T=152440 206080 0 0 $X=152010 $Y=205440
X57659 1 2 6317 5523 DLY2_5VX1 $T=156920 241920 1 0 $X=156490 $Y=236800
X57660 1 2 9298 6299 DLY2_5VX1 $T=158040 188160 1 0 $X=157610 $Y=183040
X57661 1 2 6355 5869 DLY2_5VX1 $T=161400 89600 0 0 $X=160970 $Y=88960
X57662 1 2 4227 6498 DLY2_5VX1 $T=172600 197120 0 0 $X=172170 $Y=196480
X57663 1 2 6245 789 DLY2_5VX1 $T=173160 322560 1 0 $X=172730 $Y=317440
X57664 1 2 8997 4453 DLY2_5VX1 $T=180440 421120 0 0 $X=180010 $Y=420480
X57665 1 2 6506 5558 DLY2_5VX1 $T=182120 250880 0 0 $X=181690 $Y=250240
X57666 1 2 5674 6149 DLY2_5VX1 $T=182680 286720 0 0 $X=182250 $Y=286080
X57667 1 2 6529 5610 DLY2_5VX1 $T=183240 206080 0 0 $X=182810 $Y=205440
X57668 1 2 6530 5496 DLY2_5VX1 $T=183240 268800 0 0 $X=182810 $Y=268160
X57669 1 2 5038 9011 DLY2_5VX1 $T=188280 421120 0 0 $X=187850 $Y=420480
X57670 1 2 6473 6565 DLY2_5VX1 $T=191640 44800 1 0 $X=191210 $Y=39680
X57671 1 2 5525 5721 DLY2_5VX1 $T=193320 304640 1 0 $X=192890 $Y=299520
X57672 1 2 6293 4893 DLY2_5VX1 $T=197800 403200 0 0 $X=197370 $Y=402560
X57673 1 2 6961 5622 DLY2_5VX1 $T=211800 268800 1 0 $X=211370 $Y=263680
X57674 1 2 6826 5628 DLY2_5VX1 $T=223000 224000 1 0 $X=222570 $Y=218880
X57675 1 2 6901 551 DLY2_5VX1 $T=242040 143360 1 0 $X=241610 $Y=138240
X57676 1 2 541 552 DLY2_5VX1 $T=244840 17920 1 0 $X=244410 $Y=12800
X57677 1 2 6949 6542 DLY2_5VX1 $T=252120 179200 0 0 $X=251690 $Y=178560
X57678 1 2 6953 5744 DLY2_5VX1 $T=252680 206080 0 0 $X=252250 $Y=205440
X57679 1 2 6859 6852 DLY2_5VX1 $T=260520 197120 0 0 $X=260090 $Y=196480
X57680 1 2 6554 6558 DLY2_5VX1 $T=272280 170240 0 0 $X=271850 $Y=169600
X57681 1 2 7071 7003 DLY2_5VX1 $T=282920 125440 0 0 $X=282490 $Y=124800
X57682 1 2 581 583 DLY2_5VX1 $T=285160 170240 0 0 $X=284730 $Y=169600
X57683 1 2 6380 6404 DLY2_5VX1 $T=295800 179200 1 0 $X=295370 $Y=174080
X57684 1 2 9807 5699 DLY2_5VX1 $T=305320 295680 0 0 $X=304890 $Y=295040
X57685 1 2 6478 9807 DLY2_5VX1 $T=313160 295680 0 0 $X=312730 $Y=295040
X57686 1 2 7290 7264 DLY2_5VX1 $T=319320 170240 0 0 $X=318890 $Y=169600
X57687 1 2 7440 7338 DLY2_5VX1 $T=335000 53760 1 0 $X=334570 $Y=48640
X57688 1 2 7362 7516 DLY2_5VX1 $T=335000 179200 1 0 $X=334570 $Y=174080
X57689 1 2 7366 610 DLY2_5VX1 $T=336120 170240 1 0 $X=335690 $Y=165120
X57690 1 2 608 617 DLY2_5VX1 $T=340040 134400 0 0 $X=339610 $Y=133760
X57691 1 2 7388 7425 DLY2_5VX1 $T=341160 215040 0 0 $X=340730 $Y=214400
X57692 1 2 7402 7432 DLY2_5VX1 $T=343960 170240 0 0 $X=343530 $Y=169600
X57693 1 2 612 618 DLY2_5VX1 $T=345640 53760 0 0 $X=345210 $Y=53120
X57694 1 2 7464 7482 DLY2_5VX1 $T=360200 250880 0 0 $X=359770 $Y=250240
X57695 1 2 7058 7531 DLY2_5VX1 $T=364680 62720 0 0 $X=364250 $Y=62080
X57696 1 2 6837 7551 DLY2_5VX1 $T=372520 134400 1 0 $X=372090 $Y=129280
X57697 1 2 7582 7575 DLY2_5VX1 $T=401640 215040 0 0 $X=401210 $Y=214400
X57698 1 2 7589 7596 DLY2_5VX1 $T=402200 152320 1 0 $X=401770 $Y=147200
X57699 1 2 7640 7667 DLY2_5VX1 $T=422360 206080 1 0 $X=421930 $Y=200960
X57700 1 2 7057 9630 DLY2_5VX1 $T=424600 89600 1 0 $X=424170 $Y=84480
X57701 1 2 7687 6354 DLY2_5VX1 $T=427960 125440 0 0 $X=427530 $Y=124800
X57702 1 2 657 658 DLY2_5VX1 $T=435240 17920 1 0 $X=434810 $Y=12800
X57703 1 2 661 665 DLY2_5VX1 $T=439720 26880 0 0 $X=439290 $Y=26240
X57704 1 2 9692 7724 DLY2_5VX1 $T=439720 161280 0 0 $X=439290 $Y=160640
X57705 1 2 9723 7740 DLY2_5VX1 $T=452600 125440 0 0 $X=452170 $Y=124800
X57706 1 2 674 7613 DLY2_5VX1 $T=463800 44800 1 0 $X=463370 $Y=39680
X57707 1 2 808 837 DLY4_5VX1 $T=-597960 250880 1 0 $X=-598390 $Y=245760
X57708 1 2 812 1054 DLY4_5VX1 $T=-596280 116480 0 0 $X=-596710 $Y=115840
X57709 1 2 827 843 DLY4_5VX1 $T=-596280 259840 1 0 $X=-596710 $Y=254720
X57710 1 2 813 845 DLY4_5VX1 $T=-595720 134400 1 0 $X=-596150 $Y=129280
X57711 1 2 822 844 DLY4_5VX1 $T=-595160 116480 1 0 $X=-595590 $Y=111360
X57712 1 2 818 872 DLY4_5VX1 $T=-595160 143360 1 0 $X=-595590 $Y=138240
X57713 1 2 819 846 DLY4_5VX1 $T=-595160 152320 0 0 $X=-595590 $Y=151680
X57714 1 2 820 847 DLY4_5VX1 $T=-595160 188160 1 0 $X=-595590 $Y=183040
X57715 1 2 821 848 DLY4_5VX1 $T=-595160 215040 0 0 $X=-595590 $Y=214400
X57716 1 2 823 868 DLY4_5VX1 $T=-594600 170240 0 0 $X=-595030 $Y=169600
X57717 1 2 829 854 DLY4_5VX1 $T=-594040 250880 0 0 $X=-594470 $Y=250240
X57718 1 2 824 855 DLY4_5VX1 $T=-593480 125440 0 0 $X=-593910 $Y=124800
X57719 1 2 825 851 DLY4_5VX1 $T=-593480 197120 0 0 $X=-593910 $Y=196480
X57720 1 2 912 857 DLY4_5VX1 $T=-593480 206080 0 0 $X=-593910 $Y=205440
X57721 1 2 919 925 DLY4_5VX1 $T=-592920 241920 1 0 $X=-593350 $Y=236800
X57722 1 2 831 863 DLY4_5VX1 $T=-591800 232960 1 0 $X=-592230 $Y=227840
X57723 1 2 834 858 DLY4_5VX1 $T=-591800 259840 0 0 $X=-592230 $Y=259200
X57724 1 2 841 877 DLY4_5VX1 $T=-588440 268800 0 0 $X=-588870 $Y=268160
X57725 1 2 838 874 DLY4_5VX1 $T=-587880 125440 1 0 $X=-588310 $Y=120320
X57726 1 2 839 876 DLY4_5VX1 $T=-587880 179200 1 0 $X=-588310 $Y=174080
X57727 1 2 849 916 DLY4_5VX1 $T=-585640 259840 1 0 $X=-586070 $Y=254720
X57728 1 2 852 892 DLY4_5VX1 $T=-584520 116480 1 0 $X=-584950 $Y=111360
X57729 1 2 856 903 DLY4_5VX1 $T=-583400 143360 0 0 $X=-583830 $Y=142720
X57730 1 2 707 901 DLY4_5VX1 $T=-583400 250880 0 0 $X=-583830 $Y=250240
X57731 1 2 885 1012 DLY4_5VX1 $T=-577240 277760 1 0 $X=-577670 $Y=272640
X57732 1 2 890 1010 DLY4_5VX1 $T=-576120 170240 1 0 $X=-576550 $Y=165120
X57733 1 2 889 926 DLY4_5VX1 $T=-575560 277760 0 0 $X=-575990 $Y=277120
X57734 1 2 894 930 DLY4_5VX1 $T=-575000 259840 1 0 $X=-575430 $Y=254720
X57735 1 2 902 7951 DLY4_5VX1 $T=-573880 125440 0 0 $X=-574310 $Y=124800
X57736 1 2 918 936 DLY4_5VX1 $T=-568840 286720 0 0 $X=-569270 $Y=286080
X57737 1 2 988 7957 DLY4_5VX1 $T=-567720 286720 1 0 $X=-568150 $Y=281600
X57738 1 2 920 958 DLY4_5VX1 $T=-566600 277760 1 0 $X=-567030 $Y=272640
X57739 1 2 7949 914 DLY4_5VX1 $T=-563240 98560 1 0 $X=-563670 $Y=93440
X57740 1 2 934 1016 DLY4_5VX1 $T=-563240 206080 1 0 $X=-563670 $Y=200960
X57741 1 2 935 973 DLY4_5VX1 $T=-563240 232960 1 0 $X=-563670 $Y=227840
X57742 1 2 948 983 DLY4_5VX1 $T=-560440 295680 1 0 $X=-560870 $Y=290560
X57743 1 2 953 1131 DLY4_5VX1 $T=-558760 259840 0 0 $X=-559190 $Y=259200
X57744 1 2 966 989 DLY4_5VX1 $T=-552600 71680 0 0 $X=-553030 $Y=71040
X57745 1 2 1007 990 DLY4_5VX1 $T=-549800 295680 1 0 $X=-550230 $Y=290560
X57746 1 2 1000 1048 DLY4_5VX1 $T=-548120 259840 0 0 $X=-548550 $Y=259200
X57747 1 2 1013 1065 DLY4_5VX1 $T=-544200 53760 1 0 $X=-544630 $Y=48640
X57748 1 2 1029 1077 DLY4_5VX1 $T=-541960 313600 0 0 $X=-542390 $Y=312960
X57749 1 2 7977 1004 DLY4_5VX1 $T=-538600 170240 0 0 $X=-539030 $Y=169600
X57750 1 2 1059 1061 DLY4_5VX1 $T=-536920 322560 1 0 $X=-537350 $Y=317440
X57751 1 2 1072 1781 DLY4_5VX1 $T=-532440 35840 0 0 $X=-532870 $Y=35200
X57752 1 2 1080 1138 DLY4_5VX1 $T=-531880 268800 0 0 $X=-532310 $Y=268160
X57753 1 2 7997 1081 DLY4_5VX1 $T=-531320 304640 0 0 $X=-531750 $Y=304000
X57754 1 2 1085 1123 DLY4_5VX1 $T=-530760 53760 1 0 $X=-531190 $Y=48640
X57755 1 2 1105 1160 DLY4_5VX1 $T=-525160 250880 0 0 $X=-525590 $Y=250240
X57756 1 2 1132 1189 DLY4_5VX1 $T=-521240 35840 1 0 $X=-521670 $Y=30720
X57757 1 2 8014 1150 DLY4_5VX1 $T=-519000 340480 1 0 $X=-519430 $Y=335360
X57758 1 2 1154 1167 DLY4_5VX1 $T=-516760 313600 1 0 $X=-517190 $Y=308480
X57759 1 2 8035 1212 DLY4_5VX1 $T=-506120 286720 1 0 $X=-506550 $Y=281600
X57760 1 2 9815 1280 DLY4_5VX1 $T=-506120 340480 0 0 $X=-506550 $Y=339840
X57761 1 2 1233 1229 DLY4_5VX1 $T=-504440 313600 0 0 $X=-504870 $Y=312960
X57762 1 2 8036 1237 DLY4_5VX1 $T=-503320 331520 0 0 $X=-503750 $Y=330880
X57763 1 2 1130 1244 DLY4_5VX1 $T=-502760 349440 0 0 $X=-503190 $Y=348800
X57764 1 2 8056 1266 DLY4_5VX1 $T=-498280 349440 1 0 $X=-498710 $Y=344320
X57765 1 2 1251 1295 DLY4_5VX1 $T=-492680 358400 1 0 $X=-493110 $Y=353280
X57766 1 2 1311 1369 DLY4_5VX1 $T=-492120 349440 0 0 $X=-492550 $Y=348800
X57767 1 2 1348 1359 DLY4_5VX1 $T=-491000 340480 0 0 $X=-491430 $Y=339840
X57768 1 2 1290 1219 DLY4_5VX1 $T=-488200 331520 0 0 $X=-488630 $Y=330880
X57769 1 2 1335 1376 DLY4_5VX1 $T=-487640 322560 1 0 $X=-488070 $Y=317440
X57770 1 2 1338 1374 DLY4_5VX1 $T=-484280 340480 1 0 $X=-484710 $Y=335360
X57771 1 2 8082 1398 DLY4_5VX1 $T=-480360 340480 0 0 $X=-480790 $Y=339840
X57772 1 2 1352 1381 DLY4_5VX1 $T=-479240 367360 1 0 $X=-479670 $Y=362240
X57773 1 2 1397 1436 DLY4_5VX1 $T=-477000 313600 1 0 $X=-477430 $Y=308480
X57774 1 2 1553 1466 DLY4_5VX1 $T=-475880 206080 1 0 $X=-476310 $Y=200960
X57775 1 2 1377 1368 DLY4_5VX1 $T=-473640 331520 0 0 $X=-474070 $Y=330880
X57776 1 2 1422 1410 DLY4_5VX1 $T=-473640 358400 0 0 $X=-474070 $Y=357760
X57777 1 2 9817 1449 DLY4_5VX1 $T=-473080 358400 1 0 $X=-473510 $Y=353280
X57778 1 2 1428 1491 DLY4_5VX1 $T=-472520 286720 0 0 $X=-472950 $Y=286080
X57779 1 2 1450 1494 DLY4_5VX1 $T=-469160 340480 0 0 $X=-469590 $Y=339840
X57780 1 2 8102 1433 DLY4_5VX1 $T=-466920 349440 0 0 $X=-467350 $Y=348800
X57781 1 2 8101 1524 DLY4_5VX1 $T=-466360 134400 1 0 $X=-466790 $Y=129280
X57782 1 2 1447 1479 DLY4_5VX1 $T=-463000 367360 1 0 $X=-463430 $Y=362240
X57783 1 2 1470 1495 DLY4_5VX1 $T=-462440 358400 0 0 $X=-462870 $Y=357760
X57784 1 2 1501 1556 DLY4_5VX1 $T=-461320 340480 1 0 $X=-461750 $Y=335360
X57785 1 2 1502 1508 DLY4_5VX1 $T=-459080 367360 0 0 $X=-459510 $Y=366720
X57786 1 2 1843 1609 DLY4_5VX1 $T=-454040 179200 0 0 $X=-454470 $Y=178560
X57787 1 2 1547 1289 DLY4_5VX1 $T=-451800 277760 1 0 $X=-452230 $Y=272640
X57788 1 2 8127 1601 DLY4_5VX1 $T=-451800 340480 0 0 $X=-452230 $Y=339840
X57789 1 2 1566 1643 DLY4_5VX1 $T=-449560 107520 0 0 $X=-449990 $Y=106880
X57790 1 2 1568 1669 DLY4_5VX1 $T=-443400 367360 1 0 $X=-443830 $Y=362240
X57791 1 2 1637 1598 DLY4_5VX1 $T=-440040 295680 1 0 $X=-440470 $Y=290560
X57792 1 2 1692 1724 DLY4_5VX1 $T=-433880 358400 0 0 $X=-434310 $Y=357760
X57793 1 2 1645 1664 DLY4_5VX1 $T=-433320 358400 1 0 $X=-433750 $Y=353280
X57794 1 2 1658 1705 DLY4_5VX1 $T=-431640 349440 0 0 $X=-432070 $Y=348800
X57795 1 2 1750 1699 DLY4_5VX1 $T=-430520 322560 0 0 $X=-430950 $Y=321920
X57796 1 2 1600 1548 DLY4_5VX1 $T=-429960 331520 1 0 $X=-430390 $Y=326400
X57797 1 2 8178 1818 DLY4_5VX1 $T=-426040 367360 1 0 $X=-426470 $Y=362240
X57798 1 2 8177 1674 DLY4_5VX1 $T=-425480 295680 1 0 $X=-425910 $Y=290560
X57799 1 2 1779 1843 DLY4_5VX1 $T=-422680 358400 1 0 $X=-423110 $Y=353280
X57800 1 2 1781 1856 DLY4_5VX1 $T=-421560 35840 0 0 $X=-421990 $Y=35200
X57801 1 2 1798 1788 DLY4_5VX1 $T=-421000 358400 0 0 $X=-421430 $Y=357760
X57802 1 2 1668 1741 DLY4_5VX1 $T=-419320 340480 0 0 $X=-419750 $Y=339840
X57803 1 2 1755 1807 DLY4_5VX1 $T=-417080 349440 1 0 $X=-417510 $Y=344320
X57804 1 2 1638 1583 DLY4_5VX1 $T=-414840 304640 0 0 $X=-415270 $Y=304000
X57805 1 2 1868 1965 DLY4_5VX1 $T=-410360 367360 1 0 $X=-410790 $Y=362240
X57806 1 2 9797 1949 DLY4_5VX1 $T=-409240 44800 1 0 $X=-409670 $Y=39680
X57807 1 2 1891 1975 DLY4_5VX1 $T=-408120 89600 1 0 $X=-408550 $Y=84480
X57808 1 2 1897 1980 DLY4_5VX1 $T=-408120 385280 0 0 $X=-408550 $Y=384640
X57809 1 2 1582 1589 DLY4_5VX1 $T=-406440 304640 1 0 $X=-406870 $Y=299520
X57810 1 2 1914 8237 DLY4_5VX1 $T=-405880 367360 0 0 $X=-406310 $Y=366720
X57811 1 2 1881 1938 DLY4_5VX1 $T=-401960 358400 1 0 $X=-402390 $Y=353280
X57812 1 2 1691 2021 DLY4_5VX1 $T=-401400 331520 1 0 $X=-401830 $Y=326400
X57813 1 2 1960 1957 DLY4_5VX1 $T=-400840 376320 1 0 $X=-401270 $Y=371200
X57814 1 2 1959 2017 DLY4_5VX1 $T=-399720 367360 1 0 $X=-400150 $Y=362240
X57815 1 2 9825 2042 DLY4_5VX1 $T=-399160 376320 0 0 $X=-399590 $Y=375680
X57816 1 2 9826 1970 DLY4_5VX1 $T=-398600 358400 0 0 $X=-399030 $Y=357760
X57817 1 2 1981 2065 DLY4_5VX1 $T=-397480 394240 0 0 $X=-397910 $Y=393600
X57818 1 2 1997 2092 DLY4_5VX1 $T=-394680 394240 1 0 $X=-395110 $Y=389120
X57819 1 2 2019 2117 DLY4_5VX1 $T=-391880 125440 0 0 $X=-392310 $Y=124800
X57820 1 2 1977 2143 DLY4_5VX1 $T=-389080 170240 1 0 $X=-389510 $Y=165120
X57821 1 2 2037 2040 DLY4_5VX1 $T=-389080 367360 1 0 $X=-389510 $Y=362240
X57822 1 2 2015 2051 DLY4_5VX1 $T=-389080 367360 0 0 $X=-389510 $Y=366720
X57823 1 2 2070 2443 DLY4_5VX1 $T=-386840 304640 0 0 $X=-387270 $Y=304000
X57824 1 2 2071 2164 DLY4_5VX1 $T=-386840 358400 0 0 $X=-387270 $Y=357760
X57825 1 2 2145 3799 DLY4_5VX1 $T=-386840 394240 0 0 $X=-387270 $Y=393600
X57826 1 2 2085 2178 DLY4_5VX1 $T=-385160 53760 1 0 $X=-385590 $Y=48640
X57827 1 2 1962 2335 DLY4_5VX1 $T=-384040 35840 1 0 $X=-384470 $Y=30720
X57828 1 2 2114 2198 DLY4_5VX1 $T=-382920 376320 0 0 $X=-383350 $Y=375680
X57829 1 2 2115 3434 DLY4_5VX1 $T=-382920 385280 0 0 $X=-383350 $Y=384640
X57830 1 2 2203 2251 DLY4_5VX1 $T=-372280 179200 1 0 $X=-372710 $Y=174080
X57831 1 2 8341 2292 DLY4_5VX1 $T=-372280 224000 0 0 $X=-372710 $Y=223360
X57832 1 2 2210 2252 DLY4_5VX1 $T=-372280 295680 0 0 $X=-372710 $Y=295040
X57833 1 2 2215 2293 DLY4_5VX1 $T=-372280 322560 1 0 $X=-372710 $Y=317440
X57834 1 2 2221 2274 DLY4_5VX1 $T=-372280 376320 1 0 $X=-372710 $Y=371200
X57835 1 2 2211 2257 DLY4_5VX1 $T=-372280 376320 0 0 $X=-372710 $Y=375680
X57836 1 2 2217 2265 DLY4_5VX1 $T=-372280 385280 1 0 $X=-372710 $Y=380160
X57837 1 2 2199 2245 DLY4_5VX1 $T=-372280 385280 0 0 $X=-372710 $Y=384640
X57838 1 2 2205 2259 DLY4_5VX1 $T=-372280 412160 1 0 $X=-372710 $Y=407040
X57839 1 2 2200 8295 DLY4_5VX1 $T=-372280 421120 1 0 $X=-372710 $Y=416000
X57840 1 2 2284 2374 DLY4_5VX1 $T=-348200 322560 0 0 $X=-348630 $Y=321920
X57841 1 2 2297 2379 DLY4_5VX1 $T=-347640 412160 0 0 $X=-348070 $Y=411520
X57842 1 2 2300 2376 DLY4_5VX1 $T=-347080 313600 1 0 $X=-347510 $Y=308480
X57843 1 2 2301 2387 DLY4_5VX1 $T=-346520 340480 0 0 $X=-346950 $Y=339840
X57844 1 2 2305 2389 DLY4_5VX1 $T=-346520 385280 0 0 $X=-346950 $Y=384640
X57845 1 2 2306 2390 DLY4_5VX1 $T=-346520 403200 1 0 $X=-346950 $Y=398080
X57846 1 2 2333 2488 DLY4_5VX1 $T=-343720 349440 0 0 $X=-344150 $Y=348800
X57847 1 2 2339 2409 DLY4_5VX1 $T=-343720 403200 0 0 $X=-344150 $Y=402560
X57848 1 2 3643 2410 DLY4_5VX1 $T=-343720 412160 1 0 $X=-344150 $Y=407040
X57849 1 2 2378 2460 DLY4_5VX1 $T=-338120 394240 0 0 $X=-338550 $Y=393600
X57850 1 2 2391 2470 DLY4_5VX1 $T=-337000 412160 0 0 $X=-337430 $Y=411520
X57851 1 2 2398 2462 DLY4_5VX1 $T=-335320 421120 1 0 $X=-335750 $Y=416000
X57852 1 2 2853 2502 DLY4_5VX1 $T=-333640 421120 0 0 $X=-334070 $Y=420480
X57853 1 2 2436 2517 DLY4_5VX1 $T=-330280 412160 1 0 $X=-330710 $Y=407040
X57854 1 2 2462 2541 DLY4_5VX1 $T=-328040 295680 1 0 $X=-328470 $Y=290560
X57855 1 2 2477 2554 DLY4_5VX1 $T=-326360 367360 0 0 $X=-326790 $Y=366720
X57856 1 2 2482 2569 DLY4_5VX1 $T=-324680 421120 1 0 $X=-325110 $Y=416000
X57857 1 2 2245 2594 DLY4_5VX1 $T=-320200 313600 1 0 $X=-320630 $Y=308480
X57858 1 2 719 3117 DLY4_5VX1 $T=-314040 421120 1 0 $X=-314470 $Y=416000
X57859 1 2 2583 2608 DLY4_5VX1 $T=-312360 385280 1 0 $X=-312790 $Y=380160
X57860 1 2 2198 2657 DLY4_5VX1 $T=-311800 349440 1 0 $X=-312230 $Y=344320
X57861 1 2 2588 2667 DLY4_5VX1 $T=-311240 421120 0 0 $X=-311670 $Y=420480
X57862 1 2 2634 2712 DLY4_5VX1 $T=-305080 394240 0 0 $X=-305510 $Y=393600
X57863 1 2 2569 2738 DLY4_5VX1 $T=-301160 349440 1 0 $X=-301590 $Y=344320
X57864 1 2 2265 2785 DLY4_5VX1 $T=-294440 376320 1 0 $X=-294870 $Y=371200
X57865 1 2 2918 2821 DLY4_5VX1 $T=-289960 385280 1 0 $X=-290390 $Y=380160
X57866 1 2 2257 2831 DLY4_5VX1 $T=-288280 358400 0 0 $X=-288710 $Y=357760
X57867 1 2 2705 2663 DLY4_5VX1 $T=-283240 215040 1 0 $X=-283670 $Y=209920
X57868 1 2 2312 2320 DLY4_5VX1 $T=-281000 143360 0 0 $X=-281430 $Y=142720
X57869 1 2 2782 726 DLY4_5VX1 $T=-280440 161280 1 0 $X=-280870 $Y=156160
X57870 1 2 2502 2794 DLY4_5VX1 $T=-274840 394240 1 0 $X=-275270 $Y=389120
X57871 1 2 2274 2654 DLY4_5VX1 $T=-265880 232960 0 0 $X=-266310 $Y=232320
X57872 1 2 8442 2919 DLY4_5VX1 $T=-265880 403200 1 0 $X=-266310 $Y=398080
X57873 1 2 2971 3016 DLY4_5VX1 $T=-259720 421120 1 0 $X=-260150 $Y=416000
X57874 1 2 2460 3038 DLY4_5VX1 $T=-253560 394240 1 0 $X=-253990 $Y=389120
X57875 1 2 2379 2984 DLY4_5VX1 $T=-251880 403200 1 0 $X=-252310 $Y=398080
X57876 1 2 3062 3141 DLY4_5VX1 $T=-246280 80640 0 0 $X=-246710 $Y=80000
X57877 1 2 3117 3039 DLY4_5VX1 $T=-239560 358400 0 0 $X=-239990 $Y=357760
X57878 1 2 2559 2602 DLY4_5VX1 $T=-237880 232960 0 0 $X=-238310 $Y=232320
X57879 1 2 8508 3145 DLY4_5VX1 $T=-236760 412160 0 0 $X=-237190 $Y=411520
X57880 1 2 2390 3015 DLY4_5VX1 $T=-235640 376320 0 0 $X=-236070 $Y=375680
X57881 1 2 3235 8540 DLY4_5VX1 $T=-232280 421120 1 0 $X=-232710 $Y=416000
X57882 1 2 2389 3206 DLY4_5VX1 $T=-225000 376320 0 0 $X=-225430 $Y=375680
X57883 1 2 3340 3339 DLY4_5VX1 $T=-219400 421120 0 0 $X=-219830 $Y=420480
X57884 1 2 2689 2737 DLY4_5VX1 $T=-217160 197120 0 0 $X=-217590 $Y=196480
X57885 1 2 2812 3125 DLY4_5VX1 $T=-217160 286720 0 0 $X=-217590 $Y=286080
X57886 1 2 2517 3253 DLY4_5VX1 $T=-212680 385280 0 0 $X=-213110 $Y=384640
X57887 1 2 2409 3324 DLY4_5VX1 $T=-205960 394240 0 0 $X=-206390 $Y=393600
X57888 1 2 3368 3335 DLY4_5VX1 $T=-203720 179200 1 0 $X=-204150 $Y=174080
X57889 1 2 4156 9791 DLY4_5VX1 $T=-203160 125440 0 0 $X=-203590 $Y=124800
X57890 1 2 3443 3525 DLY4_5VX1 $T=-197560 224000 1 0 $X=-197990 $Y=218880
X57891 1 2 3355 3371 DLY4_5VX1 $T=-190280 412160 0 0 $X=-190710 $Y=411520
X57892 1 2 2667 3610 DLY4_5VX1 $T=-189160 403200 1 0 $X=-189590 $Y=398080
X57893 1 2 2470 3389 DLY4_5VX1 $T=-188040 385280 1 0 $X=-188470 $Y=380160
X57894 1 2 3558 3194 DLY4_5VX1 $T=-185240 304640 1 0 $X=-185670 $Y=299520
X57895 1 2 8637 3162 DLY4_5VX1 $T=-179640 224000 1 0 $X=-180070 $Y=218880
X57896 1 2 3274 3195 DLY4_5VX1 $T=-177960 268800 1 0 $X=-178390 $Y=263680
X57897 1 2 3658 3749 DLY4_5VX1 $T=-175720 80640 0 0 $X=-176150 $Y=80000
X57898 1 2 2410 3656 DLY4_5VX1 $T=-174040 403200 0 0 $X=-174470 $Y=402560
X57899 1 2 3442 3451 DLY4_5VX1 $T=-173480 421120 0 0 $X=-173910 $Y=420480
X57900 1 2 3742 3825 DLY4_5VX1 $T=-167320 98560 1 0 $X=-167750 $Y=93440
X57901 1 2 3877 3716 DLY4_5VX1 $T=-153880 394240 1 0 $X=-154310 $Y=389120
X57902 1 2 1958 4029 DLY4_5VX1 $T=-146040 349440 1 0 $X=-146470 $Y=344320
X57903 1 2 8727 3726 DLY4_5VX1 $T=-137640 224000 0 0 $X=-138070 $Y=223360
X57904 1 2 4020 4065 DLY4_5VX1 $T=-137080 71680 0 0 $X=-137510 $Y=71040
X57905 1 2 4096 4173 DLY4_5VX1 $T=-128680 241920 0 0 $X=-129110 $Y=241280
X57906 1 2 3906 3877 DLY4_5VX1 $T=-124760 421120 1 0 $X=-125190 $Y=416000
X57907 1 2 285 4193 DLY4_5VX1 $T=-122520 35840 1 0 $X=-122950 $Y=30720
X57908 1 2 4139 4216 DLY4_5VX1 $T=-122520 134400 0 0 $X=-122950 $Y=133760
X57909 1 2 4337 4271 DLY4_5VX1 $T=-122520 385280 1 0 $X=-122950 $Y=380160
X57910 1 2 3943 3948 DLY4_5VX1 $T=-97880 188160 1 0 $X=-98310 $Y=183040
X57911 1 2 4296 4084 DLY4_5VX1 $T=-97880 197120 1 0 $X=-98310 $Y=192000
X57912 1 2 4307 4397 DLY4_5VX1 $T=-97320 197120 0 0 $X=-97750 $Y=196480
X57913 1 2 4324 4392 DLY4_5VX1 $T=-95640 349440 1 0 $X=-96070 $Y=344320
X57914 1 2 4365 4448 DLY4_5VX1 $T=-89480 322560 1 0 $X=-89910 $Y=317440
X57915 1 2 4407 4375 DLY4_5VX1 $T=-83320 98560 1 0 $X=-83750 $Y=93440
X57916 1 2 4438 4515 DLY4_5VX1 $T=-80520 331520 0 0 $X=-80950 $Y=330880
X57917 1 2 4439 4529 DLY4_5VX1 $T=-79960 376320 1 0 $X=-80390 $Y=371200
X57918 1 2 4333 4330 DLY4_5VX1 $T=-78280 62720 1 0 $X=-78710 $Y=57600
X57919 1 2 4482 4557 DLY4_5VX1 $T=-75480 259840 0 0 $X=-75910 $Y=259200
X57920 1 2 4621 4920 DLY4_5VX1 $T=-59800 412160 0 0 $X=-60230 $Y=411520
X57921 1 2 8870 4705 DLY4_5VX1 $T=-58120 403200 0 0 $X=-58550 $Y=402560
X57922 1 2 4667 4735 DLY4_5VX1 $T=-53080 197120 1 0 $X=-53510 $Y=192000
X57923 1 2 4698 8907 DLY4_5VX1 $T=-43560 412160 1 0 $X=-43990 $Y=407040
X57924 1 2 4966 4834 DLY4_5VX1 $T=-40760 331520 1 0 $X=-41190 $Y=326400
X57925 1 2 4778 4857 DLY4_5VX1 $T=-38520 340480 1 0 $X=-38950 $Y=335360
X57926 1 2 4864 4945 DLY4_5VX1 $T=-28440 322560 0 0 $X=-28870 $Y=321920
X57927 1 2 4865 4946 DLY4_5VX1 $T=-28440 340480 0 0 $X=-28870 $Y=339840
X57928 1 2 4928 4987 DLY4_5VX1 $T=-22280 376320 1 0 $X=-22710 $Y=371200
X57929 1 2 4819 4933 DLY4_5VX1 $T=-17800 403200 0 0 $X=-18230 $Y=402560
X57930 1 2 5057 5278 DLY4_5VX1 $T=-3800 403200 0 0 $X=-4230 $Y=402560
X57931 1 2 5018 5026 DLY4_5VX1 $T=-3240 349440 1 0 $X=-3670 $Y=344320
X57932 1 2 5106 5001 DLY4_5VX1 $T=1800 134400 0 0 $X=1370 $Y=133760
X57933 1 2 8988 5069 DLY4_5VX1 $T=2360 394240 0 0 $X=1930 $Y=393600
X57934 1 2 9004 5235 DLY4_5VX1 $T=9080 376320 0 0 $X=8650 $Y=375680
X57935 1 2 5025 5134 DLY4_5VX1 $T=12440 179200 0 0 $X=12010 $Y=178560
X57936 1 2 5193 757 DLY4_5VX1 $T=14680 331520 1 0 $X=14250 $Y=326400
X57937 1 2 9025 5172 DLY4_5VX1 $T=15240 421120 0 0 $X=14810 $Y=420480
X57938 1 2 767 763 DLY4_5VX1 $T=25320 367360 1 0 $X=24890 $Y=362240
X57939 1 2 5343 5593 DLY4_5VX1 $T=31480 44800 1 0 $X=31050 $Y=39680
X57940 1 2 4929 5150 DLY4_5VX1 $T=31480 340480 1 0 $X=31050 $Y=335360
X57941 1 2 5387 5383 DLY4_5VX1 $T=35960 161280 1 0 $X=35530 $Y=156160
X57942 1 2 5386 5442 DLY4_5VX1 $T=37080 107520 0 0 $X=36650 $Y=106880
X57943 1 2 768 5340 DLY4_5VX1 $T=43240 421120 1 0 $X=42810 $Y=416000
X57944 1 2 9089 5491 DLY4_5VX1 $T=46600 71680 0 0 $X=46170 $Y=71040
X57945 1 2 9111 5565 DLY4_5VX1 $T=53880 421120 1 0 $X=53450 $Y=416000
X57946 1 2 5550 5649 DLY4_5VX1 $T=56680 35840 1 0 $X=56250 $Y=30720
X57947 1 2 6650 5030 DLY4_5VX1 $T=64520 403200 0 0 $X=64090 $Y=402560
X57948 1 2 5487 5583 DLY4_5VX1 $T=67320 331520 0 0 $X=66890 $Y=330880
X57949 1 2 5665 5414 DLY4_5VX1 $T=68440 421120 0 0 $X=68010 $Y=420480
X57950 1 2 5514 5615 DLY4_5VX1 $T=70120 376320 1 0 $X=69690 $Y=371200
X57951 1 2 6026 440 DLY4_5VX1 $T=72920 53760 1 0 $X=72490 $Y=48640
X57952 1 2 5612 5598 DLY4_5VX1 $T=75160 89600 0 0 $X=74730 $Y=88960
X57953 1 2 5457 5516 DLY4_5VX1 $T=80200 188160 1 0 $X=79770 $Y=183040
X57954 1 2 5486 5555 DLY4_5VX1 $T=83000 349440 1 0 $X=82570 $Y=344320
X57955 1 2 5869 5673 DLY4_5VX1 $T=91400 80640 1 0 $X=90970 $Y=75520
X57956 1 2 6015 4755 DLY4_5VX1 $T=106520 215040 1 0 $X=106090 $Y=209920
X57957 1 2 6046 5871 DLY4_5VX1 $T=112680 170240 0 0 $X=112250 $Y=169600
X57958 1 2 5336 5680 DLY4_5VX1 $T=124440 412160 0 0 $X=124010 $Y=411520
X57959 1 2 5697 5687 DLY4_5VX1 $T=125000 412160 1 0 $X=124570 $Y=407040
X57960 1 2 6256 5327 DLY4_5VX1 $T=151880 349440 0 0 $X=151450 $Y=348800
X57961 1 2 5274 5349 DLY4_5VX1 $T=151880 367360 0 0 $X=151450 $Y=366720
X57962 1 2 4225 6271 DLY4_5VX1 $T=159160 161280 0 0 $X=158730 $Y=160640
X57963 1 2 5296 6445 DLY4_5VX1 $T=162520 376320 1 0 $X=162090 $Y=371200
X57964 1 2 5639 6000 DLY4_5VX1 $T=166440 412160 1 0 $X=166010 $Y=407040
X57965 1 2 6392 9110 DLY4_5VX1 $T=166440 412160 0 0 $X=166010 $Y=411520
X57966 1 2 5477 5655 DLY4_5VX1 $T=166440 421120 1 0 $X=166010 $Y=416000
X57967 1 2 5733 5775 DLY4_5VX1 $T=166440 421120 0 0 $X=166010 $Y=420480
X57968 1 2 6467 501 DLY4_5VX1 $T=175400 62720 0 0 $X=174970 $Y=62080
X57969 1 2 5841 6176 DLY4_5VX1 $T=177080 412160 1 0 $X=176650 $Y=407040
X57970 1 2 6483 5881 DLY4_5VX1 $T=177080 421120 1 0 $X=176650 $Y=416000
X57971 1 2 6415 6490 DLY4_5VX1 $T=181000 394240 0 0 $X=180570 $Y=393600
X57972 1 2 5474 5283 DLY4_5VX1 $T=181000 403200 1 0 $X=180570 $Y=398080
X57973 1 2 5719 6583 DLY4_5VX1 $T=181000 403200 0 0 $X=180570 $Y=402560
X57974 1 2 5277 9907 DLY4_5VX1 $T=187720 421120 1 0 $X=187290 $Y=416000
X57975 1 2 5097 5305 DLY4_5VX1 $T=191080 394240 1 0 $X=190650 $Y=389120
X57976 1 2 5241 5294 DLY4_5VX1 $T=191640 394240 0 0 $X=191210 $Y=393600
X57977 1 2 5098 5354 DLY4_5VX1 $T=197240 340480 1 0 $X=196810 $Y=335360
X57978 1 2 6494 9177 DLY4_5VX1 $T=198920 152320 0 0 $X=198490 $Y=151680
X57979 1 2 4078 6611 DLY4_5VX1 $T=198920 179200 1 0 $X=198490 $Y=174080
X57980 1 2 4395 6448 DLY4_5VX1 $T=198920 197120 1 0 $X=198490 $Y=192000
X57981 1 2 6739 5373 DLY4_5VX1 $T=201160 331520 0 0 $X=200730 $Y=330880
X57982 1 2 4734 6015 DLY4_5VX1 $T=201720 394240 1 0 $X=201290 $Y=389120
X57983 1 2 6631 6777 DLY4_5VX1 $T=205640 277760 1 0 $X=205210 $Y=272640
X57984 1 2 5129 5339 DLY4_5VX1 $T=208440 286720 0 0 $X=208010 $Y=286080
X57985 1 2 6722 5749 DLY4_5VX1 $T=209000 143360 1 0 $X=208570 $Y=138240
X57986 1 2 5540 6595 DLY4_5VX1 $T=212360 394240 1 0 $X=211930 $Y=389120
X57987 1 2 521 529 DLY4_5VX1 $T=215720 17920 0 0 $X=215290 $Y=17280
X57988 1 2 6023 6028 DLY4_5VX1 $T=223560 376320 1 0 $X=223130 $Y=371200
X57989 1 2 4733 6356 DLY4_5VX1 $T=225240 143360 0 0 $X=224810 $Y=142720
X57990 1 2 6581 6818 DLY4_5VX1 $T=225800 179200 0 0 $X=225370 $Y=178560
X57991 1 2 4713 6556 DLY4_5VX1 $T=227480 152320 0 0 $X=227050 $Y=151680
X57992 1 2 6917 5624 DLY4_5VX1 $T=230840 367360 1 0 $X=230410 $Y=362240
X57993 1 2 9453 6819 DLY4_5VX1 $T=240920 197120 1 0 $X=240490 $Y=192000
X57994 1 2 4514 6175 DLY4_5VX1 $T=240920 358400 1 0 $X=240490 $Y=353280
X57995 1 2 6896 6624 DLY4_5VX1 $T=248760 152320 1 0 $X=248330 $Y=147200
X57996 1 2 6898 6812 DLY4_5VX1 $T=249880 161280 1 0 $X=249450 $Y=156160
X57997 1 2 6944 5838 DLY4_5VX1 $T=252120 340480 0 0 $X=251690 $Y=339840
X57998 1 2 4782 6457 DLY4_5VX1 $T=254360 134400 0 0 $X=253930 $Y=133760
X57999 1 2 558 7020 DLY4_5VX1 $T=257160 116480 0 0 $X=256730 $Y=115840
X58000 1 2 560 6564 DLY4_5VX1 $T=261640 188160 1 0 $X=261210 $Y=183040
X58001 1 2 5990 5978 DLY4_5VX1 $T=262760 340480 0 0 $X=262330 $Y=339840
X58002 1 2 7054 5896 DLY4_5VX1 $T=271720 331520 1 0 $X=271290 $Y=326400
X58003 1 2 9502 6014 DLY4_5VX1 $T=284040 322560 1 0 $X=283610 $Y=317440
X58004 1 2 6066 6088 DLY4_5VX1 $T=287960 313600 0 0 $X=287530 $Y=312960
X58005 1 2 5570 6065 DLY4_5VX1 $T=290760 313600 1 0 $X=290330 $Y=308480
X58006 1 2 6069 6208 DLY4_5VX1 $T=296360 304640 0 0 $X=295930 $Y=304000
X58007 1 2 6205 7248 DLY4_5VX1 $T=300280 304640 1 0 $X=299850 $Y=299520
X58008 1 2 6062 6157 DLY4_5VX1 $T=301400 313600 1 0 $X=300970 $Y=308480
X58009 1 2 585 7081 DLY4_5VX1 $T=305320 89600 1 0 $X=304890 $Y=84480
X58010 1 2 7279 7361 DLY4_5VX1 $T=317080 89600 0 0 $X=316650 $Y=88960
X58011 1 2 6426 6185 DLY4_5VX1 $T=319880 286720 1 0 $X=319450 $Y=281600
X58012 1 2 9892 7318 DLY4_5VX1 $T=320440 232960 0 0 $X=320010 $Y=232320
X58013 1 2 7334 7345 DLY4_5VX1 $T=328280 143360 0 0 $X=327850 $Y=142720
X58014 1 2 7022 7481 DLY4_5VX1 $T=349560 134400 1 0 $X=349130 $Y=129280
X58015 1 2 619 620 DLY4_5VX1 $T=355720 98560 1 0 $X=355290 $Y=93440
X58016 1 2 7425 9563 DLY4_5VX1 $T=360760 197120 1 0 $X=360330 $Y=192000
X58017 1 2 7359 7311 DLY4_5VX1 $T=361880 224000 0 0 $X=361450 $Y=223360
X58018 1 2 7502 7459 DLY4_5VX1 $T=371960 241920 0 0 $X=371530 $Y=241280
X58019 1 2 9630 7028 DLY4_5VX1 $T=376440 89600 1 0 $X=376010 $Y=84480
X58020 1 2 7432 7452 DLY4_5VX1 $T=377000 188160 1 0 $X=376570 $Y=183040
X58021 1 2 7531 7059 DLY4_5VX1 $T=377560 80640 1 0 $X=377130 $Y=75520
X58022 1 2 7581 7043 DLY4_5VX1 $T=401640 89600 1 0 $X=401210 $Y=84480
X58023 1 2 9649 7019 DLY4_5VX1 $T=401640 188160 0 0 $X=401210 $Y=187520
X58024 1 2 7622 6259 DLY4_5VX1 $T=401640 224000 0 0 $X=401210 $Y=223360
X58025 1 2 7596 7419 DLY4_5VX1 $T=402760 170240 1 0 $X=402330 $Y=165120
X58026 1 2 7632 7009 DLY4_5VX1 $T=413960 80640 0 0 $X=413530 $Y=80000
X58027 1 2 7551 650 DLY4_5VX1 $T=420120 62720 0 0 $X=419690 $Y=62080
X58028 1 2 7508 7281 DLY4_5VX1 $T=445880 215040 1 0 $X=445450 $Y=209920
X58029 1 2 807 853 DLY8_5VX1 $T=-597960 143360 0 0 $X=-598390 $Y=142720
X58030 1 2 810 859 DLY8_5VX1 $T=-596840 134400 0 0 $X=-597270 $Y=133760
X58031 1 2 811 860 DLY8_5VX1 $T=-596280 241920 0 0 $X=-596710 $Y=241280
X58032 1 2 815 862 DLY8_5VX1 $T=-595720 161280 0 0 $X=-596150 $Y=160640
X58033 1 2 9809 864 DLY8_5VX1 $T=-595160 224000 0 0 $X=-595590 $Y=223360
X58034 1 2 816 870 DLY8_5VX1 $T=-594600 206080 1 0 $X=-595030 $Y=200960
X58035 1 2 826 869 DLY8_5VX1 $T=-592920 197120 1 0 $X=-593350 $Y=192000
X58036 1 2 830 883 DLY8_5VX1 $T=-590680 170240 1 0 $X=-591110 $Y=165120
X58037 1 2 7934 8132 DLY8_5VX1 $T=-590120 152320 1 0 $X=-590550 $Y=147200
X58038 1 2 965 887 DLY8_5VX1 $T=-589000 215040 1 0 $X=-589430 $Y=209920
X58039 1 2 836 893 DLY8_5VX1 $T=-588440 161280 1 0 $X=-588870 $Y=156160
X58040 1 2 840 1354 DLY8_5VX1 $T=-588440 232960 0 0 $X=-588870 $Y=232320
X58041 1 2 1279 896 DLY8_5VX1 $T=-587880 188160 0 0 $X=-588310 $Y=187520
X58042 1 2 835 905 DLY8_5VX1 $T=-585080 134400 1 0 $X=-585510 $Y=129280
X58043 1 2 871 921 DLY8_5VX1 $T=-580600 224000 0 0 $X=-581030 $Y=223360
X58044 1 2 879 1243 DLY8_5VX1 $T=-578360 197120 1 0 $X=-578790 $Y=192000
X58045 1 2 882 928 DLY8_5VX1 $T=-577800 268800 0 0 $X=-578230 $Y=268160
X58046 1 2 960 977 DLY8_5VX1 $T=-565480 143360 0 0 $X=-565910 $Y=142720
X58047 1 2 949 1003 DLY8_5VX1 $T=-558760 107520 0 0 $X=-559190 $Y=106880
X58048 1 2 954 1008 DLY8_5VX1 $T=-557640 80640 1 0 $X=-558070 $Y=75520
X58049 1 2 927 1020 DLY8_5VX1 $T=-556520 89600 0 0 $X=-556950 $Y=88960
X58050 1 2 964 1026 DLY8_5VX1 $T=-555400 80640 0 0 $X=-555830 $Y=80000
X58051 1 2 969 1030 DLY8_5VX1 $T=-553720 53760 0 0 $X=-554150 $Y=53120
X58052 1 2 7961 1046 DLY8_5VX1 $T=-553160 215040 0 0 $X=-553590 $Y=214400
X58053 1 2 976 1047 DLY8_5VX1 $T=-551480 89600 1 0 $X=-551910 $Y=84480
X58054 1 2 984 1255 DLY8_5VX1 $T=-550920 98560 1 0 $X=-551350 $Y=93440
X58055 1 2 992 1051 DLY8_5VX1 $T=-549800 152320 0 0 $X=-550230 $Y=151680
X58056 1 2 999 1067 DLY8_5VX1 $T=-547560 71680 1 0 $X=-547990 $Y=66560
X58057 1 2 7968 1076 DLY8_5VX1 $T=-545880 304640 0 0 $X=-546310 $Y=304000
X58058 1 2 991 1091 DLY8_5VX1 $T=-543080 80640 1 0 $X=-543510 $Y=75520
X58059 1 2 1019 1239 DLY8_5VX1 $T=-541960 71680 0 0 $X=-542390 $Y=71040
X58060 1 2 952 1092 DLY8_5VX1 $T=-541960 89600 0 0 $X=-542390 $Y=88960
X58061 1 2 1031 1097 DLY8_5VX1 $T=-541400 62720 1 0 $X=-541830 $Y=57600
X58062 1 2 1034 1100 DLY8_5VX1 $T=-540840 80640 0 0 $X=-541270 $Y=80000
X58063 1 2 7976 2495 DLY8_5VX1 $T=-539720 62720 0 0 $X=-540150 $Y=62080
X58064 1 2 1038 8005 DLY8_5VX1 $T=-536920 89600 1 0 $X=-537350 $Y=84480
X58065 1 2 1062 1125 DLY8_5VX1 $T=-535240 53760 0 0 $X=-535670 $Y=53120
X58066 1 2 1165 1204 DLY8_5VX1 $T=-535240 116480 0 0 $X=-535670 $Y=115840
X58067 1 2 7986 1086 DLY8_5VX1 $T=-533000 71680 1 0 $X=-533430 $Y=66560
X58068 1 2 1073 1145 DLY8_5VX1 $T=-533000 215040 1 0 $X=-533430 $Y=209920
X58069 1 2 1088 1156 DLY8_5VX1 $T=-528520 80640 1 0 $X=-528950 $Y=75520
X58070 1 2 1025 1170 DLY8_5VX1 $T=-527400 71680 0 0 $X=-527830 $Y=71040
X58071 1 2 1102 1134 DLY8_5VX1 $T=-526840 62720 1 0 $X=-527270 $Y=57600
X58072 1 2 1035 1168 DLY8_5VX1 $T=-526840 161280 1 0 $X=-527270 $Y=156160
X58073 1 2 1104 1128 DLY8_5VX1 $T=-526280 80640 0 0 $X=-526710 $Y=80000
X58074 1 2 1109 1186 DLY8_5VX1 $T=-525160 62720 0 0 $X=-525590 $Y=62080
X58075 1 2 8007 1157 DLY8_5VX1 $T=-522360 89600 1 0 $X=-522790 $Y=84480
X58076 1 2 1122 1197 DLY8_5VX1 $T=-521800 35840 0 0 $X=-522230 $Y=35200
X58077 1 2 1133 1345 DLY8_5VX1 $T=-521240 44800 0 0 $X=-521670 $Y=44160
X58078 1 2 1139 1209 DLY8_5VX1 $T=-520680 53760 0 0 $X=-521110 $Y=53120
X58079 1 2 1141 9793 DLY8_5VX1 $T=-520120 53760 1 0 $X=-520550 $Y=48640
X58080 1 2 1152 1222 DLY8_5VX1 $T=-518440 71680 1 0 $X=-518870 $Y=66560
X58081 1 2 8016 1231 DLY8_5VX1 $T=-517320 116480 1 0 $X=-517750 $Y=111360
X58082 1 2 8025 1254 DLY8_5VX1 $T=-513400 44800 1 0 $X=-513830 $Y=39680
X58083 1 2 1180 1250 DLY8_5VX1 $T=-512840 71680 0 0 $X=-513270 $Y=71040
X58084 1 2 1177 1253 DLY8_5VX1 $T=-512280 26880 1 0 $X=-512710 $Y=21760
X58085 1 2 1179 8051 DLY8_5VX1 $T=-512280 62720 1 0 $X=-512710 $Y=57600
X58086 1 2 8029 1270 DLY8_5VX1 $T=-511720 161280 1 0 $X=-512150 $Y=156160
X58087 1 2 1192 1277 DLY8_5VX1 $T=-510600 35840 1 0 $X=-511030 $Y=30720
X58088 1 2 1821 1272 DLY8_5VX1 $T=-510600 62720 0 0 $X=-511030 $Y=62080
X58089 1 2 9814 2381 DLY8_5VX1 $T=-510040 26880 0 0 $X=-510470 $Y=26240
X58090 1 2 1175 1287 DLY8_5VX1 $T=-507240 35840 0 0 $X=-507670 $Y=35200
X58091 1 2 1096 1294 DLY8_5VX1 $T=-506680 44800 0 0 $X=-507110 $Y=44160
X58092 1 2 1221 1296 DLY8_5VX1 $T=-506120 53760 0 0 $X=-506550 $Y=53120
X58093 1 2 1066 1305 DLY8_5VX1 $T=-505560 53760 1 0 $X=-505990 $Y=48640
X58094 1 2 1234 1313 DLY8_5VX1 $T=-503880 71680 1 0 $X=-504310 $Y=66560
X58095 1 2 1208 3187 DLY8_5VX1 $T=-503320 17920 0 0 $X=-503750 $Y=17280
X58096 1 2 19 21 DLY8_5VX1 $T=-499400 17920 1 0 $X=-499830 $Y=12800
X58097 1 2 1261 1350 DLY8_5VX1 $T=-498840 44800 1 0 $X=-499270 $Y=39680
X58098 1 2 9908 1293 DLY8_5VX1 $T=-498840 340480 1 0 $X=-499270 $Y=335360
X58099 1 2 8048 1225 DLY8_5VX1 $T=-498280 71680 0 0 $X=-498710 $Y=71040
X58100 1 2 1271 1349 DLY8_5VX1 $T=-497720 26880 1 0 $X=-498150 $Y=21760
X58101 1 2 1267 1353 DLY8_5VX1 $T=-497720 62720 1 0 $X=-498150 $Y=57600
X58102 1 2 1281 1363 DLY8_5VX1 $T=-496040 35840 1 0 $X=-496470 $Y=30720
X58103 1 2 1282 1365 DLY8_5VX1 $T=-496040 62720 0 0 $X=-496470 $Y=62080
X58104 1 2 2212 1370 DLY8_5VX1 $T=-495480 26880 0 0 $X=-495910 $Y=26240
X58105 1 2 1303 1386 DLY8_5VX1 $T=-492680 35840 0 0 $X=-493110 $Y=35200
X58106 1 2 1304 1388 DLY8_5VX1 $T=-492120 44800 0 0 $X=-492550 $Y=44160
X58107 1 2 1312 1392 DLY8_5VX1 $T=-491560 53760 0 0 $X=-491990 $Y=53120
X58108 1 2 1314 1401 DLY8_5VX1 $T=-488200 89600 0 0 $X=-488630 $Y=88960
X58109 1 2 1344 1426 DLY8_5VX1 $T=-485960 241920 0 0 $X=-486390 $Y=241280
X58110 1 2 8081 1461 DLY8_5VX1 $T=-481480 62720 0 0 $X=-481910 $Y=62080
X58111 1 2 1405 1404 DLY8_5VX1 $T=-481480 349440 0 0 $X=-481910 $Y=348800
X58112 1 2 8089 1431 DLY8_5VX1 $T=-473640 179200 1 0 $X=-474070 $Y=174080
X58113 1 2 1440 1541 DLY8_5VX1 $T=-468600 89600 1 0 $X=-469030 $Y=84480
X58114 1 2 1496 1302 DLY8_5VX1 $T=-462440 125440 1 0 $X=-462870 $Y=120320
X58115 1 2 9818 1490 DLY8_5VX1 $T=-462440 358400 1 0 $X=-462870 $Y=353280
X58116 1 2 1487 38 DLY8_5VX1 $T=-459080 26880 1 0 $X=-459510 $Y=21760
X58117 1 2 1523 1563 DLY8_5VX1 $T=-456280 80640 1 0 $X=-456710 $Y=75520
X58118 1 2 1535 1549 DLY8_5VX1 $T=-456280 349440 0 0 $X=-456710 $Y=348800
X58119 1 2 1550 1648 DLY8_5VX1 $T=-453480 232960 0 0 $X=-453910 $Y=232320
X58120 1 2 8133 1574 DLY8_5VX1 $T=-449000 358400 0 0 $X=-449430 $Y=357760
X58121 1 2 1591 1577 DLY8_5VX1 $T=-447880 358400 1 0 $X=-448310 $Y=353280
X58122 1 2 1610 1628 DLY8_5VX1 $T=-443400 179200 0 0 $X=-443830 $Y=178560
X58123 1 2 1655 1647 DLY8_5VX1 $T=-438920 367360 0 0 $X=-439350 $Y=366720
X58124 1 2 1657 1758 DLY8_5VX1 $T=-438360 116480 0 0 $X=-438790 $Y=115840
X58125 1 2 1659 1639 DLY8_5VX1 $T=-437240 349440 1 0 $X=-437670 $Y=344320
X58126 1 2 1586 1769 DLY8_5VX1 $T=-436680 62720 1 0 $X=-437110 $Y=57600
X58127 1 2 37 52 DLY8_5VX1 $T=-436120 17920 1 0 $X=-436550 $Y=12800
X58128 1 2 1394 1379 DLY8_5VX1 $T=-436120 161280 0 0 $X=-436550 $Y=160640
X58129 1 2 8155 8186 DLY8_5VX1 $T=-435560 35840 1 0 $X=-435990 $Y=30720
X58130 1 2 1682 1794 DLY8_5VX1 $T=-433880 340480 0 0 $X=-434310 $Y=339840
X58131 1 2 1753 1870 DLY8_5VX1 $T=-423800 116480 1 0 $X=-424230 $Y=111360
X58132 1 2 1785 1726 DLY8_5VX1 $T=-421560 340480 1 0 $X=-421990 $Y=335360
X58133 1 2 1989 1899 DLY8_5VX1 $T=-420440 161280 0 0 $X=-420870 $Y=160640
X58134 1 2 8197 1790 DLY8_5VX1 $T=-418200 331520 1 0 $X=-418630 $Y=326400
X58135 1 2 2925 1847 DLY8_5VX1 $T=-416520 376320 0 0 $X=-416950 $Y=375680
X58136 1 2 1825 1930 DLY8_5VX1 $T=-415960 385280 1 0 $X=-416390 $Y=380160
X58137 1 2 8201 1680 DLY8_5VX1 $T=-415400 322560 0 0 $X=-415830 $Y=321920
X58138 1 2 1740 1757 DLY8_5VX1 $T=-415400 331520 0 0 $X=-415830 $Y=330880
X58139 1 2 1836 1939 DLY8_5VX1 $T=-415400 376320 1 0 $X=-415830 $Y=371200
X58140 1 2 1717 1858 DLY8_5VX1 $T=-414840 268800 0 0 $X=-415270 $Y=268160
X58141 1 2 8215 1896 DLY8_5VX1 $T=-407000 340480 1 0 $X=-407430 $Y=335360
X58142 1 2 1920 2022 DLY8_5VX1 $T=-405320 340480 0 0 $X=-405750 $Y=339840
X58143 1 2 2868 2023 DLY8_5VX1 $T=-405320 349440 1 0 $X=-405750 $Y=344320
X58144 1 2 2454 2024 DLY8_5VX1 $T=-405320 349440 0 0 $X=-405750 $Y=348800
X58145 1 2 1945 1937 DLY8_5VX1 $T=-403080 322560 1 0 $X=-403510 $Y=317440
X58146 1 2 1947 2053 DLY8_5VX1 $T=-401400 385280 1 0 $X=-401830 $Y=380160
X58147 1 2 1700 1833 DLY8_5VX1 $T=-400280 313600 0 0 $X=-400710 $Y=312960
X58148 1 2 1979 1929 DLY8_5VX1 $T=-397480 259840 1 0 $X=-397910 $Y=254720
X58149 1 2 8444 2091 DLY8_5VX1 $T=-397480 385280 0 0 $X=-397910 $Y=384640
X58150 1 2 1708 2107 DLY8_5VX1 $T=-395800 322560 0 0 $X=-396230 $Y=321920
X58151 1 2 1876 2033 DLY8_5VX1 $T=-390760 313600 1 0 $X=-391190 $Y=308480
X58152 1 2 8245 2090 DLY8_5VX1 $T=-390760 331520 1 0 $X=-391190 $Y=326400
X58153 1 2 1811 2163 DLY8_5VX1 $T=-390760 331520 0 0 $X=-391190 $Y=330880
X58154 1 2 1913 2141 DLY8_5VX1 $T=-390760 340480 1 0 $X=-391190 $Y=335360
X58155 1 2 2016 2098 DLY8_5VX1 $T=-390760 340480 0 0 $X=-391190 $Y=339840
X58156 1 2 2034 2838 DLY8_5VX1 $T=-390760 349440 1 0 $X=-391190 $Y=344320
X58157 1 2 2035 2171 DLY8_5VX1 $T=-390760 349440 0 0 $X=-391190 $Y=348800
X58158 1 2 2036 2149 DLY8_5VX1 $T=-390760 358400 1 0 $X=-391190 $Y=353280
X58159 1 2 2078 2190 DLY8_5VX1 $T=-386840 322560 1 0 $X=-387270 $Y=317440
X58160 1 2 2073 2191 DLY8_5VX1 $T=-386840 385280 1 0 $X=-387270 $Y=380160
X58161 1 2 2131 2233 DLY8_5VX1 $T=-380680 134400 1 0 $X=-381110 $Y=129280
X58162 1 2 2132 2270 DLY8_5VX1 $T=-376200 143360 0 0 $X=-376630 $Y=142720
X58163 1 2 2167 2240 DLY8_5VX1 $T=-376200 286720 0 0 $X=-376630 $Y=286080
X58164 1 2 1809 2355 DLY8_5VX1 $T=-376200 304640 1 0 $X=-376630 $Y=299520
X58165 1 2 2154 2247 DLY8_5VX1 $T=-376200 304640 0 0 $X=-376630 $Y=304000
X58166 1 2 2168 2235 DLY8_5VX1 $T=-376200 313600 1 0 $X=-376630 $Y=308480
X58167 1 2 2169 2419 DLY8_5VX1 $T=-376200 313600 0 0 $X=-376630 $Y=312960
X58168 1 2 2170 2253 DLY8_5VX1 $T=-376200 322560 0 0 $X=-376630 $Y=321920
X58169 1 2 1912 3156 DLY8_5VX1 $T=-376200 331520 1 0 $X=-376630 $Y=326400
X58170 1 2 2079 2254 DLY8_5VX1 $T=-376200 331520 0 0 $X=-376630 $Y=330880
X58171 1 2 2144 2285 DLY8_5VX1 $T=-376200 340480 1 0 $X=-376630 $Y=335360
X58172 1 2 1850 2264 DLY8_5VX1 $T=-376200 340480 0 0 $X=-376630 $Y=339840
X58173 1 2 1849 3297 DLY8_5VX1 $T=-376200 349440 1 0 $X=-376630 $Y=344320
X58174 1 2 2216 2188 DLY8_5VX1 $T=-376200 349440 0 0 $X=-376630 $Y=348800
X58175 1 2 2531 2255 DLY8_5VX1 $T=-376200 358400 1 0 $X=-376630 $Y=353280
X58176 1 2 2172 2248 DLY8_5VX1 $T=-376200 358400 0 0 $X=-376630 $Y=357760
X58177 1 2 2173 2949 DLY8_5VX1 $T=-376200 367360 1 0 $X=-376630 $Y=362240
X58178 1 2 2174 3244 DLY8_5VX1 $T=-376200 394240 1 0 $X=-376630 $Y=389120
X58179 1 2 2175 2258 DLY8_5VX1 $T=-376200 394240 0 0 $X=-376630 $Y=393600
X58180 1 2 2176 2267 DLY8_5VX1 $T=-376200 403200 1 0 $X=-376630 $Y=398080
X58181 1 2 8270 2266 DLY8_5VX1 $T=-376200 403200 0 0 $X=-376630 $Y=402560
X58182 1 2 714 2260 DLY8_5VX1 $T=-376200 421120 0 0 $X=-376630 $Y=420480
X58183 1 2 2151 2897 DLY8_5VX1 $T=-348200 71680 0 0 $X=-348630 $Y=71040
X58184 1 2 8294 2069 DLY8_5VX1 $T=-348200 268800 1 0 $X=-348630 $Y=263680
X58185 1 2 2289 2399 DLY8_5VX1 $T=-348200 421120 0 0 $X=-348630 $Y=420480
X58186 1 2 2277 2413 DLY8_5VX1 $T=-347640 152320 0 0 $X=-348070 $Y=151680
X58187 1 2 2283 2415 DLY8_5VX1 $T=-347080 295680 0 0 $X=-347510 $Y=295040
X58188 1 2 2373 2428 DLY8_5VX1 $T=-345960 250880 0 0 $X=-346390 $Y=250240
X58189 1 2 8305 2442 DLY8_5VX1 $T=-342600 286720 0 0 $X=-343030 $Y=286080
X58190 1 2 9828 2338 DLY8_5VX1 $T=-342600 385280 1 0 $X=-343030 $Y=380160
X58191 1 2 8306 2908 DLY8_5VX1 $T=-342040 376320 1 0 $X=-342470 $Y=371200
X58192 1 2 2352 2463 DLY8_5VX1 $T=-341480 331520 0 0 $X=-341910 $Y=330880
X58193 1 2 8308 2474 DLY8_5VX1 $T=-340920 206080 1 0 $X=-341350 $Y=200960
X58194 1 2 2353 2440 DLY8_5VX1 $T=-340920 349440 1 0 $X=-341350 $Y=344320
X58195 1 2 2325 2458 DLY8_5VX1 $T=-340920 367360 0 0 $X=-341350 $Y=366720
X58196 1 2 2377 2487 DLY8_5VX1 $T=-338120 322560 1 0 $X=-338550 $Y=317440
X58197 1 2 2072 2504 DLY8_5VX1 $T=-336440 376320 0 0 $X=-336870 $Y=375680
X58198 1 2 2396 2511 DLY8_5VX1 $T=-335320 367360 1 0 $X=-335750 $Y=362240
X58199 1 2 2420 2767 DLY8_5VX1 $T=-331960 268800 0 0 $X=-332390 $Y=268160
X58200 1 2 2432 2438 DLY8_5VX1 $T=-328040 152320 0 0 $X=-328470 $Y=151680
X58201 1 2 2370 2572 DLY8_5VX1 $T=-328040 385280 0 0 $X=-328470 $Y=384640
X58202 1 2 2121 2577 DLY8_5VX1 $T=-326920 385280 1 0 $X=-327350 $Y=380160
X58203 1 2 2852 2574 DLY8_5VX1 $T=-326360 349440 1 0 $X=-326790 $Y=344320
X58204 1 2 2348 721 DLY8_5VX1 $T=-325800 394240 1 0 $X=-326230 $Y=389120
X58205 1 2 2444 2599 DLY8_5VX1 $T=-323560 403200 1 0 $X=-323990 $Y=398080
X58206 1 2 2324 2621 DLY8_5VX1 $T=-319640 394240 0 0 $X=-320070 $Y=393600
X58207 1 2 2543 2825 DLY8_5VX1 $T=-317960 277760 1 0 $X=-318390 $Y=272640
X58208 1 2 8346 3128 DLY8_5VX1 $T=-317960 358400 1 0 $X=-318390 $Y=353280
X58209 1 2 2570 2665 DLY8_5VX1 $T=-314600 232960 0 0 $X=-315030 $Y=232320
X58210 1 2 2582 2685 DLY8_5VX1 $T=-312360 206080 0 0 $X=-312790 $Y=205440
X58211 1 2 2437 2692 DLY8_5VX1 $T=-311800 412160 1 0 $X=-312230 $Y=407040
X58212 1 2 9789 2708 DLY8_5VX1 $T=-309560 161280 1 0 $X=-309990 $Y=156160
X58213 1 2 2630 2743 DLY8_5VX1 $T=-303960 232960 1 0 $X=-304390 $Y=227840
X58214 1 2 2584 2746 DLY8_5VX1 $T=-303400 421120 1 0 $X=-303830 $Y=416000
X58215 1 2 2673 2770 DLY8_5VX1 $T=-300600 421120 0 0 $X=-301030 $Y=420480
X58216 1 2 2700 2691 DLY8_5VX1 $T=-297240 412160 1 0 $X=-297670 $Y=407040
X58217 1 2 2729 2796 DLY8_5VX1 $T=-296120 412160 0 0 $X=-296550 $Y=411520
X58218 1 2 8390 2671 DLY8_5VX1 $T=-290520 295680 0 0 $X=-290950 $Y=295040
X58219 1 2 2740 2828 DLY8_5VX1 $T=-290520 349440 1 0 $X=-290950 $Y=344320
X58220 1 2 3170 2854 DLY8_5VX1 $T=-288840 421120 1 0 $X=-289270 $Y=416000
X58221 1 2 2547 2874 DLY8_5VX1 $T=-286040 421120 0 0 $X=-286470 $Y=420480
X58222 1 2 2795 2881 DLY8_5VX1 $T=-283800 403200 0 0 $X=-284230 $Y=402560
X58223 1 2 2805 2893 DLY8_5VX1 $T=-282680 179200 0 0 $X=-283110 $Y=178560
X58224 1 2 2763 2900 DLY8_5VX1 $T=-282120 277760 0 0 $X=-282550 $Y=277120
X58225 1 2 2818 2896 DLY8_5VX1 $T=-281560 412160 0 0 $X=-281990 $Y=411520
X58226 1 2 2834 2909 DLY8_5VX1 $T=-281000 250880 0 0 $X=-281430 $Y=250240
X58227 1 2 2865 2960 DLY8_5VX1 $T=-274280 421120 1 0 $X=-274710 $Y=416000
X58228 1 2 2875 2979 DLY8_5VX1 $T=-271480 421120 0 0 $X=-271910 $Y=420480
X58229 1 2 2894 2994 DLY8_5VX1 $T=-269240 206080 0 0 $X=-269670 $Y=205440
X58230 1 2 2929 3255 DLY8_5VX1 $T=-267000 313600 1 0 $X=-267430 $Y=308480
X58231 1 2 2917 8458 DLY8_5VX1 $T=-267000 412160 0 0 $X=-267430 $Y=411520
X58232 1 2 2538 2792 DLY8_5VX1 $T=-264760 44800 1 0 $X=-265190 $Y=39680
X58233 1 2 8455 2977 DLY8_5VX1 $T=-260280 170240 1 0 $X=-260710 $Y=165120
X58234 1 2 2975 3212 DLY8_5VX1 $T=-259160 331520 1 0 $X=-259590 $Y=326400
X58235 1 2 2980 2936 DLY8_5VX1 $T=-256920 421120 0 0 $X=-257350 $Y=420480
X58236 1 2 8473 732 DLY8_5VX1 $T=-252440 412160 0 0 $X=-252870 $Y=411520
X58237 1 2 3033 3147 DLY8_5VX1 $T=-249640 62720 0 0 $X=-250070 $Y=62080
X58238 1 2 3004 3044 DLY8_5VX1 $T=-238440 304640 1 0 $X=-238870 $Y=299520
X58239 1 2 3155 4295 DLY8_5VX1 $T=-235640 143360 1 0 $X=-236070 $Y=138240
X58240 1 2 8542 3344 DLY8_5VX1 $T=-221080 170240 1 0 $X=-221510 $Y=165120
X58241 1 2 3273 3364 DLY8_5VX1 $T=-218280 134400 0 0 $X=-218710 $Y=133760
X58242 1 2 3134 3064 DLY8_5VX1 $T=-216040 232960 0 0 $X=-216470 $Y=232320
X58243 1 2 8563 3386 DLY8_5VX1 $T=-212680 322560 1 0 $X=-213110 $Y=317440
X58244 1 2 3429 3522 DLY8_5VX1 $T=-198120 322560 1 0 $X=-198550 $Y=317440
X58245 1 2 3562 3584 DLY8_5VX1 $T=-185240 331520 0 0 $X=-185670 $Y=330880
X58246 1 2 3592 3685 DLY8_5VX1 $T=-181880 349440 0 0 $X=-182310 $Y=348800
X58247 1 2 3412 3394 DLY8_5VX1 $T=-172360 421120 1 0 $X=-172790 $Y=416000
X58248 1 2 3350 3261 DLY8_5VX1 $T=-171240 340480 1 0 $X=-171670 $Y=335360
X58249 1 2 3781 3741 DLY8_5VX1 $T=-162840 412160 1 0 $X=-163270 $Y=407040
X58250 1 2 3516 3508 DLY8_5VX1 $T=-162840 421120 0 0 $X=-163270 $Y=420480
X58251 1 2 3784 3920 DLY8_5VX1 $T=-162280 259840 0 0 $X=-162710 $Y=259200
X58252 1 2 3596 3918 DLY8_5VX1 $T=-161720 188160 1 0 $X=-162150 $Y=183040
X58253 1 2 3486 3471 DLY8_5VX1 $T=-155560 412160 0 0 $X=-155990 $Y=411520
X58254 1 2 4181 3998 DLY8_5VX1 $T=-153880 161280 1 0 $X=-154310 $Y=156160
X58255 1 2 3867 3866 DLY8_5VX1 $T=-153880 421120 1 0 $X=-154310 $Y=416000
X58256 1 2 3822 3855 DLY8_5VX1 $T=-151080 394240 0 0 $X=-151510 $Y=393600
X58257 1 2 3688 3700 DLY8_5VX1 $T=-148280 421120 0 0 $X=-148710 $Y=420480
X58258 1 2 3960 4087 DLY8_5VX1 $T=-143800 277760 0 0 $X=-144230 $Y=277120
X58259 1 2 3955 4091 DLY8_5VX1 $T=-142120 403200 0 0 $X=-142550 $Y=402560
X58260 1 2 3873 3912 DLY8_5VX1 $T=-141000 412160 0 0 $X=-141430 $Y=411520
X58261 1 2 3956 3898 DLY8_5VX1 $T=-139320 394240 1 0 $X=-139750 $Y=389120
X58262 1 2 3693 3684 DLY8_5VX1 $T=-139320 421120 1 0 $X=-139750 $Y=416000
X58263 1 2 4034 4041 DLY8_5VX1 $T=-134280 412160 1 0 $X=-134710 $Y=407040
X58264 1 2 8750 4064 DLY8_5VX1 $T=-133160 394240 0 0 $X=-133590 $Y=393600
X58265 1 2 4036 4183 DLY8_5VX1 $T=-132040 295680 0 0 $X=-132470 $Y=295040
X58266 1 2 3641 3765 DLY8_5VX1 $T=-132040 403200 1 0 $X=-132470 $Y=398080
X58267 1 2 3745 3738 DLY8_5VX1 $T=-127560 403200 0 0 $X=-127990 $Y=402560
X58268 1 2 8770 4136 DLY8_5VX1 $T=-126440 412160 0 0 $X=-126870 $Y=411520
X58269 1 2 8768 4126 DLY8_5VX1 $T=-126440 421120 0 0 $X=-126870 $Y=420480
X58270 1 2 8806 4109 DLY8_5VX1 $T=-97880 349440 0 0 $X=-98310 $Y=348800
X58271 1 2 4226 315 DLY8_5VX1 $T=-97880 358400 1 0 $X=-98310 $Y=353280
X58272 1 2 4116 4125 DLY8_5VX1 $T=-97880 367360 1 0 $X=-98310 $Y=362240
X58273 1 2 4285 4398 DLY8_5VX1 $T=-97880 376320 1 0 $X=-98310 $Y=371200
X58274 1 2 4121 4162 DLY8_5VX1 $T=-97880 376320 0 0 $X=-98310 $Y=375680
X58275 1 2 3860 3880 DLY8_5VX1 $T=-97880 394240 0 0 $X=-98310 $Y=393600
X58276 1 2 3618 3626 DLY8_5VX1 $T=-97880 403200 1 0 $X=-98310 $Y=398080
X58277 1 2 3410 3462 DLY8_5VX1 $T=-97880 403200 0 0 $X=-98310 $Y=402560
X58278 1 2 4073 4393 DLY8_5VX1 $T=-97880 412160 1 0 $X=-98310 $Y=407040
X58279 1 2 3430 3480 DLY8_5VX1 $T=-97880 412160 0 0 $X=-98310 $Y=411520
X58280 1 2 4301 3900 DLY8_5VX1 $T=-97880 421120 1 0 $X=-98310 $Y=416000
X58281 1 2 4273 3501 DLY8_5VX1 $T=-97880 421120 0 0 $X=-98310 $Y=420480
X58282 1 2 4308 4401 DLY8_5VX1 $T=-97320 286720 0 0 $X=-97750 $Y=286080
X58283 1 2 4218 4370 DLY8_5VX1 $T=-96200 385280 0 0 $X=-96630 $Y=384640
X58284 1 2 4329 4282 DLY8_5VX1 $T=-95080 367360 0 0 $X=-95510 $Y=366720
X58285 1 2 4318 4425 DLY8_5VX1 $T=-95080 394240 1 0 $X=-95510 $Y=389120
X58286 1 2 8957 4455 DLY8_5VX1 $T=-91720 385280 1 0 $X=-92150 $Y=380160
X58287 1 2 4346 4458 DLY8_5VX1 $T=-91160 26880 1 0 $X=-91590 $Y=21760
X58288 1 2 4384 4502 DLY8_5VX1 $T=-86120 358400 0 0 $X=-86550 $Y=357760
X58289 1 2 4402 4501 DLY8_5VX1 $T=-85000 349440 1 0 $X=-85430 $Y=344320
X58290 1 2 3988 3987 DLY8_5VX1 $T=-83320 412160 1 0 $X=-83750 $Y=407040
X58291 1 2 4344 4347 DLY8_5VX1 $T=-83320 412160 0 0 $X=-83750 $Y=411520
X58292 1 2 4547 4494 DLY8_5VX1 $T=-82200 358400 1 0 $X=-82630 $Y=353280
X58293 1 2 4319 4530 DLY8_5VX1 $T=-82200 394240 0 0 $X=-82630 $Y=393600
X58294 1 2 4424 4536 DLY8_5VX1 $T=-81640 385280 0 0 $X=-82070 $Y=384640
X58295 1 2 4423 4549 DLY8_5VX1 $T=-80520 367360 1 0 $X=-80950 $Y=362240
X58296 1 2 4440 4971 DLY8_5VX1 $T=-80520 367360 0 0 $X=-80950 $Y=366720
X58297 1 2 4441 4461 DLY8_5VX1 $T=-80520 394240 1 0 $X=-80950 $Y=389120
X58298 1 2 4420 4555 DLY8_5VX1 $T=-80520 421120 0 0 $X=-80950 $Y=420480
X58299 1 2 4371 4454 DLY8_5VX1 $T=-78840 376320 0 0 $X=-79270 $Y=375680
X58300 1 2 4452 4400 DLY8_5VX1 $T=-77160 385280 1 0 $X=-77590 $Y=380160
X58301 1 2 4466 4481 DLY8_5VX1 $T=-77160 421120 1 0 $X=-77590 $Y=416000
X58302 1 2 4472 4578 DLY8_5VX1 $T=-76600 322560 0 0 $X=-77030 $Y=321920
X58303 1 2 8841 4580 DLY8_5VX1 $T=-76040 403200 1 0 $X=-76470 $Y=398080
X58304 1 2 4459 4480 DLY8_5VX1 $T=-75480 340480 0 0 $X=-75910 $Y=339840
X58305 1 2 4503 4620 DLY8_5VX1 $T=-72680 403200 0 0 $X=-73110 $Y=402560
X58306 1 2 4537 5009 DLY8_5VX1 $T=-67640 394240 0 0 $X=-68070 $Y=393600
X58307 1 2 4545 4661 DLY8_5VX1 $T=-67080 385280 0 0 $X=-67510 $Y=384640
X58308 1 2 4559 4679 DLY8_5VX1 $T=-65960 394240 1 0 $X=-66390 $Y=389120
X58309 1 2 4497 4548 DLY8_5VX1 $T=-65960 421120 0 0 $X=-66390 $Y=420480
X58310 1 2 8802 5341 DLY8_5VX1 $T=-64280 412160 1 0 $X=-64710 $Y=407040
X58311 1 2 4596 4692 DLY8_5VX1 $T=-62600 421120 1 0 $X=-63030 $Y=416000
X58312 1 2 4624 4644 DLY8_5VX1 $T=-59240 340480 1 0 $X=-59670 $Y=335360
X58313 1 2 4585 4673 DLY8_5VX1 $T=-57000 179200 0 0 $X=-57430 $Y=178560
X58314 1 2 4682 4771 DLY8_5VX1 $T=-52520 385280 0 0 $X=-52950 $Y=384640
X58315 1 2 4678 4779 DLY8_5VX1 $T=-51960 367360 0 0 $X=-52390 $Y=366720
X58316 1 2 4683 4636 DLY8_5VX1 $T=-51400 277760 0 0 $X=-51830 $Y=277120
X58317 1 2 8879 4702 DLY8_5VX1 $T=-49720 241920 1 0 $X=-50150 $Y=236800
X58318 1 2 4286 4820 DLY8_5VX1 $T=-48040 421120 1 0 $X=-48470 $Y=416000
X58319 1 2 4287 4837 DLY8_5VX1 $T=-45800 421120 0 0 $X=-46230 $Y=420480
X58320 1 2 4937 4866 DLY8_5VX1 $T=-41880 394240 0 0 $X=-42310 $Y=393600
X58321 1 2 4795 4910 DLY8_5VX1 $T=-37400 367360 0 0 $X=-37830 $Y=366720
X58322 1 2 5764 4921 DLY8_5VX1 $T=-36280 17920 0 0 $X=-36710 $Y=17280
X58323 1 2 4836 4951 DLY8_5VX1 $T=-31800 403200 1 0 $X=-32230 $Y=398080
X58324 1 2 4838 5006 DLY8_5VX1 $T=-31240 421120 0 0 $X=-31670 $Y=420480
X58325 1 2 4495 4949 DLY8_5VX1 $T=-30120 35840 0 0 $X=-30550 $Y=35200
X58326 1 2 4955 5045 DLY8_5VX1 $T=-17800 340480 0 0 $X=-18230 $Y=339840
X58327 1 2 4411 4693 DLY8_5VX1 $T=-15560 89600 1 0 $X=-15990 $Y=84480
X58328 1 2 4998 765 DLY8_5VX1 $T=-9960 376320 0 0 $X=-10390 $Y=375680
X58329 1 2 5061 5182 DLY8_5VX1 $T=680 421120 0 0 $X=250 $Y=420480
X58330 1 2 5067 5204 DLY8_5VX1 $T=6840 403200 0 0 $X=6410 $Y=402560
X58331 1 2 5175 5059 DLY8_5VX1 $T=14120 421120 1 0 $X=13690 $Y=416000
X58332 1 2 5321 5376 DLY8_5VX1 $T=28120 403200 1 0 $X=27690 $Y=398080
X58333 1 2 5267 5266 DLY8_5VX1 $T=28680 421120 1 0 $X=28250 $Y=416000
X58334 1 2 5369 5361 DLY8_5VX1 $T=35400 421120 0 0 $X=34970 $Y=420480
X58335 1 2 5401 5390 DLY8_5VX1 $T=39880 412160 1 0 $X=39450 $Y=407040
X58336 1 2 9083 5568 DLY8_5VX1 $T=45480 340480 1 0 $X=45050 $Y=335360
X58337 1 2 5481 5589 DLY8_5VX1 $T=47720 215040 1 0 $X=47290 $Y=209920
X58338 1 2 5318 5546 DLY8_5VX1 $T=49960 403200 0 0 $X=49530 $Y=402560
X58339 1 2 5499 5531 DLY8_5VX1 $T=53880 421120 0 0 $X=53450 $Y=420480
X58340 1 2 9139 5601 DLY8_5VX1 $T=64520 421120 1 0 $X=64090 $Y=416000
X58341 1 2 5717 5766 DLY8_5VX1 $T=78520 385280 0 0 $X=78090 $Y=384640
X58342 1 2 5718 5745 DLY8_5VX1 $T=78520 412160 0 0 $X=78090 $Y=411520
X58343 1 2 5671 5847 DLY8_5VX1 $T=79080 421120 1 0 $X=78650 $Y=416000
X58344 1 2 5762 5761 DLY8_5VX1 $T=79640 421120 0 0 $X=79210 $Y=420480
X58345 1 2 5800 5864 DLY8_5VX1 $T=86920 403200 0 0 $X=86490 $Y=402560
X58346 1 2 5828 6002 DLY8_5VX1 $T=92520 152320 0 0 $X=92090 $Y=151680
X58347 1 2 5720 5734 DLY8_5VX1 $T=93640 421120 1 0 $X=93210 $Y=416000
X58348 1 2 5616 5654 DLY8_5VX1 $T=94200 421120 0 0 $X=93770 $Y=420480
X58349 1 2 9183 5833 DLY8_5VX1 $T=95320 412160 0 0 $X=94890 $Y=411520
X58350 1 2 5709 5769 DLY8_5VX1 $T=95880 358400 1 0 $X=95450 $Y=353280
X58351 1 2 5897 5922 DLY8_5VX1 $T=105400 376320 0 0 $X=104970 $Y=375680
X58352 1 2 9868 5985 DLY8_5VX1 $T=105960 403200 1 0 $X=105530 $Y=398080
X58353 1 2 5439 5445 DLY8_5VX1 $T=108200 421120 1 0 $X=107770 $Y=416000
X58354 1 2 9219 5637 DLY8_5VX1 $T=108760 421120 0 0 $X=108330 $Y=420480
X58355 1 2 5350 5328 DLY8_5VX1 $T=109880 412160 0 0 $X=109450 $Y=411520
X58356 1 2 9222 6017 DLY8_5VX1 $T=110440 412160 1 0 $X=110010 $Y=407040
X58357 1 2 5783 5469 DLY8_5VX1 $T=111560 331520 0 0 $X=111130 $Y=330880
X58358 1 2 6116 6212 DLY8_5VX1 $T=120520 403200 1 0 $X=120090 $Y=398080
X58359 1 2 6117 5422 DLY8_5VX1 $T=120520 403200 0 0 $X=120090 $Y=402560
X58360 1 2 5899 6059 DLY8_5VX1 $T=121080 376320 1 0 $X=120650 $Y=371200
X58361 1 2 6138 5574 DLY8_5VX1 $T=122760 421120 1 0 $X=122330 $Y=416000
X58362 1 2 6099 6135 DLY8_5VX1 $T=123320 241920 0 0 $X=122890 $Y=241280
X58363 1 2 5646 6250 DLY8_5VX1 $T=123320 421120 0 0 $X=122890 $Y=420480
X58364 1 2 6152 6346 DLY8_5VX1 $T=123880 232960 0 0 $X=123450 $Y=232320
X58365 1 2 5898 5938 DLY8_5VX1 $T=151880 340480 1 0 $X=151450 $Y=335360
X58366 1 2 5638 5630 DLY8_5VX1 $T=151880 394240 0 0 $X=151450 $Y=393600
X58367 1 2 6265 5662 DLY8_5VX1 $T=151880 403200 1 0 $X=151450 $Y=398080
X58368 1 2 6266 5508 DLY8_5VX1 $T=151880 403200 0 0 $X=151450 $Y=402560
X58369 1 2 6249 5529 DLY8_5VX1 $T=151880 412160 1 0 $X=151450 $Y=407040
X58370 1 2 5809 5903 DLY8_5VX1 $T=151880 412160 0 0 $X=151450 $Y=411520
X58371 1 2 5802 5928 DLY8_5VX1 $T=151880 421120 1 0 $X=151450 $Y=416000
X58372 1 2 5402 5460 DLY8_5VX1 $T=151880 421120 0 0 $X=151450 $Y=420480
X58373 1 2 6322 6685 DLY8_5VX1 $T=159720 62720 1 0 $X=159290 $Y=57600
X58374 1 2 6351 5659 DLY8_5VX1 $T=161960 394240 1 0 $X=161530 $Y=389120
X58375 1 2 6343 5564 DLY8_5VX1 $T=163080 385280 0 0 $X=162650 $Y=384640
X58376 1 2 6282 6362 DLY8_5VX1 $T=166440 394240 0 0 $X=166010 $Y=393600
X58377 1 2 5426 5492 DLY8_5VX1 $T=166440 403200 1 0 $X=166010 $Y=398080
X58378 1 2 5074 5065 DLY8_5VX1 $T=166440 403200 0 0 $X=166010 $Y=402560
X58379 1 2 5580 772 DLY8_5VX1 $T=168120 286720 0 0 $X=167690 $Y=286080
X58380 1 2 6379 5793 DLY8_5VX1 $T=170920 385280 1 0 $X=170490 $Y=380160
X58381 1 2 6464 5848 DLY8_5VX1 $T=175960 322560 0 0 $X=175530 $Y=321920
X58382 1 2 6475 6667 DLY8_5VX1 $T=176520 134400 0 0 $X=176090 $Y=133760
X58383 1 2 9879 6472 DLY8_5VX1 $T=176520 367360 0 0 $X=176090 $Y=366720
X58384 1 2 9332 6461 DLY8_5VX1 $T=176520 394240 1 0 $X=176090 $Y=389120
X58385 1 2 6491 5875 DLY8_5VX1 $T=177640 385280 0 0 $X=177210 $Y=384640
X58386 1 2 6499 507 DLY8_5VX1 $T=179320 241920 1 0 $X=178890 $Y=236800
X58387 1 2 6492 6317 DLY8_5VX1 $T=179880 412160 0 0 $X=179450 $Y=411520
X58388 1 2 6402 6606 DLY8_5VX1 $T=181560 349440 0 0 $X=181130 $Y=348800
X58389 1 2 6327 6666 DLY8_5VX1 $T=187160 376320 0 0 $X=186730 $Y=375680
X58390 1 2 5752 4247 DLY8_5VX1 $T=187720 412160 1 0 $X=187290 $Y=407040
X58391 1 2 6304 5553 DLY8_5VX1 $T=188840 376320 1 0 $X=188410 $Y=371200
X58392 1 2 6588 5768 DLY8_5VX1 $T=190520 358400 0 0 $X=190090 $Y=357760
X58393 1 2 6590 5238 DLY8_5VX1 $T=191080 367360 0 0 $X=190650 $Y=366720
X58394 1 2 6549 6700 DLY8_5VX1 $T=191640 385280 1 0 $X=191210 $Y=380160
X58395 1 2 5613 6246 DLY8_5VX1 $T=191640 403200 1 0 $X=191210 $Y=398080
X58396 1 2 9360 516 DLY8_5VX1 $T=192200 295680 1 0 $X=191770 $Y=290560
X58397 1 2 6569 6535 DLY8_5VX1 $T=192200 385280 0 0 $X=191770 $Y=384640
X58398 1 2 9366 6652 DLY8_5VX1 $T=193880 241920 1 0 $X=193450 $Y=236800
X58399 1 2 6646 6639 DLY8_5VX1 $T=194440 170240 1 0 $X=194010 $Y=165120
X58400 1 2 6618 5873 DLY8_5VX1 $T=194440 358400 1 0 $X=194010 $Y=353280
X58401 1 2 6599 6635 DLY8_5VX1 $T=201720 367360 1 0 $X=201290 $Y=362240
X58402 1 2 5359 4387 DLY8_5VX1 $T=202280 394240 0 0 $X=201850 $Y=393600
X58403 1 2 6671 5954 DLY8_5VX1 $T=202840 304640 0 0 $X=202410 $Y=304000
X58404 1 2 6657 6675 DLY8_5VX1 $T=202840 376320 0 0 $X=202410 $Y=375680
X58405 1 2 6587 6678 DLY8_5VX1 $T=203400 376320 1 0 $X=202970 $Y=371200
X58406 1 2 6691 6302 DLY8_5VX1 $T=205080 358400 0 0 $X=204650 $Y=357760
X58407 1 2 6546 6656 DLY8_5VX1 $T=205640 367360 0 0 $X=205210 $Y=366720
X58408 1 2 9391 6715 DLY8_5VX1 $T=208440 241920 1 0 $X=208010 $Y=236800
X58409 1 2 5551 5519 DLY8_5VX1 $T=208440 340480 0 0 $X=208010 $Y=339840
X58410 1 2 6723 6034 DLY8_5VX1 $T=209000 358400 1 0 $X=208570 $Y=353280
X58411 1 2 9399 6754 DLY8_5VX1 $T=210680 250880 1 0 $X=210250 $Y=245760
X58412 1 2 6686 6733 DLY8_5VX1 $T=211240 179200 0 0 $X=210810 $Y=178560
X58413 1 2 5587 5621 DLY8_5VX1 $T=211240 322560 1 0 $X=210810 $Y=317440
X58414 1 2 6744 6487 DLY8_5VX1 $T=212360 349440 0 0 $X=211930 $Y=348800
X58415 1 2 5620 6506 DLY8_5VX1 $T=212360 385280 1 0 $X=211930 $Y=380160
X58416 1 2 6753 5498 DLY8_5VX1 $T=214600 349440 1 0 $X=214170 $Y=344320
X58417 1 2 9382 6719 DLY8_5VX1 $T=216280 367360 1 0 $X=215850 $Y=362240
X58418 1 2 5441 6530 DLY8_5VX1 $T=217400 376320 0 0 $X=216970 $Y=375680
X58419 1 2 6699 6668 DLY8_5VX1 $T=219640 358400 0 0 $X=219210 $Y=357760
X58420 1 2 6078 6085 DLY8_5VX1 $T=220200 286720 1 0 $X=219770 $Y=281600
X58421 1 2 5997 9448 DLY8_5VX1 $T=223000 340480 0 0 $X=222570 $Y=339840
X58422 1 2 6773 6735 DLY8_5VX1 $T=223560 304640 0 0 $X=223130 $Y=304000
X58423 1 2 6683 6734 DLY8_5VX1 $T=223560 358400 1 0 $X=223130 $Y=353280
X58424 1 2 6751 6886 DLY8_5VX1 $T=225800 170240 1 0 $X=225370 $Y=165120
X58425 1 2 5526 5545 DLY8_5VX1 $T=225800 322560 1 0 $X=225370 $Y=317440
X58426 1 2 6822 6197 DLY8_5VX1 $T=225800 340480 1 0 $X=225370 $Y=335360
X58427 1 2 6705 6824 DLY8_5VX1 $T=226360 197120 1 0 $X=225930 $Y=192000
X58428 1 2 5566 6529 DLY8_5VX1 $T=226360 367360 0 0 $X=225930 $Y=366720
X58429 1 2 5798 5849 DLY8_5VX1 $T=226920 268800 1 0 $X=226490 $Y=263680
X58430 1 2 5588 5606 DLY8_5VX1 $T=226920 313600 1 0 $X=226490 $Y=308480
X58431 1 2 6720 6800 DLY8_5VX1 $T=226920 349440 0 0 $X=226490 $Y=348800
X58432 1 2 6848 6784 DLY8_5VX1 $T=227480 304640 1 0 $X=227050 $Y=299520
X58433 1 2 9436 6805 DLY8_5VX1 $T=228600 241920 1 0 $X=228170 $Y=236800
X58434 1 2 6847 537 DLY8_5VX1 $T=229160 250880 0 0 $X=228730 $Y=250240
X58435 1 2 6551 6663 DLY8_5VX1 $T=229160 349440 1 0 $X=228730 $Y=344320
X58436 1 2 5437 5536 DLY8_5VX1 $T=229720 313600 0 0 $X=229290 $Y=312960
X58437 1 2 6688 6725 DLY8_5VX1 $T=231400 134400 1 0 $X=230970 $Y=129280
X58438 1 2 6857 6439 DLY8_5VX1 $T=231400 331520 0 0 $X=230970 $Y=330880
X58439 1 2 5758 6919 DLY8_5VX1 $T=231960 268800 0 0 $X=231530 $Y=268160
X58440 1 2 5641 5738 DLY8_5VX1 $T=231960 322560 0 0 $X=231530 $Y=321920
X58441 1 2 9441 6797 DLY8_5VX1 $T=233080 224000 1 0 $X=232650 $Y=218880
X58442 1 2 6594 5837 DLY8_5VX1 $T=233080 259840 0 0 $X=232650 $Y=259200
X58443 1 2 6866 6089 DLY8_5VX1 $T=233080 277760 1 0 $X=232650 $Y=272640
X58444 1 2 9442 6853 DLY8_5VX1 $T=233640 295680 1 0 $X=233210 $Y=290560
X58445 1 2 5600 6922 DLY8_5VX1 $T=234200 331520 1 0 $X=233770 $Y=326400
X58446 1 2 6873 6636 DLY8_5VX1 $T=234760 277760 0 0 $X=234330 $Y=277120
X58447 1 2 5690 5722 DLY8_5VX1 $T=234760 286720 1 0 $X=234330 $Y=281600
X58448 1 2 9449 6908 DLY8_5VX1 $T=235880 295680 0 0 $X=235450 $Y=295040
X58449 1 2 6874 5852 DLY8_5VX1 $T=237000 259840 1 0 $X=236570 $Y=254720
X58450 1 2 5520 5572 DLY8_5VX1 $T=237000 286720 0 0 $X=236570 $Y=286080
X58451 1 2 5977 4444 DLY8_5VX1 $T=237000 358400 0 0 $X=236570 $Y=357760
X58452 1 2 6844 6870 DLY8_5VX1 $T=237560 340480 0 0 $X=237130 $Y=339840
X58453 1 2 5563 6950 DLY8_5VX1 $T=238120 304640 0 0 $X=237690 $Y=304000
X58454 1 2 6505 5912 DLY8_5VX1 $T=240360 250880 1 0 $X=239930 $Y=245760
X58455 1 2 6892 6637 DLY8_5VX1 $T=240360 322560 1 0 $X=239930 $Y=317440
X58456 1 2 6894 6788 DLY8_5VX1 $T=240920 224000 0 0 $X=240490 $Y=223360
X58457 1 2 793 6895 DLY8_5VX1 $T=240920 340480 1 0 $X=240490 $Y=335360
X58458 1 2 6035 6071 DLY8_5VX1 $T=241480 268800 1 0 $X=241050 $Y=263680
X58459 1 2 6903 5636 DLY8_5VX1 $T=241480 313600 1 0 $X=241050 $Y=308480
X58460 1 2 5507 5605 DLY8_5VX1 $T=242040 304640 1 0 $X=241610 $Y=299520
X58461 1 2 6601 556 DLY8_5VX1 $T=243160 241920 1 0 $X=242730 $Y=236800
X58462 1 2 5872 5839 DLY8_5VX1 $T=243720 250880 0 0 $X=243290 $Y=250240
X58463 1 2 6909 6662 DLY8_5VX1 $T=244280 232960 0 0 $X=243850 $Y=232320
X58464 1 2 5675 5682 DLY8_5VX1 $T=244280 313600 0 0 $X=243850 $Y=312960
X58465 1 2 5643 6961 DLY8_5VX1 $T=244280 349440 0 0 $X=243850 $Y=348800
X58466 1 2 6698 6782 DLY8_5VX1 $T=245960 197120 0 0 $X=245530 $Y=196480
X58467 1 2 9460 5765 DLY8_5VX1 $T=245960 241920 0 0 $X=245530 $Y=241280
X58468 1 2 6843 6878 DLY8_5VX1 $T=245960 331520 0 0 $X=245530 $Y=330880
X58469 1 2 6669 6989 DLY8_5VX1 $T=246520 232960 1 0 $X=246090 $Y=227840
X58470 1 2 6905 6990 DLY8_5VX1 $T=246520 268800 0 0 $X=246090 $Y=268160
X58471 1 2 6920 6902 DLY8_5VX1 $T=246520 322560 0 0 $X=246090 $Y=321920
X58472 1 2 6534 6781 DLY8_5VX1 $T=247640 224000 1 0 $X=247210 $Y=218880
X58473 1 2 5694 5656 DLY8_5VX1 $T=247640 259840 0 0 $X=247210 $Y=259200
X58474 1 2 6372 6260 DLY8_5VX1 $T=247640 277760 1 0 $X=247210 $Y=272640
X58475 1 2 5658 5666 DLY8_5VX1 $T=248200 295680 1 0 $X=247770 $Y=290560
X58476 1 2 6928 6877 DLY8_5VX1 $T=248760 331520 1 0 $X=248330 $Y=326400
X58477 1 2 5737 5729 DLY8_5VX1 $T=249320 277760 0 0 $X=248890 $Y=277120
X58478 1 2 6931 5772 DLY8_5VX1 $T=249320 286720 1 0 $X=248890 $Y=281600
X58479 1 2 5634 6826 DLY8_5VX1 $T=249880 349440 1 0 $X=249450 $Y=344320
X58480 1 2 6749 6174 DLY8_5VX1 $T=250440 295680 0 0 $X=250010 $Y=295040
X58481 1 2 6937 6167 DLY8_5VX1 $T=251560 259840 1 0 $X=251130 $Y=254720
X58482 1 2 6936 5713 DLY8_5VX1 $T=251560 286720 0 0 $X=251130 $Y=286080
X58483 1 2 6943 6047 DLY8_5VX1 $T=252680 304640 0 0 $X=252250 $Y=304000
X58484 1 2 6572 5707 DLY8_5VX1 $T=254920 250880 1 0 $X=254490 $Y=245760
X58485 1 2 6610 6640 DLY8_5VX1 $T=254920 322560 1 0 $X=254490 $Y=317440
X58486 1 2 6600 567 DLY8_5VX1 $T=255480 224000 0 0 $X=255050 $Y=223360
X58487 1 2 6863 6882 DLY8_5VX1 $T=256040 268800 1 0 $X=255610 $Y=263680
X58488 1 2 6965 5886 DLY8_5VX1 $T=256040 313600 1 0 $X=255610 $Y=308480
X58489 1 2 6976 7046 DLY8_5VX1 $T=256600 304640 1 0 $X=256170 $Y=299520
X58490 1 2 6978 6817 DLY8_5VX1 $T=257720 170240 0 0 $X=257290 $Y=169600
X58491 1 2 6458 6486 DLY8_5VX1 $T=257720 241920 1 0 $X=257290 $Y=236800
X58492 1 2 6975 6974 DLY8_5VX1 $T=258280 250880 0 0 $X=257850 $Y=250240
X58493 1 2 5862 5860 DLY8_5VX1 $T=258840 232960 0 0 $X=258410 $Y=232320
X58494 1 2 6615 6634 DLY8_5VX1 $T=258840 313600 0 0 $X=258410 $Y=312960
X58495 1 2 6916 6830 DLY8_5VX1 $T=259400 215040 0 0 $X=258970 $Y=214400
X58496 1 2 6850 5372 DLY8_5VX1 $T=260520 241920 0 0 $X=260090 $Y=241280
X58497 1 2 6841 5929 DLY8_5VX1 $T=261080 232960 1 0 $X=260650 $Y=227840
X58498 1 2 6994 7337 DLY8_5VX1 $T=261080 268800 0 0 $X=260650 $Y=268160
X58499 1 2 6834 7070 DLY8_5VX1 $T=261080 322560 0 0 $X=260650 $Y=321920
X58500 1 2 562 6262 DLY8_5VX1 $T=261080 340480 1 0 $X=260650 $Y=335360
X58501 1 2 6630 572 DLY8_5VX1 $T=262200 224000 1 0 $X=261770 $Y=218880
X58502 1 2 6331 796 DLY8_5VX1 $T=262200 259840 0 0 $X=261770 $Y=259200
X58503 1 2 6865 5845 DLY8_5VX1 $T=262200 277760 1 0 $X=261770 $Y=272640
X58504 1 2 7008 6007 DLY8_5VX1 $T=262760 295680 1 0 $X=262330 $Y=290560
X58505 1 2 5829 5817 DLY8_5VX1 $T=263880 277760 0 0 $X=263450 $Y=277120
X58506 1 2 7015 5814 DLY8_5VX1 $T=263880 286720 1 0 $X=263450 $Y=281600
X58507 1 2 6647 7092 DLY8_5VX1 $T=264440 206080 0 0 $X=264010 $Y=205440
X58508 1 2 9472 6923 DLY8_5VX1 $T=265000 295680 0 0 $X=264570 $Y=295040
X58509 1 2 6366 6361 DLY8_5VX1 $T=266120 259840 1 0 $X=265690 $Y=254720
X58510 1 2 7026 6911 DLY8_5VX1 $T=266120 286720 0 0 $X=265690 $Y=286080
X58511 1 2 566 6214 DLY8_5VX1 $T=266120 331520 0 0 $X=265690 $Y=330880
X58512 1 2 6626 6621 DLY8_5VX1 $T=267240 304640 0 0 $X=266810 $Y=304000
X58513 1 2 6693 6543 DLY8_5VX1 $T=268360 125440 0 0 $X=267930 $Y=124800
X58514 1 2 6384 6395 DLY8_5VX1 $T=269480 250880 1 0 $X=269050 $Y=245760
X58515 1 2 6711 6730 DLY8_5VX1 $T=269480 322560 1 0 $X=269050 $Y=317440
X58516 1 2 6628 5831 DLY8_5VX1 $T=270040 224000 0 0 $X=269610 $Y=223360
X58517 1 2 6424 7125 DLY8_5VX1 $T=270600 268800 1 0 $X=270170 $Y=263680
X58518 1 2 7045 6748 DLY8_5VX1 $T=270600 313600 1 0 $X=270170 $Y=308480
X58519 1 2 6593 6619 DLY8_5VX1 $T=271160 304640 1 0 $X=270730 $Y=299520
X58520 1 2 794 7123 DLY8_5VX1 $T=272280 241920 1 0 $X=271850 $Y=236800
X58521 1 2 7062 6347 DLY8_5VX1 $T=272840 250880 0 0 $X=272410 $Y=250240
X58522 1 2 7021 6997 DLY8_5VX1 $T=273400 232960 0 0 $X=272970 $Y=232320
X58523 1 2 7053 6832 DLY8_5VX1 $T=273400 313600 0 0 $X=272970 $Y=312960
X58524 1 2 7049 579 DLY8_5VX1 $T=273960 215040 0 0 $X=273530 $Y=214400
X58525 1 2 6252 6270 DLY8_5VX1 $T=275080 241920 0 0 $X=274650 $Y=241280
X58526 1 2 6993 6968 DLY8_5VX1 $T=275640 232960 1 0 $X=275210 $Y=227840
X58527 1 2 785 7157 DLY8_5VX1 $T=275640 268800 0 0 $X=275210 $Y=268160
X58528 1 2 5756 6953 DLY8_5VX1 $T=275640 322560 0 0 $X=275210 $Y=321920
X58529 1 2 6858 6609 DLY8_5VX1 $T=276760 224000 1 0 $X=276330 $Y=218880
X58530 1 2 6986 7153 DLY8_5VX1 $T=276760 259840 0 0 $X=276330 $Y=259200
X58531 1 2 6416 7360 DLY8_5VX1 $T=276760 277760 1 0 $X=276330 $Y=272640
X58532 1 2 7093 7168 DLY8_5VX1 $T=277320 295680 1 0 $X=276890 $Y=290560
X58533 1 2 6979 7165 DLY8_5VX1 $T=278440 277760 0 0 $X=278010 $Y=277120
X58534 1 2 5995 7163 DLY8_5VX1 $T=278440 286720 1 0 $X=278010 $Y=281600
X58535 1 2 6988 6980 DLY8_5VX1 $T=279560 295680 0 0 $X=279130 $Y=295040
X58536 1 2 6831 7183 DLY8_5VX1 $T=280680 259840 1 0 $X=280250 $Y=254720
X58537 1 2 6578 6627 DLY8_5VX1 $T=280680 286720 0 0 $X=280250 $Y=286080
X58538 1 2 6717 6726 DLY8_5VX1 $T=281800 304640 0 0 $X=281370 $Y=304000
X58539 1 2 6504 5777 DLY8_5VX1 $T=284040 215040 1 0 $X=283610 $Y=209920
X58540 1 2 7114 6040 DLY8_5VX1 $T=284040 250880 1 0 $X=283610 $Y=245760
X58541 1 2 7033 7013 DLY8_5VX1 $T=284600 224000 0 0 $X=284170 $Y=223360
X58542 1 2 7134 5996 DLY8_5VX1 $T=285160 268800 1 0 $X=284730 $Y=263680
X58543 1 2 7135 7211 DLY8_5VX1 $T=285720 304640 1 0 $X=285290 $Y=299520
X58544 1 2 5965 6677 DLY8_5VX1 $T=286280 197120 0 0 $X=285850 $Y=196480
X58545 1 2 7145 6804 DLY8_5VX1 $T=286840 241920 1 0 $X=286410 $Y=236800
X58546 1 2 7140 6181 DLY8_5VX1 $T=287400 250880 0 0 $X=286970 $Y=250240
X58547 1 2 6338 7213 DLY8_5VX1 $T=287960 232960 0 0 $X=287530 $Y=232320
X58548 1 2 7156 7115 DLY8_5VX1 $T=288520 215040 0 0 $X=288090 $Y=214400
X58549 1 2 7160 6889 DLY8_5VX1 $T=289640 241920 0 0 $X=289210 $Y=241280
X58550 1 2 6253 6365 DLY8_5VX1 $T=290200 232960 1 0 $X=289770 $Y=227840
X58551 1 2 7162 6851 DLY8_5VX1 $T=290200 268800 0 0 $X=289770 $Y=268160
X58552 1 2 6999 6616 DLY8_5VX1 $T=291320 224000 1 0 $X=290890 $Y=218880
X58553 1 2 7161 6528 DLY8_5VX1 $T=291320 259840 0 0 $X=290890 $Y=259200
X58554 1 2 7167 6468 DLY8_5VX1 $T=291320 277760 1 0 $X=290890 $Y=272640
X58555 1 2 6345 6290 DLY8_5VX1 $T=291880 295680 1 0 $X=291450 $Y=290560
X58556 1 2 6580 7237 DLY8_5VX1 $T=293000 277760 0 0 $X=292570 $Y=277120
X58557 1 2 9363 6586 DLY8_5VX1 $T=293000 286720 1 0 $X=292570 $Y=281600
X58558 1 2 7196 6991 DLY8_5VX1 $T=295240 259840 1 0 $X=294810 $Y=254720
X58559 1 2 7180 6742 DLY8_5VX1 $T=295240 286720 0 0 $X=294810 $Y=286080
X58560 1 2 7024 6973 DLY8_5VX1 $T=298600 215040 1 0 $X=298170 $Y=209920
X58561 1 2 7202 6522 DLY8_5VX1 $T=298600 250880 1 0 $X=298170 $Y=245760
X58562 1 2 6776 6918 DLY8_5VX1 $T=299160 143360 0 0 $X=298730 $Y=142720
X58563 1 2 6320 6321 DLY8_5VX1 $T=299160 224000 0 0 $X=298730 $Y=223360
X58564 1 2 7210 7068 DLY8_5VX1 $T=299720 268800 1 0 $X=299290 $Y=263680
X58565 1 2 6746 5870 DLY8_5VX1 $T=300840 197120 0 0 $X=300410 $Y=196480
X58566 1 2 7219 6517 DLY8_5VX1 $T=301400 241920 1 0 $X=300970 $Y=236800
X58567 1 2 7221 6182 DLY8_5VX1 $T=301960 250880 0 0 $X=301530 $Y=250240
X58568 1 2 7223 6442 DLY8_5VX1 $T=302520 232960 0 0 $X=302090 $Y=232320
X58569 1 2 7133 7035 DLY8_5VX1 $T=303080 215040 0 0 $X=302650 $Y=214400
X58570 1 2 7232 6924 DLY8_5VX1 $T=304200 241920 0 0 $X=303770 $Y=241280
X58571 1 2 7233 6714 DLY8_5VX1 $T=304760 232960 1 0 $X=304330 $Y=227840
X58572 1 2 7234 7102 DLY8_5VX1 $T=304760 268800 0 0 $X=304330 $Y=268160
X58573 1 2 7236 6220 DLY8_5VX1 $T=305880 224000 1 0 $X=305450 $Y=218880
X58574 1 2 7238 6948 DLY8_5VX1 $T=305880 259840 0 0 $X=305450 $Y=259200
X58575 1 2 798 6958 DLY8_5VX1 $T=305880 277760 1 0 $X=305450 $Y=272640
X58576 1 2 7242 6840 DLY8_5VX1 $T=307560 277760 0 0 $X=307130 $Y=277120
X58577 1 2 7252 7201 DLY8_5VX1 $T=309800 259840 1 0 $X=309370 $Y=254720
X58578 1 2 7259 6476 DLY8_5VX1 $T=313160 250880 1 0 $X=312730 $Y=245760
X58579 1 2 6890 6792 DLY8_5VX1 $T=313720 143360 0 0 $X=313290 $Y=142720
X58580 1 2 7269 6791 DLY8_5VX1 $T=313720 224000 0 0 $X=313290 $Y=223360
X58581 1 2 6585 7321 DLY8_5VX1 $T=314280 268800 1 0 $X=313850 $Y=263680
X58582 1 2 7096 7004 DLY8_5VX1 $T=315400 197120 0 0 $X=314970 $Y=196480
X58583 1 2 7301 7403 DLY8_5VX1 $T=315960 241920 1 0 $X=315530 $Y=236800
X58584 1 2 7275 7256 DLY8_5VX1 $T=316520 250880 0 0 $X=316090 $Y=250240
X58585 1 2 7285 6964 DLY8_5VX1 $T=318760 241920 0 0 $X=318330 $Y=241280
X58586 1 2 7284 7346 DLY8_5VX1 $T=319320 232960 1 0 $X=318890 $Y=227840
X58587 1 2 6704 6718 DLY8_5VX1 $T=319320 268800 0 0 $X=318890 $Y=268160
X58588 1 2 6992 6828 DLY8_5VX1 $T=320440 259840 0 0 $X=320010 $Y=259200
X58589 1 2 6422 6579 DLY8_5VX1 $T=324360 259840 1 0 $X=323930 $Y=254720
X58590 1 2 6729 6584 DLY8_5VX1 $T=325480 98560 1 0 $X=325050 $Y=93440
X58591 1 2 9559 7314 DLY8_5VX1 $T=326600 215040 0 0 $X=326170 $Y=214400
X58592 1 2 7315 7310 DLY8_5VX1 $T=326600 224000 1 0 $X=326170 $Y=218880
X58593 1 2 7323 7324 DLY8_5VX1 $T=327160 215040 1 0 $X=326730 $Y=209920
X58594 1 2 7329 7317 DLY8_5VX1 $T=327720 250880 1 0 $X=327290 $Y=245760
X58595 1 2 7320 7325 DLY8_5VX1 $T=328840 268800 1 0 $X=328410 $Y=263680
X58596 1 2 6521 7395 DLY8_5VX1 $T=330520 241920 1 0 $X=330090 $Y=236800
X58597 1 2 9571 7350 DLY8_5VX1 $T=331080 232960 0 0 $X=330650 $Y=232320
X58598 1 2 7335 6598 DLY8_5VX1 $T=331080 250880 0 0 $X=330650 $Y=250240
X58599 1 2 7348 7367 DLY8_5VX1 $T=332760 224000 0 0 $X=332330 $Y=223360
X58600 1 2 7355 7413 DLY8_5VX1 $T=333320 241920 0 0 $X=332890 $Y=241280
X58601 1 2 7313 7420 DLY8_5VX1 $T=333880 188160 0 0 $X=333450 $Y=187520
X58602 1 2 6767 5823 DLY8_5VX1 $T=335000 259840 0 0 $X=334570 $Y=259200
X58603 1 2 7370 7377 DLY8_5VX1 $T=338360 232960 1 0 $X=337930 $Y=227840
X58604 1 2 7352 7328 DLY8_5VX1 $T=338920 259840 1 0 $X=338490 $Y=254720
X58605 1 2 7358 7363 DLY8_5VX1 $T=342280 250880 1 0 $X=341850 $Y=245760
X58606 1 2 5585 6377 DLY8_5VX1 $T=343400 268800 1 0 $X=342970 $Y=263680
X58607 1 2 6801 6793 DLY8_5VX1 $T=345080 241920 1 0 $X=344650 $Y=236800
X58608 1 2 7389 7415 DLY8_5VX1 $T=345640 232960 0 0 $X=345210 $Y=232320
X58609 1 2 7407 7401 DLY8_5VX1 $T=345640 250880 0 0 $X=345210 $Y=250240
X58610 1 2 7411 7475 DLY8_5VX1 $T=346200 197120 1 0 $X=345770 $Y=192000
X58611 1 2 9582 7491 DLY8_5VX1 $T=347320 224000 0 0 $X=346890 $Y=223360
X58612 1 2 7460 7436 DLY8_5VX1 $T=351240 241920 0 0 $X=350810 $Y=241280
X58613 1 2 7433 7095 DLY8_5VX1 $T=352920 215040 0 0 $X=352490 $Y=214400
X58614 1 2 7456 7448 DLY8_5VX1 $T=353480 232960 1 0 $X=353050 $Y=227840
X58615 1 2 6780 9117 DLY8_5VX1 $T=356840 250880 1 0 $X=356410 $Y=245760
X58616 1 2 6681 5795 DLY8_5VX1 $T=359640 241920 1 0 $X=359210 $Y=236800
X58617 1 2 6816 6545 DLY8_5VX1 $T=360760 134400 0 0 $X=360330 $Y=133760
X58618 1 2 7507 7506 DLY8_5VX1 $T=365240 232960 0 0 $X=364810 $Y=232320
X58619 1 2 624 628 DLY8_5VX1 $T=365800 161280 1 0 $X=365370 $Y=156160
X58620 1 2 7528 7532 DLY8_5VX1 $T=370840 232960 1 0 $X=370410 $Y=227840
X58621 1 2 626 631 DLY8_5VX1 $T=373640 26880 1 0 $X=373210 $Y=21760
X58622 1 2 7541 7549 DLY8_5VX1 $T=373640 215040 0 0 $X=373210 $Y=214400
X58623 1 2 7540 7547 DLY8_5VX1 $T=373640 224000 0 0 $X=373210 $Y=223360
X58624 1 2 7587 5538 DLY8_5VX1 $T=401640 215040 1 0 $X=401210 $Y=209920
X58625 1 2 636 646 DLY8_5VX1 $T=410600 134400 1 0 $X=410170 $Y=129280
X58626 1 2 9662 7639 DLY8_5VX1 $T=411160 224000 1 0 $X=410730 $Y=218880
X58627 1 2 9669 7662 DLY8_5VX1 $T=416200 215040 0 0 $X=415770 $Y=214400
X58628 1 2 7661 7372 DLY8_5VX1 $T=422360 188160 0 0 $X=421930 $Y=187520
X58629 1 2 7615 7394 DLY8_5VX1 $T=423480 152320 0 0 $X=423050 $Y=151680
X58630 1 2 7674 7225 DLY8_5VX1 $T=424600 44800 0 0 $X=424170 $Y=44160
X58631 1 2 7678 7677 DLY8_5VX1 $T=425720 224000 1 0 $X=425290 $Y=218880
X58632 1 2 7695 7735 DLY8_5VX1 $T=430760 215040 0 0 $X=430330 $Y=214400
X58633 1 2 7693 7706 DLY8_5VX1 $T=439720 206080 1 0 $X=439290 $Y=200960
X58634 1 2 9702 7371 DLY8_5VX1 $T=445320 80640 1 0 $X=444890 $Y=75520
X58635 1 2 9713 7738 DLY8_5VX1 $T=450360 206080 0 0 $X=449930 $Y=205440
X58636 1 2 9712 7795 DLY8_5VX1 $T=450360 215040 0 0 $X=449930 $Y=214400
X58637 1 2 7755 7817 DLY8_5VX1 $T=458760 215040 1 0 $X=458330 $Y=209920
X58638 1 2 7798 7689 DLY8_5VX1 $T=463240 188160 1 0 $X=462810 $Y=183040
X58639 1 2 7787 7737 DLY8_5VX1 $T=469960 152320 1 0 $X=469530 $Y=147200
X58640 1 2 7770 7803 DLY8_5VX1 $T=476120 116480 0 0 $X=475690 $Y=115840
X58641 1 2 9896 7881 DLY8_5VX1 $T=481720 197120 1 0 $X=481290 $Y=192000
X58642 1 2 7729 7751 DLY8_5VX1 $T=484520 152320 1 0 $X=484090 $Y=147200
X58643 1 2 7862 7861 DLY8_5VX1 $T=487320 179200 1 0 $X=486890 $Y=174080
X58644 1 2 7863 7897 DLY8_5VX1 $T=487880 188160 0 0 $X=487450 $Y=187520
X58645 1 2 7343 6608 DLY8_5VX1 $T=489560 44800 1 0 $X=489130 $Y=39680
X58646 1 2 7868 7853 DLY8_5VX1 $T=489560 161280 1 0 $X=489130 $Y=156160
X58647 1 2 7870 7900 DLY8_5VX1 $T=490120 125440 1 0 $X=489690 $Y=120320
X58648 1 2 7873 7869 DLY8_5VX1 $T=490120 161280 0 0 $X=489690 $Y=160640
X58649 1 2 7792 7797 DLY8_5VX1 $T=492360 170240 0 0 $X=491930 $Y=169600
X58650 1 2 7882 7723 DLY8_5VX1 $T=494600 143360 0 0 $X=494170 $Y=142720
X58651 1 2 7703 7385 DLY8_5VX1 $T=495160 71680 0 0 $X=494730 $Y=71040
X58652 1 2 7815 7910 DLY8_5VX1 $T=495160 170240 1 0 $X=494730 $Y=165120
X58653 1 2 7804 7909 DLY8_5VX1 $T=497400 134400 1 0 $X=496970 $Y=129280
X58654 1 2 7893 7889 DLY8_5VX1 $T=499080 152320 1 0 $X=498650 $Y=147200
X58655 1 2 7417 9585 DLY8_5VX1 $T=503560 53760 1 0 $X=503130 $Y=48640
X58656 1 2 7664 7382 DLY8_5VX1 $T=503560 89600 0 0 $X=503130 $Y=88960
X58657 1 2 7905 7754 DLY8_5VX1 $T=505240 125440 0 0 $X=504810 $Y=124800
X58658 1 2 7904 7899 DLY8_5VX1 $T=505800 80640 1 0 $X=505370 $Y=75520
X58659 1 2 7791 7779 DLY8_5VX1 $T=506360 116480 1 0 $X=505930 $Y=111360
X58660 1 2 7714 7925 DLY8_5VX1 $T=510280 44800 1 0 $X=509850 $Y=39680
X58661 1 2 7719 7926 DLY8_5VX1 $T=510840 17920 0 0 $X=510410 $Y=17280
X58662 1 2 692 699 DLY8_5VX1 $T=510840 53760 0 0 $X=510410 $Y=53120
X58663 1 2 7918 7906 DLY8_5VX1 $T=511400 35840 1 0 $X=510970 $Y=30720
X58664 1 2 7919 7344 DLY8_5VX1 $T=511400 98560 1 0 $X=510970 $Y=93440
X58665 1 2 7932 9764 DLY8_5VX1 $T=511960 89600 1 0 $X=511530 $Y=84480
X58666 1 2 7920 7437 DLY8_5VX1 $T=514200 35840 0 0 $X=513770 $Y=35200
X58667 1 2 7921 702 DLY8_5VX1 $T=515320 17920 1 0 $X=514890 $Y=12800
X58668 1 2 7922 7878 DLY8_5VX1 $T=516440 62720 0 0 $X=516010 $Y=62080
X58669 1 2 7923 7907 DLY8_5VX1 $T=518120 89600 0 0 $X=517690 $Y=88960
X58670 1 2 7924 7887 DLY8_5VX1 $T=518680 44800 0 0 $X=518250 $Y=44160
X58671 1 2 7852 7839 DLY8_5VX1 $T=520920 116480 1 0 $X=520490 $Y=111360
X58672 1 2 7472 7465 DLY8_5VX1 $T=523160 26880 0 0 $X=522730 $Y=26240
X58673 1 2 7848 7884 DLY8_5VX1 $T=523160 116480 0 0 $X=522730 $Y=115840
X58674 1 2 700 704 DLY8_5VX1 $T=525400 17920 0 0 $X=524970 $Y=17280
X58675 1 2 7927 7750 DLY8_5VX1 $T=525400 107520 1 0 $X=524970 $Y=102400
X58676 1 2 7930 7914 DLY8_5VX1 $T=528760 35840 0 0 $X=528330 $Y=35200
X58677 1 2 899 1408 BU_5VX3 $T=-478680 232960 1 0 $X=-479110 $Y=227840
X58678 1 2 39 1827 BU_5VX3 $T=-419320 197120 1 0 $X=-419750 $Y=192000
X58679 1 2 1875 1825 BU_5VX3 $T=-410360 250880 1 0 $X=-410790 $Y=245760
X58680 1 2 1867 1907 BU_5VX3 $T=-410360 358400 0 0 $X=-410790 $Y=357760
X58681 1 2 1883 1982 BU_5VX3 $T=-401400 134400 1 0 $X=-401830 $Y=129280
X58682 1 2 1987 969 BU_5VX3 $T=-396920 98560 0 0 $X=-397350 $Y=97920
X58683 1 2 2426 1873 BU_5VX3 $T=-332520 98560 1 0 $X=-332950 $Y=93440
X58684 1 2 3420 1997 BU_5VX3 $T=-323000 331520 0 0 $X=-323430 $Y=330880
X58685 1 2 2562 2084 BU_5VX3 $T=-316280 286720 0 0 $X=-316710 $Y=286080
X58686 1 2 2607 2632 BU_5VX3 $T=-309000 322560 1 0 $X=-309430 $Y=317440
X58687 1 2 2758 1836 BU_5VX3 $T=-288840 286720 1 0 $X=-289270 $Y=281600
X58688 1 2 2911 8444 BU_5VX3 $T=-267560 349440 0 0 $X=-267990 $Y=348800
X58689 1 2 3096 161 BU_5VX3 $T=-241240 17920 1 180 $X=-247270 $Y=17280
X58690 1 2 3042 2435 BU_5VX3 $T=-237880 179200 1 180 $X=-243910 $Y=178560
X58691 1 2 2810 3042 BU_5VX3 $T=-239000 152320 0 0 $X=-239430 $Y=151680
X58692 1 2 3202 1947 BU_5VX3 $T=-229480 376320 1 0 $X=-229910 $Y=371200
X58693 1 2 3310 2122 BU_5VX3 $T=-217720 403200 0 0 $X=-218150 $Y=402560
X58694 1 2 8814 714 BU_5VX3 $T=-207080 421120 1 0 $X=-207510 $Y=416000
X58695 1 2 3466 3488 BU_5VX3 $T=-195320 394240 0 0 $X=-195750 $Y=393600
X58696 1 2 3464 223 BU_5VX3 $T=-194760 107520 0 0 $X=-195190 $Y=106880
X58697 1 2 3576 3662 BU_5VX3 $T=-179640 403200 0 0 $X=-180070 $Y=402560
X58698 1 2 3303 3558 BU_5VX3 $T=-172360 412160 1 0 $X=-172790 $Y=407040
X58699 1 2 3408 3777 BU_5VX3 $T=-167880 259840 0 0 $X=-168310 $Y=259200
X58700 1 2 3204 3692 BU_5VX3 $T=-167320 197120 0 0 $X=-167750 $Y=196480
X58701 1 2 3847 4088 BU_5VX3 $T=-156120 358400 0 0 $X=-156550 $Y=357760
X58702 1 2 3848 3891 BU_5VX3 $T=-155560 376320 0 0 $X=-155990 $Y=375680
X58703 1 2 3369 3310 BU_5VX3 $T=-146600 322560 1 0 $X=-147030 $Y=317440
X58704 1 2 4299 8814 BU_5VX3 $T=-97880 340480 1 0 $X=-98310 $Y=335360
X58705 1 2 4274 4655 BU_5VX3 $T=-56440 17920 1 0 $X=-56870 $Y=12800
X58706 1 2 4224 4715 BU_5VX3 $T=-49720 322560 0 0 $X=-50150 $Y=321920
X58707 1 2 4721 326 BU_5VX3 $T=-43000 188160 1 180 $X=-49030 $Y=187520
X58708 1 2 4343 4716 BU_5VX3 $T=-46360 286720 0 0 $X=-46790 $Y=286080
X58709 1 2 4792 339 BU_5VX3 $T=-32920 197120 0 180 $X=-38950 $Y=192000
X58710 1 2 4787 4811 BU_5VX3 $T=-38520 313600 0 0 $X=-38950 $Y=312960
X58711 1 2 4740 362 BU_5VX3 $T=-37960 170240 0 0 $X=-38390 $Y=169600
X58712 1 2 4741 348 BU_5VX3 $T=-36840 206080 0 0 $X=-37270 $Y=205440
X58713 1 2 4751 346 BU_5VX3 $T=-21720 161280 0 0 $X=-22150 $Y=160640
X58714 1 2 4824 366 BU_5VX3 $T=-15560 152320 1 0 $X=-15990 $Y=147200
X58715 1 2 5034 4390 BU_5VX3 $T=-6600 152320 1 0 $X=-7030 $Y=147200
X58716 1 2 4475 4647 BU_5VX3 $T=-2680 125440 0 0 $X=-3110 $Y=124800
X58717 1 2 5079 8997 BU_5VX3 $T=-440 421120 1 0 $X=-870 $Y=416000
X58718 1 2 4611 359 BU_5VX3 $T=120 116480 0 0 $X=-310 $Y=115840
X58719 1 2 5100 8826 BU_5VX3 $T=1240 80640 1 0 $X=810 $Y=75520
X58720 1 2 4566 4430 BU_5VX3 $T=4600 412160 0 0 $X=4170 $Y=411520
X58721 1 2 761 351 BU_5VX3 $T=14120 89600 1 0 $X=13690 $Y=84480
X58722 1 2 4010 5277 BU_5VX3 $T=18600 403200 1 0 $X=18170 $Y=398080
X58723 1 2 5319 5359 BU_5VX3 $T=29240 385280 1 0 $X=28810 $Y=380160
X58724 1 2 3238 5388 BU_5VX3 $T=34840 116480 0 0 $X=34410 $Y=115840
X58725 1 2 4099 5540 BU_5VX3 $T=50520 134400 0 0 $X=50090 $Y=133760
X58726 1 2 3972 3991 BU_5VX3 $T=63400 161280 1 0 $X=62970 $Y=156160
X58727 1 2 4417 5752 BU_5VX3 $T=66760 367360 0 0 $X=66330 $Y=366720
X58728 1 2 443 5312 BU_5VX3 $T=88040 44800 1 180 $X=82010 $Y=44160
X58729 1 2 4823 4749 BU_5VX3 $T=86360 250880 1 0 $X=85930 $Y=245760
X58730 1 2 4719 4957 BU_5VX3 $T=89160 71680 0 0 $X=88730 $Y=71040
X58731 1 2 4577 5974 BU_5VX3 $T=99240 62720 0 0 $X=98810 $Y=62080
X58732 1 2 4727 6062 BU_5VX3 $T=110440 71680 1 0 $X=110010 $Y=66560
X58733 1 2 4626 6162 BU_5VX3 $T=122200 89600 1 0 $X=121770 $Y=84480
X58734 1 2 5495 9291 BU_5VX3 $T=151880 116480 0 0 $X=151450 $Y=115840
X58735 1 2 350 6293 BU_5VX3 $T=151880 268800 1 0 $X=151450 $Y=263680
X58736 1 2 5207 6385 BU_5VX3 $T=161960 295680 0 0 $X=161530 $Y=295040
X58737 1 2 6200 6426 BU_5VX3 $T=166440 179200 1 0 $X=166010 $Y=174080
X58738 1 2 5249 492 BU_5VX3 $T=168680 53760 0 0 $X=168250 $Y=53120
X58739 1 2 5081 5105 BU_5VX3 $T=169240 277760 0 0 $X=168810 $Y=277120
X58740 1 2 6595 5539 BU_5VX3 $T=191080 277760 1 0 $X=190650 $Y=272640
X58741 1 2 6250 5930 BU_5VX3 $T=196120 421120 0 0 $X=195690 $Y=420480
X58742 1 2 5986 9219 BU_5VX3 $T=201720 421120 0 0 $X=201290 $Y=420480
X58743 1 2 6294 6351 BU_5VX3 $T=202280 412160 1 0 $X=201850 $Y=407040
X58744 1 2 5784 6491 BU_5VX3 $T=205640 403200 0 0 $X=205210 $Y=402560
X58745 1 2 6702 6588 BU_5VX3 $T=206200 403200 1 0 $X=205770 $Y=398080
X58746 1 2 5187 6590 BU_5VX3 $T=226920 385280 1 0 $X=226490 $Y=380160
X58747 1 2 6537 6618 BU_5VX3 $T=240920 367360 0 0 $X=240490 $Y=366720
X58748 1 2 5974 549 BU_5VX3 $T=245960 134400 1 0 $X=245530 $Y=129280
X58749 1 2 6044 6001 BU_5VX3 $T=248200 170240 0 0 $X=247770 $Y=169600
X58750 1 2 5645 6903 BU_5VX3 $T=258840 349440 0 0 $X=258410 $Y=348800
X58751 1 2 6515 574 BU_5VX3 $T=277320 26880 1 0 $X=276890 $Y=21760
X58752 1 2 590 7271 BU_5VX3 $T=310920 53760 0 0 $X=310490 $Y=53120
X58753 1 2 6162 7588 BU_5VX3 $T=313160 26880 0 0 $X=312730 $Y=26240
X58754 1 2 5759 6931 BU_5VX3 $T=321560 286720 0 0 $X=321130 $Y=286080
X58755 1 2 7346 6934 BU_5VX3 $T=337240 277760 1 0 $X=336810 $Y=272640
X58756 1 2 6794 7145 BU_5VX3 $T=349560 259840 0 0 $X=349130 $Y=259200
X58757 1 2 7379 7921 BU_5VX3 $T=536600 17920 1 0 $X=536170 $Y=12800
X58758 1 2 8054 826 DLY1_5VX1 $T=-594040 188160 0 0 $X=-594470 $Y=187520
X58759 1 2 886 7938 DLY1_5VX1 $T=-577240 98560 1 0 $X=-577670 $Y=93440
X58760 1 2 909 927 DLY1_5VX1 $T=-571080 89600 1 0 $X=-571510 $Y=84480
X58761 1 2 913 964 DLY1_5VX1 $T=-569960 80640 0 0 $X=-570390 $Y=80000
X58762 1 2 922 879 DLY1_5VX1 $T=-567160 188160 0 0 $X=-567590 $Y=187520
X58763 1 2 937 952 DLY1_5VX1 $T=-563800 80640 1 0 $X=-564230 $Y=75520
X58764 1 2 7943 931 DLY1_5VX1 $T=-563800 80640 0 0 $X=-564230 $Y=80000
X58765 1 2 947 940 DLY1_5VX1 $T=-559880 161280 1 0 $X=-560310 $Y=156160
X58766 1 2 955 1019 DLY1_5VX1 $T=-558760 71680 0 0 $X=-559190 $Y=71040
X58767 1 2 970 991 DLY1_5VX1 $T=-553720 71680 1 0 $X=-554150 $Y=66560
X58768 1 2 979 7968 DLY1_5VX1 $T=-552040 304640 0 0 $X=-552470 $Y=304000
X58769 1 2 1005 1038 DLY1_5VX1 $T=-545880 62720 0 0 $X=-546310 $Y=62080
X58770 1 2 1009 984 DLY1_5VX1 $T=-544760 116480 1 0 $X=-545190 $Y=111360
X58771 1 2 1045 1063 DLY1_5VX1 $T=-539160 215040 1 0 $X=-539590 $Y=209920
X58772 1 2 7979 7992 DLY1_5VX1 $T=-536920 152320 1 0 $X=-537350 $Y=147200
X58773 1 2 7969 1098 DLY1_5VX1 $T=-532440 98560 0 0 $X=-532870 $Y=97920
X58774 1 2 1071 1028 DLY1_5VX1 $T=-530760 259840 1 0 $X=-531190 $Y=254720
X58775 1 2 1083 1021 DLY1_5VX1 $T=-530760 304640 1 0 $X=-531190 $Y=299520
X58776 1 2 1039 1056 DLY1_5VX1 $T=-529640 107520 0 0 $X=-530070 $Y=106880
X58777 1 2 8003 1102 DLY1_5VX1 $T=-527400 44800 0 0 $X=-527830 $Y=44160
X58778 1 2 1114 1109 DLY1_5VX1 $T=-524600 44800 1 0 $X=-525030 $Y=39680
X58779 1 2 1120 1118 DLY1_5VX1 $T=-523480 331520 0 0 $X=-523910 $Y=330880
X58780 1 2 1158 8031 DLY1_5VX1 $T=-516200 286720 1 0 $X=-516630 $Y=281600
X58781 1 2 1011 1183 DLY1_5VX1 $T=-512840 232960 0 0 $X=-513270 $Y=232320
X58782 1 2 18 20 DLY1_5VX1 $T=-505560 17920 1 0 $X=-505990 $Y=12800
X58783 1 2 1230 9908 DLY1_5VX1 $T=-505000 340480 1 0 $X=-505430 $Y=335360
X58784 1 2 1135 1274 DLY1_5VX1 $T=-503880 188160 0 0 $X=-504310 $Y=187520
X58785 1 2 8046 1248 DLY1_5VX1 $T=-501080 215040 1 0 $X=-501510 $Y=209920
X58786 1 2 1268 1291 DLY1_5VX1 $T=-498280 80640 1 0 $X=-498710 $Y=75520
X58787 1 2 8059 8069 DLY1_5VX1 $T=-494360 89600 0 0 $X=-494790 $Y=88960
X58788 1 2 1317 1343 DLY1_5VX1 $T=-491000 116480 1 0 $X=-491430 $Y=111360
X58789 1 2 1246 9794 DLY1_5VX1 $T=-491000 215040 1 0 $X=-491430 $Y=209920
X58790 1 2 1360 8087 DLY1_5VX1 $T=-483720 304640 0 0 $X=-484150 $Y=304000
X58791 1 2 1326 9796 DLY1_5VX1 $T=-480920 17920 1 0 $X=-481350 $Y=12800
X58792 1 2 1438 1391 DLY1_5VX1 $T=-469720 44800 1 0 $X=-470150 $Y=39680
X58793 1 2 1207 1455 DLY1_5VX1 $T=-466360 26880 1 0 $X=-466790 $Y=21760
X58794 1 2 9790 9818 DLY1_5VX1 $T=-465800 367360 0 0 $X=-466230 $Y=366720
X58795 1 2 1364 1439 DLY1_5VX1 $T=-464680 53760 0 0 $X=-465110 $Y=53120
X58796 1 2 1493 1522 DLY1_5VX1 $T=-463000 295680 1 0 $X=-463430 $Y=290560
X58797 1 2 17 1581 DLY1_5VX1 $T=-454040 53760 1 0 $X=-454470 $Y=48640
X58798 1 2 1619 810 DLY1_5VX1 $T=-443400 143360 1 0 $X=-443830 $Y=138240
X58799 1 2 1629 1756 DLY1_5VX1 $T=-442280 313600 1 0 $X=-442710 $Y=308480
X58800 1 2 1634 2404 DLY1_5VX1 $T=-441160 80640 1 0 $X=-441590 $Y=75520
X58801 1 2 1640 1682 DLY1_5VX1 $T=-440040 340480 0 0 $X=-440470 $Y=339840
X58802 1 2 1647 1679 DLY1_5VX1 $T=-439480 224000 1 0 $X=-439910 $Y=218880
X58803 1 2 1709 1735 DLY1_5VX1 $T=-432200 367360 1 0 $X=-432630 $Y=362240
X58804 1 2 1727 1785 DLY1_5VX1 $T=-421000 349440 0 0 $X=-421430 $Y=348800
X58805 1 2 1840 1876 DLY1_5VX1 $T=-414280 295680 1 0 $X=-414710 $Y=290560
X58806 1 2 1852 1883 DLY1_5VX1 $T=-413160 188160 1 0 $X=-413590 $Y=183040
X58807 1 2 1847 1884 DLY1_5VX1 $T=-413160 232960 1 0 $X=-413590 $Y=227840
X58808 1 2 1860 1868 DLY1_5VX1 $T=-412040 367360 0 0 $X=-412470 $Y=366720
X58809 1 2 1866 1913 DLY1_5VX1 $T=-411480 349440 0 0 $X=-411910 $Y=348800
X58810 1 2 2179 1916 DLY1_5VX1 $T=-410360 98560 1 0 $X=-410790 $Y=93440
X58811 1 2 1892 1440 DLY1_5VX1 $T=-408120 134400 0 0 $X=-408550 $Y=133760
X58812 1 2 1911 1958 DLY1_5VX1 $T=-405880 224000 0 0 $X=-406310 $Y=223360
X58813 1 2 1841 9826 DLY1_5VX1 $T=-404760 358400 0 0 $X=-405190 $Y=357760
X58814 1 2 9824 1945 DLY1_5VX1 $T=-403080 295680 1 0 $X=-403510 $Y=290560
X58815 1 2 1885 1925 DLY1_5VX1 $T=-403080 313600 1 0 $X=-403510 $Y=308480
X58816 1 2 1933 1977 DLY1_5VX1 $T=-402520 179200 1 0 $X=-402950 $Y=174080
X58817 1 2 1967 1753 DLY1_5VX1 $T=-400840 116480 0 0 $X=-401270 $Y=115840
X58818 1 2 1944 1910 DLY1_5VX1 $T=-400280 152320 0 0 $X=-400710 $Y=151680
X58819 1 2 1991 8245 DLY1_5VX1 $T=-396920 331520 0 0 $X=-397350 $Y=330880
X58820 1 2 2003 2071 DLY1_5VX1 $T=-395240 367360 0 0 $X=-395670 $Y=366720
X58821 1 2 2007 2002 DLY1_5VX1 $T=-394680 295680 0 0 $X=-395110 $Y=295040
X58822 1 2 2082 2078 DLY1_5VX1 $T=-386280 376320 1 0 $X=-386710 $Y=371200
X58823 1 2 2405 2132 DLY1_5VX1 $T=-384600 143360 0 0 $X=-385030 $Y=142720
X58824 1 2 2122 2165 DLY1_5VX1 $T=-382360 403200 0 0 $X=-382790 $Y=402560
X58825 1 2 2187 8280 DLY1_5VX1 $T=-376200 268800 1 0 $X=-376630 $Y=263680
X58826 1 2 2148 2216 DLY1_5VX1 $T=-375640 367360 0 0 $X=-376070 $Y=366720
X58827 1 2 8269 2222 DLY1_5VX1 $T=-375640 412160 0 0 $X=-376070 $Y=411520
X58828 1 2 2156 2152 DLY1_5VX1 $T=-368920 188160 1 0 $X=-369350 $Y=183040
X58829 1 2 2280 87 DLY1_5VX1 $T=-348200 17920 0 0 $X=-348630 $Y=17280
X58830 1 2 2042 2340 DLY1_5VX1 $T=-348200 241920 1 0 $X=-348630 $Y=236800
X58831 1 2 2286 2328 DLY1_5VX1 $T=-348200 358400 0 0 $X=-348630 $Y=357760
X58832 1 2 2287 8302 DLY1_5VX1 $T=-348200 376320 1 0 $X=-348630 $Y=371200
X58833 1 2 2294 8297 DLY1_5VX1 $T=-347640 331520 0 0 $X=-348070 $Y=330880
X58834 1 2 2227 2278 DLY1_5VX1 $T=-347080 170240 0 0 $X=-347510 $Y=169600
X58835 1 2 2302 8307 DLY1_5VX1 $T=-347080 349440 1 0 $X=-347510 $Y=344320
X58836 1 2 2296 8304 DLY1_5VX1 $T=-347080 367360 0 0 $X=-347510 $Y=366720
X58837 1 2 2232 2279 DLY1_5VX1 $T=-343720 134400 1 0 $X=-344150 $Y=129280
X58838 1 2 2334 8319 DLY1_5VX1 $T=-343720 394240 1 0 $X=-344150 $Y=389120
X58839 1 2 2382 2414 DLY1_5VX1 $T=-337560 170240 0 0 $X=-337990 $Y=169600
X58840 1 2 2408 2397 DLY1_5VX1 $T=-335880 403200 1 0 $X=-336310 $Y=398080
X58841 1 2 2220 2281 DLY1_5VX1 $T=-333640 62720 0 0 $X=-334070 $Y=62080
X58842 1 2 2263 2466 DLY1_5VX1 $T=-333640 152320 1 0 $X=-334070 $Y=147200
X58843 1 2 2451 8337 DLY1_5VX1 $T=-330280 403200 0 0 $X=-330710 $Y=402560
X58844 1 2 2457 2469 DLY1_5VX1 $T=-329720 403200 1 0 $X=-330150 $Y=398080
X58845 1 2 2267 2498 DLY1_5VX1 $T=-329160 241920 1 0 $X=-329590 $Y=236800
X58846 1 2 4217 1860 DLY1_5VX1 $T=-320760 232960 0 0 $X=-321190 $Y=232320
X58847 1 2 2138 2238 DLY1_5VX1 $T=-317960 107520 1 0 $X=-318390 $Y=102400
X58848 1 2 2546 8348 DLY1_5VX1 $T=-317960 412160 0 0 $X=-318390 $Y=411520
X58849 1 2 2555 2584 DLY1_5VX1 $T=-317400 421120 0 0 $X=-317830 $Y=420480
X58850 1 2 4351 1911 DLY1_5VX1 $T=-308440 259840 0 0 $X=-308870 $Y=259200
X58851 1 2 2613 2648 DLY1_5VX1 $T=-306760 179200 1 0 $X=-307190 $Y=174080
X58852 1 2 2637 2576 DLY1_5VX1 $T=-303960 313600 0 0 $X=-304390 $Y=312960
X58853 1 2 2414 2592 DLY1_5VX1 $T=-301720 125440 0 0 $X=-302150 $Y=124800
X58854 1 2 2768 2812 DLY1_5VX1 $T=-287160 250880 0 0 $X=-287590 $Y=250240
X58855 1 2 2644 2809 DLY1_5VX1 $T=-286600 403200 1 0 $X=-287030 $Y=398080
X58856 1 2 2544 8422 DLY1_5VX1 $T=-281000 313600 0 0 $X=-281430 $Y=312960
X58857 1 2 8488 2808 DLY1_5VX1 $T=-279320 385280 0 0 $X=-279750 $Y=384640
X58858 1 2 2861 2867 DLY1_5VX1 $T=-273160 125440 1 0 $X=-273590 $Y=120320
X58859 1 2 2319 2203 DLY1_5VX1 $T=-265880 152320 0 0 $X=-266310 $Y=151680
X58860 1 2 9833 2944 DLY1_5VX1 $T=-265320 331520 0 0 $X=-265750 $Y=330880
X58861 1 2 2931 2937 DLY1_5VX1 $T=-265320 403200 0 0 $X=-265750 $Y=402560
X58862 1 2 2549 2998 DLY1_5VX1 $T=-260280 197120 0 0 $X=-260710 $Y=196480
X58863 1 2 2862 3057 DLY1_5VX1 $T=-251320 197120 1 0 $X=-251750 $Y=192000
X58864 1 2 2697 2983 DLY1_5VX1 $T=-246280 188160 0 0 $X=-246710 $Y=187520
X58865 1 2 2873 2951 DLY1_5VX1 $T=-241800 340480 0 0 $X=-242230 $Y=339840
X58866 1 2 168 3148 DLY1_5VX1 $T=-241240 71680 1 0 $X=-241670 $Y=66560
X58867 1 2 3215 3005 DLY1_5VX1 $T=-227240 331520 0 0 $X=-227670 $Y=330880
X58868 1 2 8538 3274 DLY1_5VX1 $T=-223880 250880 1 0 $X=-224310 $Y=245760
X58869 1 2 3242 3282 DLY1_5VX1 $T=-223880 394240 0 0 $X=-224310 $Y=393600
X58870 1 2 3266 3354 DLY1_5VX1 $T=-220520 313600 0 0 $X=-220950 $Y=312960
X58871 1 2 8544 3300 DLY1_5VX1 $T=-219400 188160 1 0 $X=-219830 $Y=183040
X58872 1 2 3168 3303 DLY1_5VX1 $T=-219400 268800 1 0 $X=-219830 $Y=263680
X58873 1 2 2976 3177 DLY1_5VX1 $T=-208760 349440 1 0 $X=-209190 $Y=344320
X58874 1 2 3404 8600 DLY1_5VX1 $T=-200920 232960 0 0 $X=-201350 $Y=232320
X58875 1 2 3239 3467 DLY1_5VX1 $T=-199240 152320 0 0 $X=-199670 $Y=151680
X58876 1 2 3432 3475 DLY1_5VX1 $T=-197560 71680 0 0 $X=-197990 $Y=71040
X58877 1 2 3482 3518 DLY1_5VX1 $T=-194200 421120 0 0 $X=-194630 $Y=420480
X58878 1 2 3513 3560 DLY1_5VX1 $T=-189720 71680 1 0 $X=-190150 $Y=66560
X58879 1 2 3531 3585 DLY1_5VX1 $T=-188040 358400 1 0 $X=-188470 $Y=353280
X58880 1 2 3367 9909 DLY1_5VX1 $T=-185240 152320 0 0 $X=-185670 $Y=151680
X58881 1 2 3417 3635 DLY1_5VX1 $T=-181880 358400 0 0 $X=-182310 $Y=357760
X58882 1 2 3686 8665 DLY1_5VX1 $T=-173480 367360 1 0 $X=-173910 $Y=362240
X58883 1 2 3691 3646 DLY1_5VX1 $T=-172920 170240 0 0 $X=-173350 $Y=169600
X58884 1 2 9845 3750 DLY1_5VX1 $T=-169560 71680 0 0 $X=-169990 $Y=71040
X58885 1 2 3836 3876 DLY1_5VX1 $T=-157240 340480 0 0 $X=-157670 $Y=339840
X58886 1 2 3820 3717 DLY1_5VX1 $T=-153320 125440 0 0 $X=-153750 $Y=124800
X58887 1 2 3729 3781 DLY1_5VX1 $T=-148840 403200 0 0 $X=-149270 $Y=402560
X58888 1 2 3934 3613 DLY1_5VX1 $T=-147160 188160 1 0 $X=-147590 $Y=183040
X58889 1 2 8728 3952 DLY1_5VX1 $T=-140440 412160 1 0 $X=-140870 $Y=407040
X58890 1 2 3743 3731 DLY1_5VX1 $T=-139880 125440 0 0 $X=-140310 $Y=124800
X58891 1 2 4052 8761 DLY1_5VX1 $T=-134280 376320 0 0 $X=-134710 $Y=375680
X58892 1 2 3926 3850 DLY1_5VX1 $T=-133720 421120 0 0 $X=-134150 $Y=420480
X58893 1 2 4074 4089 DLY1_5VX1 $T=-131480 349440 0 0 $X=-131910 $Y=348800
X58894 1 2 4031 4023 DLY1_5VX1 $T=-124200 277760 1 0 $X=-124630 $Y=272640
X58895 1 2 4178 3805 DLY1_5VX1 $T=-119160 62720 0 0 $X=-119590 $Y=62080
X58896 1 2 3844 3742 DLY1_5VX1 $T=-118600 98560 0 0 $X=-119030 $Y=97920
X58897 1 2 3946 3974 DLY1_5VX1 $T=-118600 394240 0 0 $X=-119030 $Y=393600
X58898 1 2 4185 3826 DLY1_5VX1 $T=-118040 17920 1 0 $X=-118470 $Y=12800
X58899 1 2 3604 8793 DLY1_5VX1 $T=-118040 179200 0 0 $X=-118470 $Y=178560
X58900 1 2 4188 4263 DLY1_5VX1 $T=-118040 295680 1 0 $X=-118470 $Y=290560
X58901 1 2 4184 4406 DLY1_5VX1 $T=-118040 349440 1 0 $X=-118470 $Y=344320
X58902 1 2 3884 3818 DLY1_5VX1 $T=-97880 26880 1 0 $X=-98310 $Y=21760
X58903 1 2 4278 3711 DLY1_5VX1 $T=-97880 224000 0 0 $X=-98310 $Y=223360
X58904 1 2 8886 4338 DLY1_5VX1 $T=-97880 385280 1 0 $X=-98310 $Y=380160
X58905 1 2 4315 4345 DLY1_5VX1 $T=-96760 304640 0 0 $X=-97190 $Y=304000
X58906 1 2 4412 4332 DLY1_5VX1 $T=-83320 403200 1 0 $X=-83750 $Y=398080
X58907 1 2 4413 4456 DLY1_5VX1 $T=-83320 421120 1 0 $X=-83750 $Y=416000
X58908 1 2 4463 4487 DLY1_5VX1 $T=-78840 268800 1 0 $X=-79270 $Y=263680
X58909 1 2 4498 4527 DLY1_5VX1 $T=-73800 250880 0 0 $X=-74230 $Y=250240
X58910 1 2 4069 4296 DLY1_5VX1 $T=-72120 232960 0 0 $X=-72550 $Y=232320
X58911 1 2 9856 4535 DLY1_5VX1 $T=-65960 367360 1 0 $X=-66390 $Y=362240
X58912 1 2 4587 4629 DLY1_5VX1 $T=-63160 322560 1 0 $X=-63590 $Y=317440
X58913 1 2 4581 4576 DLY1_5VX1 $T=-62600 80640 0 0 $X=-63030 $Y=80000
X58914 1 2 3616 3935 DLY1_5VX1 $T=-61480 224000 0 0 $X=-61910 $Y=223360
X58915 1 2 3376 3710 DLY1_5VX1 $T=-45800 134400 1 0 $X=-46230 $Y=129280
X58916 1 2 4763 4830 DLY1_5VX1 $T=-37960 403200 1 0 $X=-38390 $Y=398080
X58917 1 2 4211 4861 DLY1_5VX1 $T=-34600 107520 1 0 $X=-35030 $Y=102400
X58918 1 2 4849 4510 DLY1_5VX1 $T=-30120 134400 0 0 $X=-30550 $Y=133760
X58919 1 2 4853 4905 DLY1_5VX1 $T=-29560 179200 1 0 $X=-29990 $Y=174080
X58920 1 2 4813 4712 DLY1_5VX1 $T=-22840 134400 1 0 $X=-23270 $Y=129280
X58921 1 2 4947 8954 DLY1_5VX1 $T=-20040 394240 0 0 $X=-20470 $Y=393600
X58922 1 2 3812 3770 DLY1_5VX1 $T=-15560 125440 1 0 $X=-15990 $Y=120320
X58923 1 2 4828 4797 DLY1_5VX1 $T=-13320 304640 0 0 $X=-13750 $Y=304000
X58924 1 2 5016 5019 DLY1_5VX1 $T=-2680 403200 1 0 $X=-3110 $Y=398080
X58925 1 2 5178 4770 DLY1_5VX1 $T=13000 367360 1 0 $X=12570 $Y=362240
X58926 1 2 5229 5280 DLY1_5VX1 $T=19160 134400 1 0 $X=18730 $Y=129280
X58927 1 2 5326 5232 DLY1_5VX1 $T=28680 197120 0 0 $X=28250 $Y=196480
X58928 1 2 4462 4354 DLY1_5VX1 $T=30360 232960 1 0 $X=29930 $Y=227840
X58929 1 2 4891 5115 DLY1_5VX1 $T=30920 385280 0 0 $X=30490 $Y=384640
X58930 1 2 5391 5448 DLY1_5VX1 $T=38200 71680 1 0 $X=37770 $Y=66560
X58931 1 2 4279 5458 DLY1_5VX1 $T=40440 215040 1 0 $X=40010 $Y=209920
X58932 1 2 5423 5379 DLY1_5VX1 $T=43800 394240 0 0 $X=43370 $Y=393600
X58933 1 2 5012 5300 DLY1_5VX1 $T=56120 412160 0 0 $X=55690 $Y=411520
X58934 1 2 5567 5612 DLY1_5VX1 $T=57800 89600 1 0 $X=57370 $Y=84480
X58935 1 2 8924 5254 DLY1_5VX1 $T=60040 340480 1 0 $X=59610 $Y=335360
X58936 1 2 425 424 DLY1_5VX1 $T=65080 17920 0 0 $X=64650 $Y=17280
X58937 1 2 8900 5703 DLY1_5VX1 $T=67320 304640 0 0 $X=66890 $Y=304000
X58938 1 2 5644 4689 DLY1_5VX1 $T=67880 152320 1 0 $X=67450 $Y=147200
X58939 1 2 4962 5427 DLY1_5VX1 $T=72920 349440 1 0 $X=72490 $Y=344320
X58940 1 2 5736 5781 DLY1_5VX1 $T=75720 412160 1 0 $X=75290 $Y=407040
X58941 1 2 5405 5455 DLY1_5VX1 $T=77400 170240 1 0 $X=76970 $Y=165120
X58942 1 2 5463 5462 DLY1_5VX1 $T=79640 116480 0 0 $X=79210 $Y=115840
X58943 1 2 5801 5790 DLY1_5VX1 $T=83000 394240 0 0 $X=82570 $Y=393600
X58944 1 2 5754 5791 DLY1_5VX1 $T=85800 412160 1 0 $X=85370 $Y=407040
X58945 1 2 4446 745 DLY1_5VX1 $T=87480 268800 1 0 $X=87050 $Y=263680
X58946 1 2 5926 5966 DLY1_5VX1 $T=97560 232960 1 0 $X=97130 $Y=227840
X58947 1 2 3895 5977 DLY1_5VX1 $T=99800 197120 0 0 $X=99370 $Y=196480
X58948 1 2 454 6026 DLY1_5VX1 $T=105960 35840 0 0 $X=105530 $Y=35200
X58949 1 2 5704 6061 DLY1_5VX1 $T=109880 349440 0 0 $X=109450 $Y=348800
X58950 1 2 6065 5595 DLY1_5VX1 $T=113800 134400 1 0 $X=113370 $Y=129280
X58951 1 2 5464 5456 DLY1_5VX1 $T=117160 295680 1 0 $X=116730 $Y=290560
X58952 1 2 5813 6046 DLY1_5VX1 $T=122760 188160 1 0 $X=122330 $Y=183040
X58953 1 2 5678 4775 DLY1_5VX1 $T=126680 277760 0 0 $X=126250 $Y=277120
X58954 1 2 6185 6219 DLY1_5VX1 $T=127240 53760 0 0 $X=126810 $Y=53120
X58955 1 2 4774 4732 DLY1_5VX1 $T=132280 277760 1 0 $X=131850 $Y=272640
X58956 1 2 5004 5473 DLY1_5VX1 $T=151880 232960 0 0 $X=151450 $Y=232320
X58957 1 2 4664 6300 DLY1_5VX1 $T=151880 277760 1 0 $X=151450 $Y=272640
X58958 1 2 6263 5830 DLY1_5VX1 $T=151880 295680 0 0 $X=151450 $Y=295040
X58959 1 2 9278 6269 DLY1_5VX1 $T=151880 322560 0 0 $X=151450 $Y=321920
X58960 1 2 6267 6316 DLY1_5VX1 $T=152440 215040 0 0 $X=152010 $Y=214400
X58961 1 2 5244 5387 DLY1_5VX1 $T=161400 134400 1 0 $X=160970 $Y=129280
X58962 1 2 6356 784 DLY1_5VX1 $T=161960 170240 0 0 $X=161530 $Y=169600
X58963 1 2 5657 5571 DLY1_5VX1 $T=161960 277760 1 0 $X=161530 $Y=272640
X58964 1 2 6377 5650 DLY1_5VX1 $T=164200 98560 1 0 $X=163770 $Y=93440
X58965 1 2 5700 5386 DLY1_5VX1 $T=164760 116480 1 0 $X=164330 $Y=111360
X58966 1 2 6202 6478 DLY1_5VX1 $T=170360 259840 1 0 $X=169930 $Y=254720
X58967 1 2 9326 9879 DLY1_5VX1 $T=170360 367360 0 0 $X=169930 $Y=366720
X58968 1 2 6455 6494 DLY1_5VX1 $T=173720 143360 1 0 $X=173290 $Y=138240
X58969 1 2 6391 6421 DLY1_5VX1 $T=174280 340480 1 0 $X=173850 $Y=335360
X58970 1 2 6556 6567 DLY1_5VX1 $T=186600 170240 0 0 $X=186170 $Y=169600
X58971 1 2 6573 5391 DLY1_5VX1 $T=188280 188160 0 0 $X=187850 $Y=187520
X58972 1 2 6606 6623 DLY1_5VX1 $T=191640 322560 0 0 $X=191210 $Y=321920
X58973 1 2 6597 9368 DLY1_5VX1 $T=191640 403200 0 0 $X=191210 $Y=402560
X58974 1 2 9368 6650 DLY1_5VX1 $T=196120 412160 0 0 $X=195690 $Y=411520
X58975 1 2 9907 4249 DLY1_5VX1 $T=198360 421120 1 0 $X=197930 $Y=416000
X58976 1 2 6689 6671 DLY1_5VX1 $T=203400 313600 1 0 $X=202970 $Y=308480
X58977 1 2 6700 6589 DLY1_5VX1 $T=206200 385280 1 0 $X=205770 $Y=380160
X58978 1 2 6716 6722 DLY1_5VX1 $T=207880 125440 0 0 $X=207450 $Y=124800
X58979 1 2 6736 5735 DLY1_5VX1 $T=211800 277760 0 0 $X=211370 $Y=277120
X58980 1 2 6666 6310 DLY1_5VX1 $T=220200 367360 0 0 $X=219770 $Y=366720
X58981 1 2 6798 5755 DLY1_5VX1 $T=222440 125440 1 0 $X=222010 $Y=120320
X58982 1 2 6821 5651 DLY1_5VX1 $T=224120 259840 1 0 $X=223690 $Y=254720
X58983 1 2 6827 6842 DLY1_5VX1 $T=225240 241920 0 0 $X=224810 $Y=241280
X58984 1 2 5556 5567 DLY1_5VX1 $T=226360 98560 0 0 $X=225930 $Y=97920
X58985 1 2 5609 6917 DLY1_5VX1 $T=241480 367360 1 0 $X=241050 $Y=362240
X58986 1 2 6440 6892 DLY1_5VX1 $T=243720 349440 1 0 $X=243290 $Y=344320
X58987 1 2 5432 6969 DLY1_5VX1 $T=251000 188160 1 0 $X=250570 $Y=183040
X58988 1 2 6323 6467 DLY1_5VX1 $T=256600 80640 0 0 $X=256170 $Y=80000
X58989 1 2 7108 7133 DLY1_5VX1 $T=280120 206080 0 0 $X=279690 $Y=205440
X58990 1 2 580 6140 DLY1_5VX1 $T=285160 134400 0 0 $X=284730 $Y=133760
X58991 1 2 7169 6502 DLY1_5VX1 $T=291880 35840 0 0 $X=291450 $Y=35200
X58992 1 2 6219 586 DLY1_5VX1 $T=302520 134400 1 0 $X=302090 $Y=129280
X58993 1 2 7299 5269 DLY1_5VX1 $T=310360 295680 1 0 $X=309930 $Y=290560
X58994 1 2 7263 9549 DLY1_5VX1 $T=312600 179200 1 0 $X=312170 $Y=174080
X58995 1 2 5617 7296 DLY1_5VX1 $T=315400 286720 0 0 $X=314970 $Y=286080
X58996 1 2 9549 9892 DLY1_5VX1 $T=316520 206080 0 0 $X=316090 $Y=205440
X58997 1 2 7274 7323 DLY1_5VX1 $T=316520 215040 1 0 $X=316090 $Y=209920
X58998 1 2 7280 6352 DLY1_5VX1 $T=318200 35840 1 0 $X=317770 $Y=30720
X58999 1 2 7281 6901 DLY1_5VX1 $T=318200 44800 1 0 $X=317770 $Y=39680
X59000 1 2 7283 7100 DLY1_5VX1 $T=318760 188160 0 0 $X=318330 $Y=187520
X59001 1 2 7306 6949 DLY1_5VX1 $T=323800 26880 0 0 $X=323370 $Y=26240
X59002 1 2 9565 9567 DLY1_5VX1 $T=328280 206080 0 0 $X=327850 $Y=205440
X59003 1 2 7308 7329 DLY1_5VX1 $T=328280 277760 1 0 $X=327850 $Y=272640
X59004 1 2 603 7306 DLY1_5VX1 $T=329400 134400 0 0 $X=328970 $Y=133760
X59005 1 2 7298 7355 DLY1_5VX1 $T=333880 268800 0 0 $X=333450 $Y=268160
X59006 1 2 6484 7169 DLY1_5VX1 $T=342280 44800 0 0 $X=341850 $Y=44160
X59007 1 2 7395 6527 DLY1_5VX1 $T=353480 259840 1 0 $X=353050 $Y=254720
X59008 1 2 7443 7456 DLY1_5VX1 $T=356280 215040 1 0 $X=355850 $Y=209920
X59009 1 2 5821 7508 DLY1_5VX1 $T=360200 62720 1 0 $X=359770 $Y=57600
X59010 1 2 7400 7411 DLY1_5VX1 $T=361320 206080 1 0 $X=360890 $Y=200960
X59011 1 2 7512 7507 DLY1_5VX1 $T=365800 241920 0 0 $X=365370 $Y=241280
X59012 1 2 6969 6573 DLY1_5VX1 $T=367480 215040 0 0 $X=367050 $Y=214400
X59013 1 2 7527 7528 DLY1_5VX1 $T=374200 241920 1 0 $X=373770 $Y=236800
X59014 1 2 7550 7540 DLY1_5VX1 $T=378120 224000 1 0 $X=377690 $Y=218880
X59015 1 2 491 7280 DLY1_5VX1 $T=382040 44800 1 0 $X=381610 $Y=39680
X59016 1 2 7005 7584 DLY1_5VX1 $T=402200 197120 0 0 $X=401770 $Y=196480
X59017 1 2 7588 7592 DLY1_5VX1 $T=402200 224000 1 0 $X=401770 $Y=218880
X59018 1 2 7591 7589 DLY1_5VX1 $T=404440 134400 0 0 $X=404010 $Y=133760
X59019 1 2 9893 7622 DLY1_5VX1 $T=405560 232960 1 0 $X=405130 $Y=227840
X59020 1 2 7613 5785 DLY1_5VX1 $T=408360 26880 1 0 $X=407930 $Y=21760
X59021 1 2 9495 7626 DLY1_5VX1 $T=416200 71680 0 0 $X=415770 $Y=71040
X59022 1 2 802 7678 DLY1_5VX1 $T=426280 224000 0 0 $X=425850 $Y=223360
X59023 1 2 7701 7629 DLY1_5VX1 $T=433000 80640 0 0 $X=432570 $Y=80000
X59024 1 2 7347 9702 DLY1_5VX1 $T=439720 80640 0 0 $X=439290 $Y=80000
X59025 1 2 7727 7746 DLY1_5VX1 $T=446440 98560 1 0 $X=446010 $Y=93440
X59026 1 2 7760 7770 DLY1_5VX1 $T=452040 116480 1 0 $X=451610 $Y=111360
X59027 1 2 9726 7773 DLY1_5VX1 $T=453720 98560 0 0 $X=453290 $Y=97920
X59028 1 2 9732 7790 DLY1_5VX1 $T=459880 80640 1 0 $X=459450 $Y=75520
X59029 1 2 7796 7812 DLY1_5VX1 $T=463240 134400 1 0 $X=462810 $Y=129280
X59030 1 2 7788 7798 DLY1_5VX1 $T=463800 179200 0 0 $X=463370 $Y=178560
X59031 1 2 7817 7776 DLY1_5VX1 $T=473320 215040 1 0 $X=472890 $Y=209920
X59032 1 2 7775 9896 DLY1_5VX1 $T=477800 197120 0 0 $X=477370 $Y=196480
X59033 1 2 7832 7862 DLY1_5VX1 $T=487320 179200 0 0 $X=486890 $Y=178560
X59034 1 2 7841 7863 DLY1_5VX1 $T=492920 188160 1 0 $X=492490 $Y=183040
X59035 1 2 7732 7882 DLY1_5VX1 $T=493480 143360 1 0 $X=493050 $Y=138240
X59036 1 2 7886 7868 DLY1_5VX1 $T=496280 152320 0 0 $X=495850 $Y=151680
X59037 1 2 7892 7875 DLY1_5VX1 $T=499640 107520 1 0 $X=499210 $Y=102400
X59038 1 2 7898 7918 DLY1_5VX1 $T=501320 35840 1 0 $X=500890 $Y=30720
X59039 1 2 7856 7893 DLY1_5VX1 $T=502440 152320 0 0 $X=502010 $Y=151680
X59040 1 2 9753 7873 DLY1_5VX1 $T=504680 161280 0 0 $X=504250 $Y=160640
X59041 1 2 7902 7904 DLY1_5VX1 $T=509720 71680 0 0 $X=509290 $Y=71040
X59042 1 2 7917 7905 DLY1_5VX1 $T=511960 134400 1 0 $X=511530 $Y=129280
X59043 1 2 9769 7922 DLY1_5VX1 $T=517000 62720 1 0 $X=516570 $Y=57600
X59044 1 2 7896 7923 DLY1_5VX1 $T=518680 80640 0 0 $X=518250 $Y=80000
X59045 1 2 7895 7924 DLY1_5VX1 $T=519240 53760 1 0 $X=518810 $Y=48640
X59046 1 2 9808 7927 DLY1_5VX1 $T=525960 107520 0 0 $X=525530 $Y=106880
X59047 1 2 7929 7932 DLY1_5VX1 $T=526520 89600 1 0 $X=526090 $Y=84480
X59048 1 2 7911 7930 DLY1_5VX1 $T=529320 35840 1 0 $X=528890 $Y=30720
X59049 1 2 7931 703 DLY1_5VX1 $T=530440 17920 1 0 $X=530010 $Y=12800
X59050 1 2 6498 6762 BU_5VX6 $T=209560 385280 0 0 $X=209130 $Y=384640
X59051 1 2 987 946 BU_5VX12 $T=-553160 197120 0 0 $X=-553590 $Y=196480
X59052 1 2 1318 995 BU_5VX12 $T=-538040 241920 0 0 $X=-538470 $Y=241280
X59053 1 2 8013 1161 BU_5VX12 $T=-521240 268800 0 0 $X=-521670 $Y=268160
X59054 1 2 1318 1201 BU_5VX12 $T=-491560 224000 0 0 $X=-491990 $Y=223360
X59055 1 2 1474 1258 BU_5VX12 $T=-491560 286720 1 0 $X=-491990 $Y=281600
X59056 1 2 1631 1321 BU_5VX12 $T=-474200 224000 0 0 $X=-474630 $Y=223360
X59057 1 2 1474 1480 BU_5VX12 $T=-465800 277760 0 0 $X=-466230 $Y=277120
X59058 1 2 1631 1573 BU_5VX12 $T=-442280 241920 0 0 $X=-442710 $Y=241280
X59059 1 2 2020 1835 BU_5VX12 $T=-417640 313600 0 0 $X=-418070 $Y=312960
X59060 1 2 1905 1730 BU_5VX12 $T=-408120 206080 1 0 $X=-408550 $Y=200960
X59061 1 2 2020 1919 BU_5VX12 $T=-393000 295680 1 0 $X=-393430 $Y=290560
X59062 1 2 2146 1346 BU_5VX12 $T=-379000 80640 1 0 $X=-379430 $Y=75520
X59063 1 2 2146 971 BU_5VX12 $T=-379000 89600 0 0 $X=-379430 $Y=88960
X59064 1 2 2146 1242 BU_5VX12 $T=-379000 98560 0 0 $X=-379430 $Y=97920
X59065 1 2 2147 2223 BU_5VX12 $T=-379000 206080 0 0 $X=-379430 $Y=205440
X59066 1 2 2147 2103 BU_5VX12 $T=-379000 259840 1 0 $X=-379430 $Y=254720
X59067 1 2 2298 1002 BU_5VX12 $T=-348200 53760 0 0 $X=-348630 $Y=53120
X59068 1 2 2298 7952 BU_5VX12 $T=-347640 62720 1 0 $X=-348070 $Y=57600
X59069 1 2 2298 1147 BU_5VX12 $T=-333640 53760 1 0 $X=-334070 $Y=48640
X59070 1 2 2146 1552 BU_5VX12 $T=-331400 89600 1 0 $X=-331830 $Y=84480
X59071 1 2 2298 1171 BU_5VX12 $T=-330280 62720 1 0 $X=-330710 $Y=57600
X59072 1 2 103 112 BU_5VX12 $T=-325240 17920 0 0 $X=-325670 $Y=17280
X59073 1 2 2298 1822 BU_5VX12 $T=-318520 53760 0 0 $X=-318950 $Y=53120
X59074 1 2 2298 1387 BU_5VX12 $T=-316280 53760 1 0 $X=-316710 $Y=48640
X59075 1 2 2146 2189 BU_5VX12 $T=-314040 89600 1 0 $X=-314470 $Y=84480
X59076 1 2 103 8076 BU_5VX12 $T=-312920 26880 1 0 $X=-313350 $Y=21760
X59077 1 2 2298 2345 BU_5VX12 $T=-308440 62720 0 0 $X=-308870 $Y=62080
X59078 1 2 2650 2614 BU_5VX12 $T=-303960 304640 1 0 $X=-304390 $Y=299520
X59079 1 2 2710 2626 BU_5VX12 $T=-297800 268800 1 0 $X=-298230 $Y=263680
X59080 1 2 2298 2344 BU_5VX12 $T=-296120 53760 0 0 $X=-296550 $Y=53120
X59081 1 2 103 90 BU_5VX12 $T=-295560 17920 1 0 $X=-295990 $Y=12800
X59082 1 2 103 2342 BU_5VX12 $T=-295560 17920 0 0 $X=-295990 $Y=17280
X59083 1 2 2146 2529 BU_5VX12 $T=-292760 98560 1 0 $X=-293190 $Y=93440
X59084 1 2 2590 1905 BU_5VX12 $T=-291640 71680 1 0 $X=-292070 $Y=66560
X59085 1 2 2146 2762 BU_5VX12 $T=-283800 80640 0 0 $X=-284230 $Y=80000
X59086 1 2 114 2710 BU_5VX12 $T=-283240 98560 0 0 $X=-283670 $Y=97920
X59087 1 2 2146 2754 BU_5VX12 $T=-282120 107520 1 0 $X=-282550 $Y=102400
X59088 1 2 2650 2733 BU_5VX12 $T=-281000 358400 1 0 $X=-281430 $Y=353280
X59089 1 2 2298 8345 BU_5VX12 $T=-278760 53760 0 0 $X=-279190 $Y=53120
X59090 1 2 2298 2336 BU_5VX12 $T=-275960 53760 1 0 $X=-276390 $Y=48640
X59091 1 2 2146 2772 BU_5VX12 $T=-275400 98560 1 0 $X=-275830 $Y=93440
X59092 1 2 2901 2947 BU_5VX12 $T=-269800 295680 1 0 $X=-270230 $Y=290560
X59093 1 2 2146 2956 BU_5VX12 $T=-264760 107520 1 0 $X=-265190 $Y=102400
X59094 1 2 2901 2880 BU_5VX12 $T=-256360 367360 0 0 $X=-256790 $Y=366720
X59095 1 2 8404 3094 BU_5VX12 $T=-252440 232960 1 0 $X=-252870 $Y=227840
X59096 1 2 3287 3178 BU_5VX12 $T=-232840 197120 1 0 $X=-233270 $Y=192000
X59097 1 2 3287 3219 BU_5VX12 $T=-218280 143360 0 0 $X=-218710 $Y=142720
X59098 1 2 203 3222 BU_5VX12 $T=-217160 53760 0 0 $X=-217590 $Y=53120
X59099 1 2 3287 3193 BU_5VX12 $T=-197000 116480 1 0 $X=-197430 $Y=111360
X59100 1 2 203 3830 BU_5VX12 $T=-155560 44800 1 0 $X=-155990 $Y=39680
X59101 1 2 203 3774 BU_5VX12 $T=-155000 89600 1 0 $X=-155430 $Y=84480
X59102 1 2 3287 4161 BU_5VX12 $T=-143800 143360 0 0 $X=-144230 $Y=142720
X59103 1 2 3287 3916 BU_5VX12 $T=-138200 107520 1 0 $X=-138630 $Y=102400
X59104 1 2 4311 3169 BU_5VX12 $T=-135960 161280 0 0 $X=-136390 $Y=160640
X59105 1 2 203 4092 BU_5VX12 $T=-135400 53760 0 0 $X=-135830 $Y=53120
X59106 1 2 4313 3030 BU_5VX12 $T=-129240 232960 1 0 $X=-129670 $Y=227840
X59107 1 2 4311 3293 BU_5VX12 $T=-97880 134400 1 0 $X=-98310 $Y=129280
X59108 1 2 4311 3521 BU_5VX12 $T=-97880 143360 1 0 $X=-98310 $Y=138240
X59109 1 2 4313 3493 BU_5VX12 $T=-97880 259840 1 0 $X=-98310 $Y=254720
X59110 1 2 4311 3911 BU_5VX12 $T=-96200 152320 0 0 $X=-96630 $Y=151680
X59111 1 2 4313 3586 BU_5VX12 $T=-95640 250880 0 0 $X=-96070 $Y=250240
X59112 1 2 4313 3257 BU_5VX12 $T=-94520 232960 1 0 $X=-94950 $Y=227840
X59113 1 2 4313 4388 BU_5VX12 $T=-94520 232960 0 0 $X=-94950 $Y=232320
X59114 1 2 3287 4348 BU_5VX12 $T=-93960 98560 0 0 $X=-94390 $Y=97920
X59115 1 2 4313 3851 BU_5VX12 $T=-91720 250880 1 0 $X=-92150 $Y=245760
X59116 1 2 4311 4168 BU_5VX12 $T=-89480 125440 0 0 $X=-89910 $Y=124800
X59117 1 2 4313 4154 BU_5VX12 $T=-87240 241920 0 0 $X=-87670 $Y=241280
X59118 1 2 4311 4353 BU_5VX12 $T=-85560 152320 1 0 $X=-85990 $Y=147200
X59119 1 2 4311 3556 BU_5VX12 $T=-85560 161280 1 0 $X=-85990 $Y=156160
X59120 1 2 3287 4352 BU_5VX12 $T=-83320 179200 0 0 $X=-83750 $Y=178560
X59121 1 2 4311 4358 BU_5VX12 $T=-77720 134400 1 0 $X=-78150 $Y=129280
X59122 1 2 4313 4645 BU_5VX12 $T=-70440 224000 1 0 $X=-70870 $Y=218880
X59123 1 2 3287 4511 BU_5VX12 $T=-68200 152320 1 0 $X=-68630 $Y=147200
X59124 1 2 4311 3719 BU_5VX12 $T=-68200 161280 1 0 $X=-68630 $Y=156160
X59125 1 2 4313 4909 BU_5VX12 $T=-61480 232960 1 0 $X=-61910 $Y=227840
X59126 1 2 3287 8858 BU_5VX12 $T=-58120 116480 1 0 $X=-58550 $Y=111360
X59127 1 2 4311 4496 BU_5VX12 $T=-54200 143360 1 0 $X=-54630 $Y=138240
X59128 1 2 4313 3994 BU_5VX12 $T=-44120 232960 1 0 $X=-44550 $Y=227840
X59129 1 2 3287 4610 BU_5VX12 $T=-43000 161280 0 0 $X=-43430 $Y=160640
X59130 1 2 5041 5064 BU_5VX12 $T=-8280 215040 1 0 $X=-8710 $Y=209920
X59131 1 2 5088 4914 BU_5VX12 $T=-1560 286720 0 0 $X=-1990 $Y=286080
X59132 1 2 5088 5140 BU_5VX12 $T=6280 250880 0 0 $X=5850 $Y=250240
X59133 1 2 5088 5095 BU_5VX12 $T=9640 215040 0 0 $X=9210 $Y=214400
X59134 1 2 5380 5050 BU_5VX12 $T=16360 259840 1 0 $X=15930 $Y=254720
X59135 1 2 400 5461 BU_5VX12 $T=30920 53760 0 0 $X=30490 $Y=53120
X59136 1 2 5380 5159 BU_5VX12 $T=36520 259840 0 0 $X=36090 $Y=259200
X59137 1 2 5088 5245 BU_5VX12 $T=36520 295680 1 0 $X=36090 $Y=290560
X59138 1 2 400 5524 BU_5VX12 $T=39320 98560 1 0 $X=38890 $Y=93440
X59139 1 2 5380 5363 BU_5VX12 $T=43800 215040 0 0 $X=43370 $Y=214400
X59140 1 2 5380 5521 BU_5VX12 $T=45480 241920 0 0 $X=45050 $Y=241280
X59141 1 2 5041 5396 BU_5VX12 $T=46040 188160 1 0 $X=45610 $Y=183040
X59142 1 2 5380 5549 BU_5VX12 $T=49400 268800 1 0 $X=48970 $Y=263680
X59143 1 2 5088 9070 BU_5VX12 $T=52200 250880 1 0 $X=51770 $Y=245760
X59144 1 2 400 5619 BU_5VX12 $T=56120 134400 0 0 $X=55690 $Y=133760
X59145 1 2 5041 5676 BU_5VX12 $T=62280 215040 1 0 $X=61850 $Y=209920
X59146 1 2 5380 5931 BU_5VX12 $T=64520 215040 0 0 $X=64090 $Y=214400
X59147 1 2 5380 5933 BU_5VX12 $T=67320 259840 1 0 $X=66890 $Y=254720
X59148 1 2 5088 9131 BU_5VX12 $T=70680 286720 0 0 $X=70250 $Y=286080
X59149 1 2 400 5688 BU_5VX12 $T=71800 71680 0 0 $X=71370 $Y=71040
X59150 1 2 5380 9157 BU_5VX12 $T=73480 241920 1 0 $X=73050 $Y=236800
X59151 1 2 400 5693 BU_5VX12 $T=74600 44800 1 0 $X=74170 $Y=39680
X59152 1 2 5041 5911 BU_5VX12 $T=83560 170240 1 0 $X=83130 $Y=165120
X59153 1 2 400 5757 BU_5VX12 $T=84120 107520 0 0 $X=83690 $Y=106880
X59154 1 2 400 5776 BU_5VX12 $T=88040 134400 0 0 $X=87610 $Y=133760
X59155 1 2 5088 5818 BU_5VX12 $T=90280 224000 1 0 $X=89850 $Y=218880
X59156 1 2 5041 9143 BU_5VX12 $T=92520 188160 0 0 $X=92090 $Y=187520
X59157 1 2 5041 5910 BU_5VX12 $T=102600 143360 0 0 $X=102170 $Y=142720
X59158 1 2 5380 9243 BU_5VX12 $T=103720 259840 0 0 $X=103290 $Y=259200
X59159 1 2 5380 6336 BU_5VX12 $T=107640 241920 1 0 $X=107210 $Y=236800
X59160 1 2 5088 6127 BU_5VX12 $T=116040 224000 0 0 $X=115610 $Y=223360
X59161 1 2 5041 6158 BU_5VX12 $T=120520 215040 1 0 $X=120090 $Y=209920
X59162 1 2 5041 6076 BU_5VX12 $T=121080 179200 1 0 $X=120650 $Y=174080
X59163 1 2 5088 6104 BU_5VX12 $T=155800 259840 0 0 $X=155370 $Y=259200
X59164 1 2 5088 6213 BU_5VX12 $T=156360 304640 0 0 $X=155930 $Y=304000
X59165 1 2 5041 9299 BU_5VX12 $T=168120 170240 0 0 $X=167690 $Y=169600
X59166 1 2 6453 6648 BU_5VX12 $T=172600 80640 1 0 $X=172170 $Y=75520
X59167 1 2 6453 6470 BU_5VX12 $T=173160 89600 0 0 $X=172730 $Y=88960
X59168 1 2 5041 6332 BU_5VX12 $T=175400 215040 0 0 $X=174970 $Y=214400
X59169 1 2 495 493 BU_5VX12 $T=177640 35840 1 0 $X=177210 $Y=30720
X59170 1 2 6538 6441 BU_5VX12 $T=183240 44800 0 0 $X=182810 $Y=44160
X59171 1 2 6453 6459 BU_5VX12 $T=184920 116480 0 0 $X=184490 $Y=115840
X59172 1 2 6538 6591 BU_5VX12 $T=186040 62720 0 0 $X=185610 $Y=62080
X59173 1 2 6538 9359 BU_5VX12 $T=186600 53760 0 0 $X=186170 $Y=53120
X59174 1 2 6453 6813 BU_5VX12 $T=192200 98560 0 0 $X=191770 $Y=97920
X59175 1 2 510 6386 BU_5VX12 $T=195560 80640 0 0 $X=195130 $Y=80000
X59176 1 2 510 6474 BU_5VX12 $T=195560 107520 0 0 $X=195130 $Y=106880
X59177 1 2 6453 6825 BU_5VX12 $T=201720 71680 1 0 $X=201290 $Y=66560
X59178 1 2 6453 6771 BU_5VX12 $T=204520 80640 1 0 $X=204090 $Y=75520
X59179 1 2 495 6433 BU_5VX12 $T=205080 53760 1 0 $X=204650 $Y=48640
X59180 1 2 510 9369 BU_5VX12 $T=212920 80640 0 0 $X=212490 $Y=80000
X59181 1 2 6538 6925 BU_5VX12 $T=221320 62720 1 0 $X=220890 $Y=57600
X59182 1 2 6538 6912 BU_5VX12 $T=222440 53760 1 0 $X=222010 $Y=48640
X59183 1 2 6453 7170 BU_5VX12 $T=230280 80640 0 0 $X=229850 $Y=80000
X59184 1 2 510 6763 BU_5VX12 $T=230840 116480 1 0 $X=230410 $Y=111360
X59185 1 2 510 6738 BU_5VX12 $T=235880 71680 1 0 $X=235450 $Y=66560
X59186 1 2 6538 7349 BU_5VX12 $T=237560 44800 1 0 $X=237130 $Y=39680
X59187 1 2 6538 7369 BU_5VX12 $T=242040 71680 0 0 $X=241610 $Y=71040
X59188 1 2 6453 6985 BU_5VX12 $T=243720 89600 1 0 $X=243290 $Y=84480
X59189 1 2 6453 7063 BU_5VX12 $T=261080 89600 1 0 $X=260650 $Y=84480
X59190 1 2 510 7016 BU_5VX12 $T=263880 98560 0 0 $X=263450 $Y=97920
X59191 1 2 6538 7101 BU_5VX12 $T=264440 53760 0 0 $X=264010 $Y=53120
X59192 1 2 6453 7190 BU_5VX12 $T=280120 80640 1 0 $X=279690 $Y=75520
X59193 1 2 6538 7820 BU_5VX12 $T=284040 62720 1 0 $X=283610 $Y=57600
X59194 1 2 510 9478 BU_5VX12 $T=286280 107520 1 0 $X=285850 $Y=102400
X59195 1 2 6538 7847 BU_5VX12 $T=286840 44800 0 0 $X=286410 $Y=44160
X59196 1 2 495 7189 BU_5VX12 $T=318200 62720 1 0 $X=317770 $Y=57600
X59197 1 2 510 7319 BU_5VX12 $T=329960 107520 0 0 $X=329530 $Y=106880
X59198 1 2 495 611 BU_5VX12 $T=356280 26880 1 0 $X=355850 $Y=21760
X59199 1 2 510 7757 BU_5VX12 $T=466600 98560 0 0 $X=466170 $Y=97920
X59200 1 2 510 7866 BU_5VX12 $T=499080 62720 0 0 $X=498650 $Y=62080
X59201 1 2 495 690 BU_5VX12 $T=511400 26880 1 0 $X=510970 $Y=21760
X59202 1 2 114 2020 BU_5VX16 $T=-314600 98560 1 0 $X=-315030 $Y=93440
X59203 1 2 2590 1318 BU_5VX16 $T=-313480 71680 1 0 $X=-313910 $Y=66560
X59204 1 2 114 1474 BU_5VX16 $T=-313480 80640 0 0 $X=-313910 $Y=80000
X59205 1 2 2590 1631 BU_5VX16 $T=-310680 71680 0 0 $X=-311110 $Y=71040
X59206 1 2 8386 2298 BU_5VX16 $T=-296680 44800 0 0 $X=-297110 $Y=44160
X59207 1 2 8404 2840 BU_5VX16 $T=-285480 232960 1 0 $X=-285910 $Y=227840
X59208 1 2 114 8013 BU_5VX16 $T=-279880 89600 1 0 $X=-280310 $Y=84480
X59209 1 2 3794 103 BU_5VX16 $T=-278200 17920 0 0 $X=-278630 $Y=17280
X59210 1 2 2590 987 BU_5VX16 $T=-274280 62720 0 0 $X=-274710 $Y=62080
X59211 1 2 2590 2147 BU_5VX16 $T=-263080 71680 1 0 $X=-263510 $Y=66560
X59212 1 2 2590 8404 BU_5VX16 $T=-259720 62720 1 0 $X=-260150 $Y=57600
X59213 1 2 8462 2146 BU_5VX16 $T=-258600 53760 1 0 $X=-259030 $Y=48640
X59214 1 2 114 2901 BU_5VX16 $T=-245160 89600 0 0 $X=-245590 $Y=88960
X59215 1 2 114 2650 BU_5VX16 $T=-223320 89600 0 0 $X=-223750 $Y=88960
X59216 1 2 238 3794 BU_5VX16 $T=-170120 17920 0 0 $X=-170550 $Y=17280
X59217 1 2 238 8462 BU_5VX16 $T=-164520 26880 1 0 $X=-164950 $Y=21760
X59218 1 2 238 8386 BU_5VX16 $T=-152200 26880 0 0 $X=-152630 $Y=26240
X59219 1 2 238 270 BU_5VX16 $T=-148280 17920 0 0 $X=-148710 $Y=17280
X59220 1 2 238 2590 BU_5VX16 $T=-142680 26880 1 0 $X=-143110 $Y=21760
X59221 1 2 4303 3287 BU_5VX16 $T=-97880 44800 1 0 $X=-98310 $Y=39680
X59222 1 2 4484 878 BU_5VX16 $T=-75480 268800 0 0 $X=-75910 $Y=268160
X59223 1 2 4542 4313 BU_5VX16 $T=-68760 215040 0 0 $X=-69190 $Y=214400
X59224 1 2 4543 1713 BU_5VX16 $T=-67640 250880 0 0 $X=-68070 $Y=250240
X59225 1 2 4592 4311 BU_5VX16 $T=-63720 98560 1 0 $X=-64150 $Y=93440
X59226 1 2 4722 4826 BU_5VX16 $T=-45800 250880 0 0 $X=-46230 $Y=250240
X59227 1 2 4484 7936 BU_5VX16 $T=-36840 268800 1 0 $X=-37270 $Y=263680
X59228 1 2 4484 895 BU_5VX16 $T=-30120 241920 1 0 $X=-30550 $Y=236800
X59229 1 2 4484 1113 BU_5VX16 $T=-25080 277760 1 0 $X=-25510 $Y=272640
X59230 1 2 4978 2552 BU_5VX16 $T=-15560 304640 1 0 $X=-15990 $Y=299520
X59231 1 2 4543 1235 BU_5VX16 $T=-15000 268800 1 0 $X=-15430 $Y=263680
X59232 1 2 5279 4303 BU_5VX16 $T=-13880 35840 1 0 $X=-14310 $Y=30720
X59233 1 2 5048 3533 BU_5VX16 $T=-4920 259840 0 0 $X=-5350 $Y=259200
X59234 1 2 8978 396 BU_5VX16 $T=-4360 26880 1 0 $X=-4790 $Y=21760
X59235 1 2 4543 2359 BU_5VX16 $T=-3240 277760 1 0 $X=-3670 $Y=272640
X59236 1 2 4978 2698 BU_5VX16 $T=-1560 295680 1 0 $X=-1990 $Y=290560
X59237 1 2 4543 2475 BU_5VX16 $T=1240 268800 0 0 $X=810 $Y=268160
X59238 1 2 396 400 BU_5VX16 $T=2360 17920 0 0 $X=1930 $Y=17280
X59239 1 2 396 5088 BU_5VX16 $T=7960 35840 1 0 $X=7530 $Y=30720
X59240 1 2 4978 2652 BU_5VX16 $T=7960 286720 1 0 $X=7530 $Y=281600
X59241 1 2 5279 401 BU_5VX16 $T=8520 44800 1 0 $X=8090 $Y=39680
X59242 1 2 396 5041 BU_5VX16 $T=13560 26880 0 0 $X=13130 $Y=26240
X59243 1 2 396 5380 BU_5VX16 $T=16360 17920 1 0 $X=15930 $Y=12800
X59244 1 2 5279 4542 BU_5VX16 $T=17480 26880 1 0 $X=17050 $Y=21760
X59245 1 2 5279 407 BU_5VX16 $T=24200 17920 0 0 $X=23770 $Y=17280
X59246 1 2 4978 3104 BU_5VX16 $T=27560 268800 1 0 $X=27130 $Y=263680
X59247 1 2 5279 4592 BU_5VX16 $T=30360 35840 1 0 $X=29930 $Y=30720
X59248 1 2 5279 414 BU_5VX16 $T=38200 17920 1 0 $X=37770 $Y=12800
X59249 1 2 417 427 BU_5VX16 $T=60040 17920 1 0 $X=59610 $Y=12800
X59250 1 2 494 6538 BU_5VX16 $T=177080 17920 0 0 $X=176650 $Y=17280
X59251 1 2 494 6453 BU_5VX16 $T=194440 26880 0 0 $X=194010 $Y=26240
X59252 1 2 542 6981 BU_5VX16 $T=254360 17920 1 0 $X=253930 $Y=12800
X59253 1 2 85 5147 IN_5VX16 $T=-348200 358400 1 0 $X=-348630 $Y=353280
X59254 1 2 308 238 IN_5VX16 $T=-97880 17920 0 0 $X=-98310 $Y=17280
X59255 1 2 5147 4484 IN_5VX16 $T=-60920 259840 0 0 $X=-61350 $Y=259200
X59256 1 2 5147 4543 IN_5VX16 $T=-40200 259840 0 0 $X=-40630 $Y=259200
X59257 1 2 5147 5048 IN_5VX16 $T=-13320 277760 0 0 $X=-13750 $Y=277120
X59258 1 2 308 8978 IN_5VX16 $T=-8840 26880 0 0 $X=-9270 $Y=26240
X59259 1 2 308 5279 IN_5VX16 $T=-4360 17920 1 0 $X=-4790 $Y=12800
X59260 1 2 5147 4722 IN_5VX16 $T=6840 268800 1 0 $X=6410 $Y=263680
X59261 1 2 5147 4978 IN_5VX16 $T=7400 277760 0 0 $X=6970 $Y=277120
X59262 1 2 308 417 IN_5VX16 $T=44360 26880 0 0 $X=43930 $Y=26240
X59263 1 2 16 899 IN_5VX3 $T=-523480 170240 1 180 $X=-527830 $Y=169600
X59264 1 2 16 974 IN_5VX3 $T=-521800 125440 1 0 $X=-522230 $Y=120320
X59265 1 2 153 2499 IN_5VX3 $T=-255800 268800 1 180 $X=-260150 $Y=268160
X59266 1 2 153 4343 IN_5VX3 $T=-12760 286720 1 0 $X=-13190 $Y=281600
X59267 1 2 153 5504 IN_5VX3 $T=50520 224000 1 0 $X=50090 $Y=218880
X59268 1 2 153 6540 IN_5VX3 $T=253800 107520 1 0 $X=253370 $Y=102400
X59269 1 2 153 7032 IN_5VX3 $T=265560 71680 1 0 $X=265130 $Y=66560
X59270 1 2 153 2810 IN_5VX4 $T=-227800 26880 1 0 $X=-228230 $Y=21760
X59271 1 2 4457 323 IN_5VX4 $T=-75480 17920 0 0 $X=-75910 $Y=17280
X59272 1 2 4571 353 IN_5VX4 $T=-58680 143360 1 0 $X=-59110 $Y=138240
X59273 1 2 933 7971 IN_5VX1 $T=-545320 179200 1 0 $X=-545750 $Y=174080
X59274 1 2 7973 1044 IN_5VX1 $T=-542520 179200 0 0 $X=-542950 $Y=178560
X59275 1 2 973 1041 IN_5VX1 $T=-533000 224000 0 180 $X=-535110 $Y=218880
X59276 1 2 1131 1089 IN_5VX1 $T=-521800 259840 1 0 $X=-522230 $Y=254720
X59277 1 2 899 1117 IN_5VX1 $T=-515640 322560 0 180 $X=-517750 $Y=317440
X59278 1 2 9910 8027 IN_5VX1 $T=-508360 143360 1 180 $X=-510470 $Y=142720
X59279 1 2 1182 1181 IN_5VX1 $T=-507800 134400 1 180 $X=-509910 $Y=133760
X59280 1 2 1375 8072 IN_5VX1 $T=-481480 259840 1 180 $X=-483590 $Y=259200
X59281 1 2 1302 1328 IN_5VX1 $T=-479240 161280 0 180 $X=-481350 $Y=156160
X59282 1 2 1389 1342 IN_5VX1 $T=-477000 107520 0 180 $X=-479110 $Y=102400
X59283 1 2 1468 8103 IN_5VX1 $T=-464680 116480 0 180 $X=-466790 $Y=111360
X59284 1 2 1503 1486 IN_5VX1 $T=-459080 268800 1 180 $X=-461190 $Y=268160
X59285 1 2 1626 1529 IN_5VX1 $T=-445080 143360 0 180 $X=-447190 $Y=138240
X59286 1 2 1376 1579 IN_5VX1 $T=-446760 286720 0 0 $X=-447190 $Y=286080
X59287 1 2 1632 8145 IN_5VX1 $T=-440040 286720 0 180 $X=-442150 $Y=281600
X59288 1 2 1667 8149 IN_5VX1 $T=-436120 277760 0 180 $X=-438230 $Y=272640
X59289 1 2 1436 8147 IN_5VX1 $T=-436120 286720 0 180 $X=-438230 $Y=281600
X59290 1 2 1699 1325 IN_5VX1 $T=-431640 286720 0 180 $X=-433750 $Y=281600
X59291 1 2 1160 9911 IN_5VX1 $T=-430520 259840 0 0 $X=-430950 $Y=259200
X59292 1 2 1419 8175 IN_5VX1 $T=-428840 215040 0 0 $X=-429270 $Y=214400
X59293 1 2 1681 8183 IN_5VX1 $T=-426040 286720 0 0 $X=-426470 $Y=286080
X59294 1 2 1767 1728 IN_5VX1 $T=-422120 277760 1 180 $X=-424230 $Y=277120
X59295 1 2 1661 8206 IN_5VX1 $T=-414280 80640 0 0 $X=-414710 $Y=80000
X59296 1 2 1817 8212 IN_5VX1 $T=-414280 268800 1 0 $X=-414710 $Y=263680
X59297 1 2 53 8179 IN_5VX1 $T=-412040 26880 0 180 $X=-414150 $Y=21760
X59298 1 2 8202 1857 IN_5VX1 $T=-411480 134400 0 0 $X=-411910 $Y=133760
X59299 1 2 1648 1859 IN_5VX1 $T=-407560 232960 0 0 $X=-407990 $Y=232320
X59300 1 2 1854 1936 IN_5VX1 $T=-404760 250880 1 0 $X=-405190 $Y=245760
X59301 1 2 1934 1906 IN_5VX1 $T=-400280 215040 0 180 $X=-402390 $Y=209920
X59302 1 2 61 1763 IN_5VX1 $T=-399160 89600 1 180 $X=-401270 $Y=88960
X59303 1 2 61 1815 IN_5VX1 $T=-396920 44800 0 180 $X=-399030 $Y=39680
X59304 1 2 39 712 IN_5VX1 $T=-396360 53760 0 180 $X=-398470 $Y=48640
X59305 1 2 1928 8244 IN_5VX1 $T=-394680 241920 1 0 $X=-395110 $Y=236800
X59306 1 2 39 65 IN_5VX1 $T=-391320 44800 1 180 $X=-393430 $Y=44160
X59307 1 2 41 67 IN_5VX1 $T=-390200 26880 1 180 $X=-392310 $Y=26240
X59308 1 2 43 71 IN_5VX1 $T=-391320 44800 0 0 $X=-391750 $Y=44160
X59309 1 2 61 8243 IN_5VX1 $T=-389640 80640 1 180 $X=-391750 $Y=80000
X59310 1 2 2038 73 IN_5VX1 $T=-389640 80640 0 0 $X=-390070 $Y=80000
X59311 1 2 2046 2096 IN_5VX1 $T=-389080 215040 1 0 $X=-389510 $Y=209920
X59312 1 2 2101 8253 IN_5VX1 $T=-383480 206080 0 0 $X=-383910 $Y=205440
X59313 1 2 1661 69 IN_5VX1 $T=-381240 26880 0 180 $X=-383350 $Y=21760
X59314 1 2 2050 2118 IN_5VX1 $T=-382920 197120 0 0 $X=-383350 $Y=196480
X59315 1 2 2157 2109 IN_5VX1 $T=-376760 143360 1 180 $X=-378870 $Y=142720
X59316 1 2 715 2105 IN_5VX1 $T=-376760 197120 1 180 $X=-378870 $Y=196480
X59317 1 2 1084 9912 IN_5VX1 $T=-376200 107520 1 0 $X=-376630 $Y=102400
X59318 1 2 2181 9827 IN_5VX1 $T=-374520 179200 0 180 $X=-376630 $Y=174080
X59319 1 2 2089 9798 IN_5VX1 $T=-370040 161280 0 0 $X=-370470 $Y=160640
X59320 1 2 717 2087 IN_5VX1 $T=-364440 161280 0 180 $X=-366550 $Y=156160
X59321 1 2 2362 8299 IN_5VX1 $T=-342040 161280 0 180 $X=-344150 $Y=156160
X59322 1 2 2094 718 IN_5VX1 $T=-339240 170240 1 180 $X=-341350 $Y=169600
X59323 1 2 8313 2313 IN_5VX1 $T=-337560 170240 1 180 $X=-339670 $Y=169600
X59324 1 2 1661 2551 IN_5VX1 $T=-315160 71680 1 0 $X=-315590 $Y=66560
X59325 1 2 2499 8373 IN_5VX1 $T=-301720 385280 1 0 $X=-302150 $Y=380160
X59326 1 2 39 2687 IN_5VX1 $T=-298360 44800 0 0 $X=-298790 $Y=44160
X59327 1 2 41 2713 IN_5VX1 $T=-297240 17920 1 0 $X=-297670 $Y=12800
X59328 1 2 2594 2723 IN_5VX1 $T=-292200 295680 0 0 $X=-292630 $Y=295040
X59329 1 2 43 2732 IN_5VX1 $T=-289400 62720 1 180 $X=-291510 $Y=62080
X59330 1 2 17 8395 IN_5VX1 $T=-291080 98560 0 0 $X=-291510 $Y=97920
X59331 1 2 61 2678 IN_5VX1 $T=-289400 107520 1 180 $X=-291510 $Y=106880
X59332 1 2 8396 2769 IN_5VX1 $T=-288280 268800 0 0 $X=-288710 $Y=268160
X59333 1 2 47 128 IN_5VX1 $T=-284360 26880 1 180 $X=-286470 $Y=26240
X59334 1 2 40 2747 IN_5VX1 $T=-283240 35840 1 180 $X=-285350 $Y=35200
X59335 1 2 9913 8403 IN_5VX1 $T=-284920 259840 0 0 $X=-285350 $Y=259200
X59336 1 2 132 2801 IN_5VX1 $T=-278760 26880 1 0 $X=-279190 $Y=21760
X59337 1 2 2831 2835 IN_5VX1 $T=-273160 331520 1 0 $X=-273590 $Y=326400
X59338 1 2 47 2860 IN_5VX1 $T=-268680 107520 1 180 $X=-270790 $Y=106880
X59339 1 2 77 137 IN_5VX1 $T=-266440 26880 0 180 $X=-268550 $Y=21760
X59340 1 2 3088 9914 IN_5VX1 $T=-266440 241920 1 0 $X=-266870 $Y=236800
X59341 1 2 3003 731 IN_5VX1 $T=-254680 232960 1 0 $X=-255110 $Y=227840
X59342 1 2 43 3035 IN_5VX1 $T=-241800 152320 1 180 $X=-243910 $Y=151680
X59343 1 2 1661 3113 IN_5VX1 $T=-241240 152320 0 0 $X=-241670 $Y=151680
X59344 1 2 3159 3164 IN_5VX1 $T=-235080 340480 0 0 $X=-235510 $Y=339840
X59345 1 2 3185 2968 IN_5VX1 $T=-230040 143360 1 180 $X=-232150 $Y=142720
X59346 1 2 3212 3221 IN_5VX1 $T=-221080 241920 0 180 $X=-223190 $Y=236800
X59347 1 2 3324 3330 IN_5VX1 $T=-216600 385280 1 0 $X=-217030 $Y=380160
X59348 1 2 8560 8558 IN_5VX1 $T=-212120 367360 0 180 $X=-214230 $Y=362240
X59349 1 2 47 3414 IN_5VX1 $T=-205960 62720 0 0 $X=-206390 $Y=62080
X59350 1 2 43 3375 IN_5VX1 $T=-203720 98560 1 0 $X=-204150 $Y=93440
X59351 1 2 8583 3337 IN_5VX1 $T=-202040 206080 0 180 $X=-204150 $Y=200960
X59352 1 2 77 8589 IN_5VX1 $T=-195880 98560 0 180 $X=-197990 $Y=93440
X59353 1 2 8599 8595 IN_5VX1 $T=-195880 367360 0 180 $X=-197990 $Y=362240
X59354 1 2 3448 3396 IN_5VX1 $T=-195320 206080 0 180 $X=-197430 $Y=200960
X59355 1 2 61 3476 IN_5VX1 $T=-196440 107520 0 0 $X=-196870 $Y=106880
X59356 1 2 40 3465 IN_5VX1 $T=-196440 125440 1 0 $X=-196870 $Y=120320
X59357 1 2 3454 3415 IN_5VX1 $T=-194760 170240 0 180 $X=-196870 $Y=165120
X59358 1 2 3444 3504 IN_5VX1 $T=-191960 232960 1 0 $X=-192390 $Y=227840
X59359 1 2 8610 3423 IN_5VX1 $T=-188040 367360 1 180 $X=-190150 $Y=366720
X59360 1 2 39 3489 IN_5VX1 $T=-184120 80640 0 180 $X=-186230 $Y=75520
X59361 1 2 3544 3642 IN_5VX1 $T=-184680 367360 0 0 $X=-185110 $Y=366720
X59362 1 2 3580 8621 IN_5VX1 $T=-181320 26880 0 180 $X=-183430 $Y=21760
X59363 1 2 3610 3110 IN_5VX1 $T=-174040 358400 1 180 $X=-176150 $Y=357760
X59364 1 2 3253 3655 IN_5VX1 $T=-174040 367360 0 180 $X=-176150 $Y=362240
X59365 1 2 3038 9915 IN_5VX1 $T=-175160 358400 1 0 $X=-175590 $Y=353280
X59366 1 2 3385 3793 IN_5VX1 $T=-172920 313600 1 0 $X=-173350 $Y=308480
X59367 1 2 8628 8654 IN_5VX1 $T=-172920 376320 1 0 $X=-173350 $Y=371200
X59368 1 2 3695 3787 IN_5VX1 $T=-163400 358400 1 0 $X=-163830 $Y=353280
X59369 1 2 3584 3979 IN_5VX1 $T=-154440 322560 0 0 $X=-154870 $Y=321920
X59370 1 2 3801 3902 IN_5VX1 $T=-148840 224000 0 0 $X=-149270 $Y=223360
X59371 1 2 3875 8716 IN_5VX1 $T=-146600 304640 0 0 $X=-147030 $Y=304000
X59372 1 2 3899 8733 IN_5VX1 $T=-139320 340480 1 0 $X=-139750 $Y=335360
X59373 1 2 4000 9802 IN_5VX1 $T=-133160 268800 1 0 $X=-133590 $Y=263680
X59374 1 2 4058 4080 IN_5VX1 $T=-132600 286720 0 0 $X=-133030 $Y=286080
X59375 1 2 4066 8749 IN_5VX1 $T=-130360 71680 0 180 $X=-132470 $Y=66560
X59376 1 2 8721 8752 IN_5VX1 $T=-130360 331520 1 180 $X=-132470 $Y=330880
X59377 1 2 3968 8762 IN_5VX1 $T=-130360 250880 1 0 $X=-130790 $Y=245760
X59378 1 2 1980 4104 IN_5VX1 $T=-124760 241920 0 180 $X=-126870 $Y=236800
X59379 1 2 4137 8776 IN_5VX1 $T=-120840 80640 0 180 $X=-122950 $Y=75520
X59380 1 2 4097 4160 IN_5VX1 $T=-122520 89600 0 0 $X=-122950 $Y=88960
X59381 1 2 4158 8775 IN_5VX1 $T=-119720 304640 0 180 $X=-121830 $Y=299520
X59382 1 2 4194 8747 IN_5VX1 $T=-116360 215040 0 180 $X=-118470 $Y=209920
X59383 1 2 8784 4150 IN_5VX1 $T=-116360 241920 1 180 $X=-118470 $Y=241280
X59384 1 2 9850 8785 IN_5VX1 $T=-118040 277760 1 0 $X=-118470 $Y=272640
X59385 1 2 745 744 IN_5VX1 $T=-114120 241920 1 180 $X=-116230 $Y=241280
X59386 1 2 746 4135 IN_5VX1 $T=-112440 304640 0 180 $X=-114550 $Y=299520
X59387 1 2 4042 4228 IN_5VX1 $T=-113560 259840 1 0 $X=-113990 $Y=254720
X59388 1 2 4546 4442 IN_5VX1 $T=-79960 62720 1 0 $X=-80390 $Y=57600
X59389 1 2 8840 4473 IN_5VX1 $T=-77160 17920 0 0 $X=-77590 $Y=17280
X59390 1 2 4366 8844 IN_5VX1 $T=-76040 44800 1 0 $X=-76470 $Y=39680
X59391 1 2 4477 4433 IN_5VX1 $T=-73800 53760 0 180 $X=-75910 $Y=48640
X59392 1 2 325 328 IN_5VX1 $T=-70440 17920 0 180 $X=-72550 $Y=12800
X59393 1 2 4432 8852 IN_5VX1 $T=-70440 35840 1 180 $X=-72550 $Y=35200
X59394 1 2 8855 4506 IN_5VX1 $T=-68760 35840 1 180 $X=-70870 $Y=35200
X59395 1 2 9855 8849 IN_5VX1 $T=-67080 71680 0 180 $X=-69190 $Y=66560
X59396 1 2 751 8859 IN_5VX1 $T=-66520 80640 1 0 $X=-66950 $Y=75520
X59397 1 2 4561 8857 IN_5VX1 $T=-63720 71680 0 180 $X=-65830 $Y=66560
X59398 1 2 4568 8862 IN_5VX1 $T=-63160 80640 0 180 $X=-65270 $Y=75520
X59399 1 2 4591 4622 IN_5VX1 $T=-60920 89600 1 0 $X=-61350 $Y=84480
X59400 1 2 346 343 IN_5VX1 $T=-56440 17920 0 180 $X=-58550 $Y=12800
X59401 1 2 4648 4598 IN_5VX1 $T=-54200 80640 1 180 $X=-56310 $Y=80000
X59402 1 2 4343 4651 IN_5VX1 $T=-51960 349440 0 180 $X=-54070 $Y=344320
X59403 1 2 4604 4686 IN_5VX1 $T=-46360 35840 1 180 $X=-48470 $Y=35200
X59404 1 2 348 8880 IN_5VX1 $T=-45240 80640 0 180 $X=-47350 $Y=75520
X59405 1 2 362 4724 IN_5VX1 $T=-46360 53760 1 0 $X=-46790 $Y=48640
X59406 1 2 4739 330 IN_5VX1 $T=-40760 89600 0 180 $X=-42870 $Y=84480
X59407 1 2 4759 9916 IN_5VX1 $T=-34040 134400 1 180 $X=-36150 $Y=133760
X59408 1 2 4792 4809 IN_5VX1 $T=-35160 206080 1 0 $X=-35590 $Y=200960
X59409 1 2 4739 4873 IN_5VX1 $T=-27320 107520 1 0 $X=-27750 $Y=102400
X59410 1 2 4854 4825 IN_5VX1 $T=-26760 224000 0 0 $X=-27190 $Y=223360
X59411 1 2 8937 9917 IN_5VX1 $T=-18360 98560 0 180 $X=-20470 $Y=93440
X59412 1 2 346 8953 IN_5VX1 $T=-11080 98560 1 180 $X=-13190 $Y=97920
X59413 1 2 359 4860 IN_5VX1 $T=-11080 62720 1 0 $X=-11510 $Y=57600
X59414 1 2 351 383 IN_5VX1 $T=-10520 26880 0 0 $X=-10950 $Y=26240
X59415 1 2 346 8965 IN_5VX1 $T=-10520 152320 0 0 $X=-10950 $Y=151680
X59416 1 2 348 4943 IN_5VX1 $T=-7720 107520 1 180 $X=-9830 $Y=106880
X59417 1 2 4739 5029 IN_5VX1 $T=-8280 152320 1 0 $X=-8710 $Y=147200
X59418 1 2 362 8967 IN_5VX1 $T=-7720 62720 0 0 $X=-8150 $Y=62080
X59419 1 2 326 5024 IN_5VX1 $T=-3240 170240 1 180 $X=-5350 $Y=169600
X59420 1 2 366 4973 IN_5VX1 $T=-2680 143360 1 180 $X=-4790 $Y=142720
X59421 1 2 8986 5008 IN_5VX1 $T=-2680 161280 0 180 $X=-4790 $Y=156160
X59422 1 2 4945 4970 IN_5VX1 $T=-2680 313600 1 180 $X=-4790 $Y=312960
X59423 1 2 387 5028 IN_5VX1 $T=-1560 17920 1 180 $X=-3670 $Y=17280
X59424 1 2 5039 5072 IN_5VX1 $T=-2680 161280 1 0 $X=-3110 $Y=156160
X59425 1 2 4611 5091 IN_5VX1 $T=-440 134400 1 0 $X=-870 $Y=129280
X59426 1 2 339 8982 IN_5VX1 $T=2920 161280 0 180 $X=810 $Y=156160
X59427 1 2 5069 5131 IN_5VX1 $T=1240 385280 0 0 $X=810 $Y=384640
X59428 1 2 350 5211 IN_5VX1 $T=4040 53760 1 0 $X=3610 $Y=48640
X59429 1 2 5042 5086 IN_5VX1 $T=7400 259840 0 180 $X=5290 $Y=254720
X59430 1 2 9026 5202 IN_5VX1 $T=15800 197120 0 0 $X=15370 $Y=196480
X59431 1 2 5152 9860 IN_5VX1 $T=19720 340480 1 180 $X=17610 $Y=339840
X59432 1 2 5189 9032 IN_5VX1 $T=18040 385280 1 0 $X=17610 $Y=380160
X59433 1 2 9035 5251 IN_5VX1 $T=19720 286720 0 0 $X=19290 $Y=286080
X59434 1 2 5190 9040 IN_5VX1 $T=20280 80640 1 0 $X=19850 $Y=75520
X59435 1 2 4946 5262 IN_5VX1 $T=21400 304640 0 0 $X=20970 $Y=304000
X59436 1 2 353 5206 IN_5VX1 $T=23640 62720 0 180 $X=21530 $Y=57600
X59437 1 2 9051 9043 IN_5VX1 $T=27000 376320 0 180 $X=24890 $Y=371200
X59438 1 2 5276 9057 IN_5VX1 $T=27560 385280 1 0 $X=27130 $Y=380160
X59439 1 2 9918 5253 IN_5VX1 $T=30920 376320 0 180 $X=28810 $Y=371200
X59440 1 2 5278 5264 IN_5VX1 $T=34840 385280 1 0 $X=34410 $Y=380160
X59441 1 2 9076 9073 IN_5VX1 $T=41560 385280 0 180 $X=39450 $Y=380160
X59442 1 2 763 9088 IN_5VX1 $T=44360 385280 1 0 $X=43930 $Y=380160
X59443 1 2 419 5301 IN_5VX1 $T=62280 17920 1 180 $X=60170 $Y=17280
X59444 1 2 5515 5602 IN_5VX1 $T=61160 376320 0 0 $X=60730 $Y=375680
X59445 1 2 421 382 IN_5VX1 $T=63960 17920 1 180 $X=61850 $Y=17280
X59446 1 2 5583 9146 IN_5VX1 $T=68440 358400 0 0 $X=68010 $Y=357760
X59447 1 2 9145 9149 IN_5VX1 $T=69560 250880 0 0 $X=69130 $Y=250240
X59448 1 2 5684 5581 IN_5VX1 $T=86360 259840 0 180 $X=84250 $Y=254720
X59449 1 2 5939 5876 IN_5VX1 $T=94200 385280 0 180 $X=92090 $Y=380160
X59450 1 2 4739 5904 IN_5VX1 $T=94760 71680 0 0 $X=94330 $Y=71040
X59451 1 2 5745 5951 IN_5VX1 $T=99800 277760 1 0 $X=99370 $Y=272640
X59452 1 2 326 6011 IN_5VX1 $T=110440 71680 0 180 $X=108330 $Y=66560
X59453 1 2 6016 9212 IN_5VX1 $T=110440 340480 0 180 $X=108330 $Y=335360
X59454 1 2 359 452 IN_5VX1 $T=112680 35840 0 180 $X=110570 $Y=30720
X59455 1 2 6059 5955 IN_5VX1 $T=113240 358400 1 180 $X=111130 $Y=357760
X59456 1 2 4739 6087 IN_5VX1 $T=115480 152320 1 0 $X=115050 $Y=147200
X59457 1 2 339 6038 IN_5VX1 $T=117720 71680 0 180 $X=115610 $Y=66560
X59458 1 2 9234 9231 IN_5VX1 $T=117720 358400 1 180 $X=115610 $Y=357760
X59459 1 2 9221 9872 IN_5VX1 $T=118280 385280 0 0 $X=117850 $Y=384640
X59460 1 2 6109 9240 IN_5VX1 $T=120520 232960 0 180 $X=118410 $Y=227840
X59461 1 2 362 5956 IN_5VX1 $T=119400 62720 0 0 $X=118970 $Y=62080
X59462 1 2 348 6074 IN_5VX1 $T=122200 89600 0 180 $X=120090 $Y=84480
X59463 1 2 339 474 IN_5VX1 $T=125560 53760 0 0 $X=125130 $Y=53120
X59464 1 2 346 473 IN_5VX1 $T=131720 71680 0 180 $X=129610 $Y=66560
X59465 1 2 326 470 IN_5VX1 $T=134520 53760 0 0 $X=134090 $Y=53120
X59466 1 2 348 6198 IN_5VX1 $T=135080 89600 0 0 $X=134650 $Y=88960
X59467 1 2 346 6199 IN_5VX1 $T=135640 71680 1 0 $X=135210 $Y=66560
X59468 1 2 9268 6153 IN_5VX1 $T=138440 277760 1 180 $X=136330 $Y=277120
X59469 1 2 6092 9284 IN_5VX1 $T=151880 152320 0 0 $X=151450 $Y=151680
X59470 1 2 9277 6307 IN_5VX1 $T=154120 125440 0 0 $X=153690 $Y=124800
X59471 1 2 9297 9292 IN_5VX1 $T=158600 197120 1 0 $X=158170 $Y=192000
X59472 1 2 6399 6410 IN_5VX1 $T=170360 241920 1 180 $X=168250 $Y=241280
X59473 1 2 6443 6501 IN_5VX1 $T=175960 268800 1 0 $X=175530 $Y=263680
X59474 1 2 6561 6557 IN_5VX1 $T=188840 286720 0 180 $X=186730 $Y=281600
X59475 1 2 6520 6563 IN_5VX1 $T=187160 358400 1 0 $X=186730 $Y=353280
X59476 1 2 6642 6571 IN_5VX1 $T=191640 358400 0 180 $X=189530 $Y=353280
X59477 1 2 6570 9365 IN_5VX1 $T=192760 358400 1 0 $X=192330 $Y=353280
X59478 1 2 9882 9372 IN_5VX1 $T=194440 277760 0 0 $X=194010 $Y=277120
X59479 1 2 6649 791 IN_5VX1 $T=200600 331520 0 180 $X=198490 $Y=326400
X59480 1 2 6664 9883 IN_5VX1 $T=201160 259840 1 180 $X=199050 $Y=259200
X59481 1 2 9884 9375 IN_5VX1 $T=199480 295680 0 0 $X=199050 $Y=295040
X59482 1 2 6713 6604 IN_5VX1 $T=201160 313600 0 180 $X=199050 $Y=308480
X59483 1 2 9386 6676 IN_5VX1 $T=208440 295680 0 180 $X=206330 $Y=290560
X59484 1 2 6690 6617 IN_5VX1 $T=208440 340480 1 180 $X=206330 $Y=339840
X59485 1 2 540 543 IN_5VX1 $T=252680 26880 0 0 $X=252250 $Y=26240
X59486 1 2 542 564 IN_5VX1 $T=263880 26880 1 0 $X=263450 $Y=21760
X59487 1 2 548 9475 IN_5VX1 $T=273400 44800 0 180 $X=271290 $Y=39680
X59488 1 2 545 9487 IN_5VX1 $T=280120 62720 1 180 $X=278010 $Y=62080
X59489 1 2 7098 9492 IN_5VX1 $T=279000 71680 1 0 $X=278570 $Y=66560
X59490 1 2 542 9520 IN_5VX1 $T=299160 161280 1 180 $X=297050 $Y=160640
X59491 1 2 545 584 IN_5VX1 $T=300280 53760 1 180 $X=298170 $Y=53120
X59492 1 2 540 7176 IN_5VX1 $T=301400 44800 0 180 $X=299290 $Y=39680
X59493 1 2 540 7226 IN_5VX1 $T=304200 143360 1 0 $X=303770 $Y=138240
X59494 1 2 544 9539 IN_5VX1 $T=307000 161280 0 0 $X=306570 $Y=160640
X59495 1 2 550 7216 IN_5VX1 $T=312600 161280 1 0 $X=312170 $Y=156160
X59496 1 2 532 7292 IN_5VX1 $T=316520 53760 0 0 $X=316090 $Y=53120
X59497 1 2 546 7293 IN_5VX1 $T=319880 116480 1 0 $X=319450 $Y=111360
X59498 1 2 523 9558 IN_5VX1 $T=329960 35840 1 180 $X=327850 $Y=35200
X59499 1 2 545 9606 IN_5VX1 $T=364120 89600 0 180 $X=362010 $Y=84480
X59500 1 2 548 7504 IN_5VX1 $T=364680 161280 0 0 $X=364250 $Y=160640
X59501 1 2 550 7495 IN_5VX1 $T=366920 89600 1 0 $X=366490 $Y=84480
X59502 1 2 547 7526 IN_5VX1 $T=370840 134400 1 0 $X=370410 $Y=129280
X59503 1 2 540 7565 IN_5VX1 $T=384280 134400 0 0 $X=383850 $Y=133760
X59504 1 2 540 9628 IN_5VX1 $T=386520 116480 0 180 $X=384410 $Y=111360
X59505 1 2 9650 9656 IN_5VX1 $T=401640 116480 1 0 $X=401210 $Y=111360
X59506 1 2 544 7522 IN_5VX1 $T=405000 98560 0 180 $X=402890 $Y=93440
X59507 1 2 540 7606 IN_5VX1 $T=403320 179200 0 0 $X=402890 $Y=178560
X59508 1 2 9658 7597 IN_5VX1 $T=408920 44800 0 180 $X=406810 $Y=39680
X59509 1 2 546 7635 IN_5VX1 $T=408920 71680 0 180 $X=406810 $Y=66560
X59510 1 2 542 7602 IN_5VX1 $T=407800 62720 0 0 $X=407370 $Y=62080
X59511 1 2 637 7646 IN_5VX1 $T=414520 26880 1 0 $X=414090 $Y=21760
X59512 1 2 533 7659 IN_5VX1 $T=419000 53760 1 0 $X=418570 $Y=48640
X59513 1 2 7627 9676 IN_5VX1 $T=424040 26880 0 0 $X=423610 $Y=26240
X59514 1 2 7636 7643 IN_5VX1 $T=426280 80640 0 180 $X=424170 $Y=75520
X59515 1 2 644 7655 IN_5VX1 $T=427400 107520 1 180 $X=425290 $Y=106880
X59516 1 2 9683 9674 IN_5VX1 $T=427960 35840 1 180 $X=425850 $Y=35200
X59517 1 2 532 7630 IN_5VX1 $T=429640 71680 0 180 $X=427530 $Y=66560
X59518 1 2 9684 9687 IN_5VX1 $T=431320 53760 0 0 $X=430890 $Y=53120
X59519 1 2 656 7675 IN_5VX1 $T=433000 107520 1 180 $X=430890 $Y=106880
X59520 1 2 535 9894 IN_5VX1 $T=437480 26880 0 180 $X=435370 $Y=21760
X59521 1 2 528 9685 IN_5VX1 $T=437480 35840 0 180 $X=435370 $Y=30720
X59522 1 2 550 9693 IN_5VX1 $T=438040 179200 0 0 $X=437610 $Y=178560
X59523 1 2 663 7715 IN_5VX1 $T=444760 62720 0 180 $X=442650 $Y=57600
X59524 1 2 7728 9704 IN_5VX1 $T=447000 179200 0 180 $X=444890 $Y=174080
X59525 1 2 672 7784 IN_5VX1 $T=463800 71680 0 180 $X=461690 $Y=66560
X59526 1 2 676 7781 IN_5VX1 $T=468840 35840 1 180 $X=466730 $Y=35200
X59527 1 2 959 996 BU_5VX4 $T=-558200 295680 0 0 $X=-558630 $Y=295040
X59528 1 2 1185 1207 BU_5VX4 $T=-512280 17920 1 0 $X=-512710 $Y=12800
X59529 1 2 17 2038 BU_5VX4 $T=-506120 134400 0 0 $X=-506550 $Y=133760
X59530 1 2 1323 8074 BU_5VX4 $T=-491560 143360 0 0 $X=-491990 $Y=142720
X59531 1 2 8159 1659 BU_5VX4 $T=-435560 376320 1 0 $X=-435990 $Y=371200
X59532 1 2 1746 1773 BU_5VX4 $T=-426040 71680 0 0 $X=-426470 $Y=71040
X59533 1 2 1661 1846 BU_5VX4 $T=-417640 224000 1 0 $X=-418070 $Y=218880
X59534 1 2 5513 5746 BU_5VX4 $T=93080 385280 0 0 $X=92650 $Y=384640
X59535 1 2 6013 6798 BU_5VX4 $T=279560 170240 1 0 $X=279130 $Y=165120
X59536 1 2 7626 7583 BU_5VX4 $T=409480 62720 0 0 $X=409050 $Y=62080
X59537 1 2 1041 901 7970 EO2_5VX1 $T=-538600 224000 1 180 $X=-545190 $Y=223360
X59538 1 2 7987 7984 7980 EO2_5VX1 $T=-530200 179200 1 180 $X=-536790 $Y=178560
X59539 1 2 7985 7994 1057 EO2_5VX1 $T=-522920 206080 0 180 $X=-529510 $Y=200960
X59540 1 2 1082 8001 1053 EO2_5VX1 $T=-522920 224000 0 180 $X=-529510 $Y=218880
X59541 1 2 9813 1174 8020 EO2_5VX1 $T=-508360 232960 0 180 $X=-514950 $Y=227840
X59542 1 2 9919 1224 8068 EO2_5VX1 $T=-494920 250880 1 0 $X=-495350 $Y=245760
X59543 1 2 1328 1379 1288 EO2_5VX1 $T=-478680 161280 1 180 $X=-485270 $Y=160640
X59544 1 2 1212 1485 1414 EO2_5VX1 $T=-460200 259840 0 180 $X=-466790 $Y=254720
X59545 1 2 8110 1356 8106 EO2_5VX1 $T=-460200 268800 0 180 $X=-466790 $Y=263680
X59546 1 2 1554 1534 9819 EO2_5VX1 $T=-450120 268800 0 0 $X=-450550 $Y=268160
X59547 1 2 1529 1603 8144 EO2_5VX1 $T=-448440 134400 0 0 $X=-448870 $Y=133760
X59548 1 2 1539 8142 8148 EO2_5VX1 $T=-447320 116480 1 0 $X=-447750 $Y=111360
X59549 1 2 1729 1722 1662 EO2_5VX1 $T=-424360 116480 0 180 $X=-430950 $Y=111360
X59550 1 2 1774 8187 1683 EO2_5VX1 $T=-417640 89600 0 180 $X=-424230 $Y=84480
X59551 1 2 8208 1832 1775 EO2_5VX1 $T=-409800 125440 0 180 $X=-416390 $Y=120320
X59552 1 2 1418 1853 1739 EO2_5VX1 $T=-409800 215040 0 180 $X=-416390 $Y=209920
X59553 1 2 1829 1761 1791 EO2_5VX1 $T=-408120 286720 0 180 $X=-414710 $Y=281600
X59554 1 2 57 50 1915 EO2_5VX1 $T=-409800 26880 0 0 $X=-410230 $Y=26240
X59555 1 2 8223 1902 8211 EO2_5VX1 $T=-401400 134400 0 180 $X=-407990 $Y=129280
X59556 1 2 1485 8220 1972 EO2_5VX1 $T=-406440 259840 0 0 $X=-406870 $Y=259200
X59557 1 2 1436 1830 8234 EO2_5VX1 $T=-401400 286720 1 0 $X=-401830 $Y=281600
X59558 1 2 1992 1942 8227 EO2_5VX1 $T=-394680 107520 0 180 $X=-401270 $Y=102400
X59559 1 2 1719 8225 8246 EO2_5VX1 $T=-399720 268800 1 0 $X=-400150 $Y=263680
X59560 1 2 1921 8238 1999 EO2_5VX1 $T=-399160 80640 0 0 $X=-399590 $Y=80000
X59561 1 2 8234 2006 8242 EO2_5VX1 $T=-397480 277760 1 0 $X=-397910 $Y=272640
X59562 1 2 1853 1923 2032 EO2_5VX1 $T=-395800 206080 0 0 $X=-396230 $Y=205440
X59563 1 2 2014 713 1953 EO2_5VX1 $T=-389080 143360 0 180 $X=-395670 $Y=138240
X59564 1 2 8234 2028 2048 EO2_5VX1 $T=-394120 268800 0 0 $X=-394550 $Y=268160
X59565 1 2 1880 1978 2063 EO2_5VX1 $T=-392440 215040 0 0 $X=-392870 $Y=214400
X59566 1 2 2047 1935 8258 EO2_5VX1 $T=-384040 241920 1 0 $X=-384470 $Y=236800
X59567 1 2 8267 2139 8257 EO2_5VX1 $T=-376200 152320 1 180 $X=-382790 $Y=151680
X59568 1 2 2228 2076 8263 EO2_5VX1 $T=-374520 259840 1 180 $X=-381110 $Y=259200
X59569 1 2 9920 2180 2158 EO2_5VX1 $T=-378440 161280 0 0 $X=-378870 $Y=160640
X59570 1 2 2124 2195 2019 EO2_5VX1 $T=-373400 125440 1 0 $X=-373830 $Y=120320
X59571 1 2 1790 2048 2228 EO2_5VX1 $T=-370040 268800 1 0 $X=-370470 $Y=263680
X59572 1 2 8278 2238 8287 EO2_5VX1 $T=-368360 116480 1 0 $X=-368790 $Y=111360
X59573 1 2 715 2236 2246 EO2_5VX1 $T=-367800 197120 0 0 $X=-368230 $Y=196480
X59574 1 2 2228 716 2272 EO2_5VX1 $T=-367800 259840 0 0 $X=-368230 $Y=259200
X59575 1 2 2153 2272 2321 EO2_5VX1 $T=-346520 250880 1 0 $X=-346950 $Y=245760
X59576 1 2 2321 8309 2372 EO2_5VX1 $T=-344280 232960 0 0 $X=-344710 $Y=232320
X59577 1 2 2321 2350 2315 EO2_5VX1 $T=-335880 241920 0 180 $X=-342470 $Y=236800
X59578 1 2 1864 2372 8329 EO2_5VX1 $T=-335320 215040 0 0 $X=-335750 $Y=214400
X59579 1 2 8329 2363 8335 EO2_5VX1 $T=-329720 206080 0 0 $X=-330150 $Y=205440
X59580 1 2 8329 2386 2497 EO2_5VX1 $T=-328600 215040 1 0 $X=-329030 $Y=209920
X59581 1 2 2427 2497 9830 EO2_5VX1 $T=-315160 197120 1 0 $X=-315590 $Y=192000
X59582 1 2 9830 2523 2611 EO2_5VX1 $T=-309560 197120 0 0 $X=-309990 $Y=196480
X59583 1 2 9830 8350 2709 EO2_5VX1 $T=-308440 197120 1 0 $X=-308870 $Y=192000
X59584 1 2 2703 8376 8372 EO2_5VX1 $T=-296120 143360 1 180 $X=-302710 $Y=142720
X59585 1 2 2094 2709 2704 EO2_5VX1 $T=-301720 197120 1 0 $X=-302150 $Y=192000
X59586 1 2 121 2714 8375 EO2_5VX1 $T=-292760 53760 0 180 $X=-299350 $Y=48640
X59587 1 2 2723 2657 8393 EO2_5VX1 $T=-293880 313600 1 0 $X=-294310 $Y=308480
X59588 1 2 2704 8389 2756 EO2_5VX1 $T=-292200 188160 1 0 $X=-292630 $Y=183040
X59589 1 2 2748 41 2793 EO2_5VX1 $T=-289400 98560 0 0 $X=-289830 $Y=97920
X59590 1 2 2704 2662 2817 EO2_5VX1 $T=-286040 188160 0 0 $X=-286470 $Y=187520
X59591 1 2 8420 2830 2779 EO2_5VX1 $T=-276520 304640 1 180 $X=-283110 $Y=304000
X59592 1 2 8424 2790 8415 EO2_5VX1 $T=-274840 268800 1 180 $X=-281430 $Y=268160
X59593 1 2 2829 2857 2813 EO2_5VX1 $T=-269800 286720 1 180 $X=-276390 $Y=286080
X59594 1 2 8448 2878 8431 EO2_5VX1 $T=-262520 322560 1 180 $X=-269110 $Y=321920
X59595 1 2 8452 156 8468 EO2_5VX1 $T=-259720 152320 0 0 $X=-260150 $Y=151680
X59596 1 2 41 3013 3000 EO2_5VX1 $T=-258040 98560 1 0 $X=-258470 $Y=93440
X59597 1 2 2855 3013 8480 EO2_5VX1 $T=-255240 71680 0 0 $X=-255670 $Y=71040
X59598 1 2 9921 3040 8495 EO2_5VX1 $T=-247960 340480 0 0 $X=-248390 $Y=339840
X59599 1 2 3107 3092 3023 EO2_5VX1 $T=-239560 170240 0 180 $X=-246150 $Y=165120
X59600 1 2 3124 3200 8529 EO2_5VX1 $T=-232280 179200 0 0 $X=-232710 $Y=178560
X59601 1 2 3221 3255 3197 EO2_5VX1 $T=-217720 241920 1 180 $X=-224310 $Y=241280
X59602 1 2 8550 3144 3232 EO2_5VX1 $T=-214360 349440 1 180 $X=-220950 $Y=348800
X59603 1 2 8568 3332 9843 EO2_5VX1 $T=-208760 358400 0 0 $X=-209190 $Y=357760
X59604 1 2 3366 3346 2607 EO2_5VX1 $T=-204840 161280 0 0 $X=-205270 $Y=160640
X59605 1 2 3306 3361 8585 EO2_5VX1 $T=-197560 71680 0 180 $X=-204150 $Y=66560
X59606 1 2 3015 3481 3229 EO2_5VX1 $T=-190840 349440 1 180 $X=-197430 $Y=348800
X59607 1 2 3504 3597 8608 EO2_5VX1 $T=-188600 232960 1 180 $X=-195190 $Y=232320
X59608 1 2 2915 8614 2510 EO2_5VX1 $T=-193080 179200 0 0 $X=-193510 $Y=178560
X59609 1 2 3484 8624 8614 EO2_5VX1 $T=-180760 179200 1 180 $X=-187350 $Y=178560
X59610 1 2 2259 3649 3667 EO2_5VX1 $T=-179640 304640 0 0 $X=-180070 $Y=304000
X59611 1 2 3740 3509 3798 EO2_5VX1 $T=-167320 376320 1 0 $X=-167750 $Y=371200
X59612 1 2 8668 8695 8687 EO2_5VX1 $T=-154440 197120 0 180 $X=-161030 $Y=192000
X59613 1 2 3886 3869 3789 EO2_5VX1 $T=-150520 98560 0 180 $X=-157110 $Y=93440
X59614 1 2 8707 3859 3870 EO2_5VX1 $T=-146600 206080 0 180 $X=-153190 $Y=200960
X59615 1 2 3481 3837 8705 EO2_5VX1 $T=-152760 358400 1 0 $X=-153190 $Y=353280
X59616 1 2 9848 3909 8708 EO2_5VX1 $T=-140440 206080 0 180 $X=-147030 $Y=200960
X59617 1 2 3767 8718 8712 EO2_5VX1 $T=-138760 358400 1 180 $X=-145350 $Y=357760
X59618 1 2 3966 3910 8726 EO2_5VX1 $T=-143800 215040 1 0 $X=-144230 $Y=209920
X59619 1 2 3649 8723 4050 EO2_5VX1 $T=-143800 304640 0 0 $X=-144230 $Y=304000
X59620 1 2 8730 4012 3945 EO2_5VX1 $T=-136520 367360 1 180 $X=-143110 $Y=366720
X59621 1 2 3253 3996 8730 EO2_5VX1 $T=-142120 376320 0 0 $X=-142550 $Y=375680
X59622 1 2 273 271 3598 EO2_5VX1 $T=-132600 17920 0 180 $X=-139190 $Y=12800
X59623 1 2 3881 741 8765 EO2_5VX1 $T=-137640 313600 1 0 $X=-138070 $Y=308480
X59624 1 2 8730 8746 4070 EO2_5VX1 $T=-135960 367360 0 0 $X=-136390 $Y=366720
X59625 1 2 4040 4039 8736 EO2_5VX1 $T=-129240 215040 1 180 $X=-135830 $Y=214400
X59626 1 2 3716 4070 4176 EO2_5VX1 $T=-129800 358400 1 0 $X=-130230 $Y=353280
X59627 1 2 4086 8772 4101 EO2_5VX1 $T=-118600 224000 1 180 $X=-125190 $Y=223360
X59628 1 2 4223 4198 4076 EO2_5VX1 $T=-113000 125440 1 180 $X=-119590 $Y=124800
X59629 1 2 9850 4134 4322 EO2_5VX1 $T=-119160 286720 0 0 $X=-119590 $Y=286080
X59630 1 2 4203 4017 8788 EO2_5VX1 $T=-118600 340480 1 0 $X=-119030 $Y=335360
X59631 1 2 4176 4001 4331 EO2_5VX1 $T=-118600 358400 1 0 $X=-119030 $Y=353280
X59632 1 2 4187 4141 4219 EO2_5VX1 $T=-118040 224000 0 0 $X=-118470 $Y=223360
X59633 1 2 4176 4169 4232 EO2_5VX1 $T=-118040 349440 0 0 $X=-118470 $Y=348800
X59634 1 2 4335 8813 4118 EO2_5VX1 $T=-91720 143360 1 180 $X=-98310 $Y=142720
X59635 1 2 4210 4232 8827 EO2_5VX1 $T=-95640 331520 0 0 $X=-96070 $Y=330880
X59636 1 2 3839 4383 4391 EO2_5VX1 $T=-90600 304640 0 0 $X=-91030 $Y=304000
X59637 1 2 8827 8831 4383 EO2_5VX1 $T=-81640 331520 0 180 $X=-88230 $Y=326400
X59638 1 2 8827 4376 8828 EO2_5VX1 $T=-81080 331520 1 180 $X=-87670 $Y=330880
X59639 1 2 4269 4447 8843 EO2_5VX1 $T=-82760 286720 0 0 $X=-83190 $Y=286080
X59640 1 2 4521 4380 4441 EO2_5VX1 $T=-80520 259840 1 0 $X=-80950 $Y=254720
X59641 1 2 8843 4465 8832 EO2_5VX1 $T=-72680 286720 0 180 $X=-79270 $Y=281600
X59642 1 2 4391 4419 4405 EO2_5VX1 $T=-71000 304640 0 180 $X=-77590 $Y=299520
X59643 1 2 8843 8853 4508 EO2_5VX1 $T=-75480 286720 0 0 $X=-75910 $Y=286080
X59644 1 2 4422 4508 4521 EO2_5VX1 $T=-74360 259840 1 0 $X=-74790 $Y=254720
X59645 1 2 4391 8851 4447 EO2_5VX1 $T=-68200 313600 0 180 $X=-74790 $Y=308480
X59646 1 2 326 333 4550 EO2_5VX1 $T=-71000 44800 0 0 $X=-71430 $Y=44160
X59647 1 2 4521 8856 8863 EO2_5VX1 $T=-69880 241920 0 0 $X=-70310 $Y=241280
X59648 1 2 344 340 4567 EO2_5VX1 $T=-58120 17920 1 180 $X=-64710 $Y=17280
X59649 1 2 9922 4552 4612 EO2_5VX1 $T=-59800 197120 1 0 $X=-60230 $Y=192000
X59650 1 2 4539 8872 4653 EO2_5VX1 $T=-58680 107520 0 0 $X=-59110 $Y=106880
X59651 1 2 4695 4653 4167 EO2_5VX1 $T=-46920 161280 1 180 $X=-53510 $Y=160640
X59652 1 2 339 8880 4744 EO2_5VX1 $T=-50840 89600 1 0 $X=-51270 $Y=84480
X59653 1 2 4805 4783 4774 EO2_5VX1 $T=-34040 143360 1 180 $X=-40630 $Y=142720
X59654 1 2 4863 4842 4906 EO2_5VX1 $T=-33480 206080 1 0 $X=-33910 $Y=200960
X59655 1 2 4917 8926 4871 EO2_5VX1 $T=-21720 71680 1 180 $X=-28310 $Y=71040
X59656 1 2 5020 4904 4976 EO2_5VX1 $T=-21720 53760 0 0 $X=-22150 $Y=53120
X59657 1 2 4959 348 4924 EO2_5VX1 $T=-15560 125440 0 180 $X=-22150 $Y=120320
X59658 1 2 4977 4904 8942 EO2_5VX1 $T=-21160 71680 1 0 $X=-21590 $Y=66560
X59659 1 2 4970 757 8936 EO2_5VX1 $T=-13320 304640 1 180 $X=-19910 $Y=304000
X59660 1 2 5039 5007 4997 EO2_5VX1 $T=-4920 161280 0 180 $X=-11510 $Y=156160
X59661 1 2 4940 4968 5087 EO2_5VX1 $T=-8280 241920 1 0 $X=-8710 $Y=236800
X59662 1 2 5107 8999 5148 EO2_5VX1 $T=1800 286720 1 0 $X=1370 $Y=281600
X59663 1 2 5110 5130 9003 EO2_5VX1 $T=2360 313600 0 0 $X=1930 $Y=312960
X59664 1 2 5111 5142 5192 EO2_5VX1 $T=3480 322560 0 0 $X=3050 $Y=321920
X59665 1 2 5118 339 9007 EO2_5VX1 $T=4600 161280 1 0 $X=4170 $Y=156160
X59666 1 2 9002 5163 5173 EO2_5VX1 $T=7400 206080 1 0 $X=6970 $Y=200960
X59667 1 2 5155 9015 9022 EO2_5VX1 $T=8520 313600 0 0 $X=8090 $Y=312960
X59668 1 2 9923 764 9037 EO2_5VX1 $T=19720 358400 1 0 $X=19290 $Y=353280
X59669 1 2 5191 5162 9041 EO2_5VX1 $T=28120 161280 1 180 $X=21530 $Y=160640
X59670 1 2 5256 5309 5298 EO2_5VX1 $T=32040 71680 0 180 $X=25450 $Y=66560
X59671 1 2 9062 5306 5275 EO2_5VX1 $T=32040 358400 0 180 $X=25450 $Y=353280
X59672 1 2 5309 346 5230 EO2_5VX1 $T=37080 107520 1 180 $X=30490 $Y=106880
X59673 1 2 5331 5176 9059 EO2_5VX1 $T=37080 295680 1 180 $X=30490 $Y=295040
X59674 1 2 9055 5367 9066 EO2_5VX1 $T=31480 224000 0 0 $X=31050 $Y=223360
X59675 1 2 5431 5246 5494 EO2_5VX1 $T=44360 394240 1 0 $X=43930 $Y=389120
X59676 1 2 763 5712 5706 EO2_5VX1 $T=67320 394240 0 0 $X=66890 $Y=393600
X59677 1 2 9148 5698 5603 EO2_5VX1 $T=75720 385280 0 180 $X=69130 $Y=380160
X59678 1 2 5555 9148 5627 EO2_5VX1 $T=76280 358400 0 180 $X=69690 $Y=353280
X59679 1 2 5706 9161 5780 EO2_5VX1 $T=76280 394240 0 0 $X=75850 $Y=393600
X59680 1 2 5706 5705 9158 EO2_5VX1 $T=84680 394240 0 180 $X=78090 $Y=389120
X59681 1 2 5751 5774 5747 EO2_5VX1 $T=88600 376320 1 180 $X=82010 $Y=375680
X59682 1 2 5565 5780 773 EO2_5VX1 $T=89160 394240 0 0 $X=88730 $Y=393600
X59683 1 2 5951 5847 5840 EO2_5VX1 $T=99800 277760 0 180 $X=93210 $Y=272640
X59684 1 2 773 9186 776 EO2_5VX1 $T=95320 394240 1 0 $X=94890 $Y=389120
X59685 1 2 773 5851 5973 EO2_5VX1 $T=97000 385280 1 0 $X=96570 $Y=380160
X59686 1 2 459 458 6101 EO2_5VX1 $T=112680 44800 0 0 $X=112250 $Y=44160
X59687 1 2 5993 452 6095 EO2_5VX1 $T=114360 53760 0 0 $X=113930 $Y=53120
X59688 1 2 5923 6100 9238 EO2_5VX1 $T=115480 331520 1 0 $X=115050 $Y=326400
X59689 1 2 6112 780 9873 EO2_5VX1 $T=131160 358400 0 180 $X=124570 $Y=353280
X59690 1 2 6153 6224 9264 EO2_5VX1 $T=126120 277760 1 0 $X=125690 $Y=272640
X59691 1 2 6114 6090 9266 EO2_5VX1 $T=127800 385280 0 0 $X=127370 $Y=384640
X59692 1 2 6100 6105 6137 EO2_5VX1 $T=135080 367360 0 180 $X=128490 $Y=362240
X59693 1 2 6199 5889 6201 EO2_5VX1 $T=137880 80640 1 180 $X=131290 $Y=80000
X59694 1 2 9296 6237 9287 EO2_5VX1 $T=158600 161280 1 180 $X=152010 $Y=160640
X59695 1 2 6258 776 9304 EO2_5VX1 $T=155800 394240 1 0 $X=155370 $Y=389120
X59696 1 2 9304 6329 9289 EO2_5VX1 $T=162520 376320 0 180 $X=155930 $Y=371200
X59697 1 2 9304 9309 6403 EO2_5VX1 $T=162520 376320 0 0 $X=162090 $Y=375680
X59698 1 2 9308 6235 6432 EO2_5VX1 $T=163080 134400 0 0 $X=162650 $Y=133760
X59699 1 2 6048 6403 6489 EO2_5VX1 $T=168680 349440 0 0 $X=168250 $Y=348800
X59700 1 2 9312 6339 9334 EO2_5VX1 $T=169240 232960 0 0 $X=168810 $Y=232320
X59701 1 2 9323 6430 9338 EO2_5VX1 $T=171480 241920 1 0 $X=171050 $Y=236800
X59702 1 2 6489 9336 6507 EO2_5VX1 $T=175400 349440 0 0 $X=174970 $Y=348800
X59703 1 2 6489 6342 6526 EO2_5VX1 $T=178200 358400 1 0 $X=177770 $Y=353280
X59704 1 2 9339 788 9881 EO2_5VX1 $T=178760 250880 1 0 $X=178330 $Y=245760
X59705 1 2 9351 6500 6602 EO2_5VX1 $T=184920 250880 1 0 $X=184490 $Y=245760
X59706 1 2 9355 6603 6612 EO2_5VX1 $T=191080 259840 1 0 $X=190650 $Y=254720
X59707 1 2 9377 9385 9380 EO2_5VX1 $T=211800 277760 1 180 $X=205210 $Y=277120
X59708 1 2 9804 6658 6679 EO2_5VX1 $T=214040 268800 1 180 $X=207450 $Y=268160
X59709 1 2 6690 6707 6743 EO2_5VX1 $T=208440 349440 1 0 $X=208010 $Y=344320
X59710 1 2 6737 6507 6765 EO2_5VX1 $T=211240 313600 1 0 $X=210810 $Y=308480
X59711 1 2 6765 9417 9420 EO2_5VX1 $T=217400 304640 0 0 $X=216970 $Y=304000
X59712 1 2 6807 9416 9413 EO2_5VX1 $T=224120 259840 0 180 $X=217530 $Y=254720
X59713 1 2 6561 9420 6807 EO2_5VX1 $T=220760 268800 1 0 $X=220330 $Y=263680
X59714 1 2 6765 6778 6854 EO2_5VX1 $T=221320 304640 1 0 $X=220890 $Y=299520
X59715 1 2 6807 6808 6863 EO2_5VX1 $T=226920 259840 0 0 $X=226490 $Y=259200
X59716 1 2 6954 9466 9463 EO2_5VX1 $T=254360 116480 0 180 $X=247770 $Y=111360
X59717 1 2 561 545 6959 EO2_5VX1 $T=260520 26880 1 180 $X=253930 $Y=26240
X59718 1 2 563 544 7064 EO2_5VX1 $T=266680 26880 0 0 $X=266250 $Y=26240
X59719 1 2 7090 7039 7023 EO2_5VX1 $T=279000 89600 1 180 $X=272410 $Y=88960
X59720 1 2 7218 9511 7194 EO2_5VX1 $T=302520 197120 0 180 $X=295930 $Y=192000
X59721 1 2 9525 7194 7119 EO2_5VX1 $T=303640 206080 0 180 $X=297050 $Y=200960
X59722 1 2 548 9523 9531 EO2_5VX1 $T=300840 161280 0 0 $X=300410 $Y=160640
X59723 1 2 7235 7267 9547 EO2_5VX1 $T=310360 125440 1 0 $X=309930 $Y=120320
X59724 1 2 7255 7258 7217 EO2_5VX1 $T=316520 179200 1 180 $X=309930 $Y=178560
X59725 1 2 7373 7368 7359 EO2_5VX1 $T=340600 206080 1 180 $X=334010 $Y=205440
X59726 1 2 9588 7463 7342 EO2_5VX1 $T=348440 152320 1 180 $X=341850 $Y=151680
X59727 1 2 9586 9593 9595 EO2_5VX1 $T=348440 188160 0 0 $X=348010 $Y=187520
X59728 1 2 7454 7479 9601 EO2_5VX1 $T=355160 98560 0 0 $X=354730 $Y=97920
X59729 1 2 7492 7498 7451 EO2_5VX1 $T=365800 161280 0 180 $X=359210 $Y=156160
X59730 1 2 7500 9612 7489 EO2_5VX1 $T=367480 89600 1 180 $X=360890 $Y=88960
X59731 1 2 7510 540 9924 EO2_5VX1 $T=367480 179200 0 180 $X=360890 $Y=174080
X59732 1 2 7523 550 7539 EO2_5VX1 $T=369160 116480 0 0 $X=368730 $Y=115840
X59733 1 2 548 7536 7558 EO2_5VX1 $T=370840 107520 0 0 $X=370410 $Y=106880
X59734 1 2 7573 7523 7561 EO2_5VX1 $T=375880 44800 1 0 $X=375450 $Y=39680
X59735 1 2 7568 7536 7503 EO2_5VX1 $T=382600 116480 0 180 $X=376010 $Y=111360
X59736 1 2 7617 548 9636 EO2_5VX1 $T=387640 134400 0 180 $X=381050 $Y=129280
X59737 1 2 7552 9637 9627 EO2_5VX1 $T=387640 215040 0 180 $X=381050 $Y=209920
X59738 1 2 7554 7510 9647 EO2_5VX1 $T=382040 170240 0 0 $X=381610 $Y=169600
X59739 1 2 547 542 7601 EO2_5VX1 $T=401640 35840 0 0 $X=401210 $Y=35200
X59740 1 2 546 7601 7574 EO2_5VX1 $T=407800 62720 1 180 $X=401210 $Y=62080
X59741 1 2 7585 7579 634 EO2_5VX1 $T=402200 26880 1 0 $X=401770 $Y=21760
X59742 1 2 632 7601 635 EO2_5VX1 $T=403320 17920 0 0 $X=402890 $Y=17280
X59743 1 2 7995 977 1051 1060 HA_5VX1 $T=-529080 143360 0 180 $X=-538470 $Y=138240
X59744 1 2 7972 1046 1003 7987 HA_5VX1 $T=-538040 170240 1 0 $X=-538470 $Y=165120
X59745 1 2 1190 1157 7995 1095 HA_5VX1 $T=-517880 134400 1 180 $X=-527270 $Y=133760
X59746 1 2 7999 1128 1157 8015 HA_5VX1 $T=-523480 143360 0 0 $X=-523910 $Y=142720
X59747 1 2 8044 1225 8026 1199 HA_5VX1 $T=-501080 125440 0 180 $X=-510470 $Y=120320
X59748 1 2 8047 1138 1157 8038 HA_5VX1 $T=-498840 179200 1 180 $X=-508230 $Y=178560
X59749 1 2 1307 1231 1190 1259 HA_5VX1 $T=-485960 134400 0 180 $X=-495350 $Y=129280
X59750 1 2 1263 1110 1231 1329 HA_5VX1 $T=-492680 134400 0 0 $X=-493110 $Y=133760
X59751 1 2 1366 1401 1307 1306 HA_5VX1 $T=-481480 98560 0 180 $X=-490870 $Y=93440
X59752 1 2 1362 1415 27 1435 HA_5VX1 $T=-475320 26880 1 0 $X=-475750 $Y=21760
X59753 1 2 1458 1231 1384 1423 HA_5VX1 $T=-466360 152320 1 180 $X=-475750 $Y=151680
X59754 1 2 8104 28 26 1434 HA_5VX1 $T=-464120 17920 0 180 $X=-473510 $Y=12800
X59755 1 2 8095 1437 1434 1456 HA_5VX1 $T=-471960 35840 0 0 $X=-472390 $Y=35200
X59756 1 2 1261 1435 9925 1467 HA_5VX1 $T=-470280 44800 0 0 $X=-470710 $Y=44160
X59757 1 2 35 1563 1003 1444 HA_5VX1 $T=-455160 80640 1 180 $X=-464550 $Y=80000
X59758 1 2 1221 1467 9926 8116 HA_5VX1 $T=-463560 62720 1 0 $X=-463990 $Y=57600
X59759 1 2 1464 8107 1456 1518 HA_5VX1 $T=-462440 44800 1 0 $X=-462870 $Y=39680
X59760 1 2 1340 8116 1546 1537 HA_5VX1 $T=-461320 71680 1 0 $X=-461750 $Y=66560
X59761 1 2 1554 1374 1436 1503 HA_5VX1 $T=-451800 277760 0 180 $X=-461190 $Y=272640
X59762 1 2 1481 1528 1563 1539 HA_5VX1 $T=-459640 107520 1 0 $X=-460070 $Y=102400
X59763 1 2 8118 8121 1518 1752 HA_5VX1 $T=-458520 53760 0 0 $X=-458950 $Y=53120
X59764 1 2 1180 1593 1537 1621 HA_5VX1 $T=-448440 80640 0 0 $X=-448870 $Y=80000
X59765 1 2 1564 8152 1621 1844 HA_5VX1 $T=-438360 98560 1 0 $X=-438790 $Y=93440
X59766 1 2 1651 8169 1752 1742 HA_5VX1 $T=-431640 53760 0 0 $X=-432070 $Y=53120
X59767 1 2 8191 39 1661 1774 HA_5VX1 $T=-417080 80640 1 180 $X=-426470 $Y=80000
X59768 1 2 1770 1742 1819 1805 HA_5VX1 $T=-423240 71680 1 0 $X=-423670 $Y=66560
X59769 1 2 50 43 1661 53 HA_5VX1 $T=-422120 17920 0 0 $X=-422550 $Y=17280
X59770 1 2 1812 1805 8209 8205 HA_5VX1 $T=-418200 80640 1 0 $X=-418630 $Y=75520
X59771 1 2 1821 1844 1898 1869 HA_5VX1 $T=-414840 98560 0 0 $X=-415270 $Y=97920
X59772 1 2 1877 8205 8224 1921 HA_5VX1 $T=-409240 80640 1 0 $X=-409670 $Y=75520
X59773 1 2 8213 1992 1869 1942 HA_5VX1 $T=-405880 98560 0 0 $X=-406310 $Y=97920
X59774 1 2 1271 64 60 1940 HA_5VX1 $T=-396360 17920 1 180 $X=-405750 $Y=17280
X59775 1 2 1303 1940 1373 1961 HA_5VX1 $T=-394680 26880 1 180 $X=-404070 $Y=26240
X59776 1 2 2018 8240 1950 1985 HA_5VX1 $T=-391320 80640 0 180 $X=-400710 $Y=75520
X59777 1 2 1983 8241 1558 8240 HA_5VX1 $T=-389640 71680 0 180 $X=-399030 $Y=66560
X59778 1 2 2044 1985 1974 2008 HA_5VX1 $T=-388520 89600 0 180 $X=-397910 $Y=84480
X59779 1 2 1304 1961 1536 8241 HA_5VX1 $T=-387400 53760 0 180 $X=-396790 $Y=48640
X59780 1 2 9920 2094 8248 2089 HA_5VX1 $T=-380120 161280 1 180 $X=-389510 $Y=160640
X59781 1 2 2085 2008 1861 2142 HA_5VX1 $T=-373960 107520 1 180 $X=-383350 $Y=106880
X59782 1 2 2220 8274 2130 8272 HA_5VX1 $T=-369480 80640 1 180 $X=-378870 $Y=80000
X59783 1 2 1566 2142 2061 8275 HA_5VX1 $T=-377320 116480 1 0 $X=-377750 $Y=111360
X59784 1 2 2227 8275 8264 2195 HA_5VX1 $T=-367800 116480 1 180 $X=-377190 $Y=115840
X59785 1 2 1152 2128 8283 8279 HA_5VX1 $T=-374520 53760 1 0 $X=-374950 $Y=48640
X59786 1 2 1179 8279 2202 8274 HA_5VX1 $T=-365560 62720 1 180 $X=-374950 $Y=62080
X59787 1 2 1909 2206 8272 2207 HA_5VX1 $T=-365560 89600 0 180 $X=-374950 $Y=84480
X59788 1 2 2232 8282 9912 8278 HA_5VX1 $T=-365560 107520 0 180 $X=-374950 $Y=102400
X59789 1 2 2212 84 2249 2234 HA_5VX1 $T=-371160 26880 1 0 $X=-371590 $Y=21760
X59790 1 2 1281 8281 2234 8283 HA_5VX1 $T=-370600 44800 0 0 $X=-371030 $Y=44160
X59791 1 2 2218 2424 2262 2237 HA_5VX1 $T=-370600 71680 1 0 $X=-371030 $Y=66560
X59792 1 2 2269 2207 2136 1952 HA_5VX1 $T=-361640 98560 0 180 $X=-371030 $Y=93440
X59793 1 2 1891 2004 1916 8282 HA_5VX1 $T=-361640 107520 1 180 $X=-371030 $Y=106880
X59794 1 2 8317 2431 2483 2456 HA_5VX1 $T=-333640 98560 0 0 $X=-334070 $Y=97920
X59795 1 2 2261 2329 8338 2262 HA_5VX1 $T=-332520 44800 0 0 $X=-332950 $Y=44160
X59796 1 2 2417 8334 108 8338 HA_5VX1 $T=-327480 35840 0 0 $X=-327910 $Y=35200
X59797 1 2 2412 2478 2237 2483 HA_5VX1 $T=-319080 80640 1 0 $X=-319510 $Y=75520
X59798 1 2 2484 8351 2456 2581 HA_5VX1 $T=-316840 107520 0 0 $X=-317270 $Y=106880
X59799 1 2 722 2585 2640 2609 HA_5VX1 $T=-312920 134400 0 0 $X=-313350 $Y=133760
X59800 1 2 2528 2535 2581 2618 HA_5VX1 $T=-310680 125440 0 0 $X=-311110 $Y=124800
X59801 1 2 2591 2623 2609 8376 HA_5VX1 $T=-304520 143360 1 0 $X=-304950 $Y=138240
X59802 1 2 2641 2696 2618 2640 HA_5VX1 $T=-293880 134400 1 180 $X=-303270 $Y=133760
X59803 1 2 2714 2732 1661 2669 HA_5VX1 $T=-289400 62720 0 0 $X=-289830 $Y=62080
X59804 1 2 2850 2671 2743 8409 HA_5VX1 $T=-275960 241920 0 180 $X=-285350 $Y=236800
X59805 1 2 2780 2801 137 2866 HA_5VX1 $T=-284360 26880 0 0 $X=-284790 $Y=26240
X59806 1 2 2819 2825 2685 8424 HA_5VX1 $T=-279320 259840 0 0 $X=-279750 $Y=259200
X59807 1 2 2996 2977 2850 2957 HA_5VX1 $T=-254680 232960 0 180 $X=-264070 $Y=227840
X59808 1 2 3013 47 40 2961 HA_5VX1 $T=-251320 80640 0 180 $X=-260710 $Y=75520
X59809 1 2 8466 2738 2977 3045 HA_5VX1 $T=-253560 268800 0 0 $X=-253990 $Y=268160
X59810 1 2 3087 3064 8475 2995 HA_5VX1 $T=-242360 224000 1 180 $X=-251750 $Y=223360
X59811 1 2 2927 2893 2977 2999 HA_5VX1 $T=-249640 241920 0 0 $X=-250070 $Y=241280
X59812 1 2 3086 8501 8515 3123 HA_5VX1 $T=-241800 134400 0 0 $X=-242230 $Y=133760
X59813 1 2 177 3100 2425 3131 HA_5VX1 $T=-231720 71680 1 180 $X=-241110 $Y=71040
X59814 1 2 178 3154 164 8505 HA_5VX1 $T=-231720 107520 1 180 $X=-241110 $Y=106880
X59815 1 2 3106 8505 8518 3161 HA_5VX1 $T=-240680 116480 1 0 $X=-241110 $Y=111360
X59816 1 2 3168 3123 8499 3137 HA_5VX1 $T=-231720 143360 1 180 $X=-241110 $Y=142720
X59817 1 2 2744 3133 9927 3124 HA_5VX1 $T=-231720 179200 0 180 $X=-241110 $Y=174080
X59818 1 2 3157 3137 8484 3133 HA_5VX1 $T=-231160 170240 1 180 $X=-240550 $Y=169600
X59819 1 2 2280 3161 9928 8515 HA_5VX1 $T=-228920 134400 0 180 $X=-238310 $Y=129280
X59820 1 2 186 3188 3111 3048 HA_5VX1 $T=-227800 53760 0 180 $X=-237190 $Y=48640
X59821 1 2 183 3179 3131 3154 HA_5VX1 $T=-225000 98560 1 180 $X=-234390 $Y=97920
X59822 1 2 194 187 174 3210 HA_5VX1 $T=-221080 17920 0 180 $X=-230470 $Y=12800
X59823 1 2 3196 3244 2994 3260 HA_5VX1 $T=-225000 232960 0 0 $X=-225430 $Y=232320
X59824 1 2 8561 2994 2996 3190 HA_5VX1 $T=-215480 232960 0 180 $X=-224870 $Y=227840
X59825 1 2 190 3210 3296 3188 HA_5VX1 $T=-222200 35840 1 0 $X=-222630 $Y=30720
X59826 1 2 3267 2994 2266 3302 HA_5VX1 $T=-218840 250880 0 0 $X=-219270 $Y=250240
X59827 1 2 3360 3344 8561 3264 HA_5VX1 $T=-204280 206080 1 180 $X=-213670 $Y=205440
X59828 1 2 8568 732 3253 8560 HA_5VX1 $T=-209880 367360 1 0 $X=-210310 $Y=362240
X59829 1 2 3393 2092 3469 3359 HA_5VX1 $T=-202040 179200 0 0 $X=-202470 $Y=178560
X59830 1 2 8593 206 3096 8603 HA_5VX1 $T=-199240 44800 1 0 $X=-199670 $Y=39680
X59831 1 2 3469 3514 3639 8624 HA_5VX1 $T=-190840 170240 0 0 $X=-191270 $Y=169600
X59832 1 2 3326 3963 8632 3301 HA_5VX1 $T=-190840 179200 1 0 $X=-191270 $Y=174080
X59833 1 2 3240 3216 8645 3582 HA_5VX1 $T=-186360 161280 0 0 $X=-186790 $Y=160640
X59834 1 2 3638 3608 3554 3575 HA_5VX1 $T=-176840 152320 0 180 $X=-186230 $Y=147200
X59835 1 2 3690 3475 3574 3231 HA_5VX1 $T=-173480 143360 0 180 $X=-182870 $Y=138240
X59836 1 2 8632 8635 3697 3639 HA_5VX1 $T=-181880 170240 0 0 $X=-182310 $Y=169600
X59837 1 2 3689 3918 2685 8643 HA_5VX1 $T=-171800 188160 1 180 $X=-181190 $Y=187520
X59838 1 2 3574 3561 8658 8650 HA_5VX1 $T=-178520 125440 1 0 $X=-178950 $Y=120320
X59839 1 2 8645 3624 3575 3697 HA_5VX1 $T=-176840 161280 0 0 $X=-177270 $Y=160640
X59840 1 2 240 237 235 3573 HA_5VX1 $T=-166760 26880 1 180 $X=-176150 $Y=26240
X59841 1 2 8646 3711 3638 3725 HA_5VX1 $T=-174600 161280 1 0 $X=-175030 $Y=156160
X59842 1 2 8676 3603 8650 3554 HA_5VX1 $T=-165080 134400 1 180 $X=-174470 $Y=133760
X59843 1 2 8671 8666 8651 3707 HA_5VX1 $T=-164520 62720 0 180 $X=-173910 $Y=57600
X59844 1 2 8675 8669 3696 3680 HA_5VX1 $T=-163960 107520 0 180 $X=-173350 $Y=102400
X59845 1 2 3759 3737 3680 8658 HA_5VX1 $T=-163960 116480 1 180 $X=-173350 $Y=115840
X59846 1 2 3477 3710 8676 3352 HA_5VX1 $T=-172920 143360 0 0 $X=-173350 $Y=142720
X59847 1 2 8674 3707 3701 3696 HA_5VX1 $T=-162840 80640 0 180 $X=-172230 $Y=75520
X59848 1 2 8655 3724 8675 3743 HA_5VX1 $T=-171240 107520 0 0 $X=-171670 $Y=106880
X59849 1 2 3615 2498 3918 8668 HA_5VX1 $T=-171240 188160 0 0 $X=-171670 $Y=187520
X59850 1 2 8673 3736 241 8666 HA_5VX1 $T=-161720 35840 1 180 $X=-171110 $Y=35200
X59851 1 2 3681 3148 3759 3800 HA_5VX1 $T=-169000 125440 1 0 $X=-169430 $Y=120320
X59852 1 2 3754 3826 8673 3788 HA_5VX1 $T=-155000 53760 0 180 $X=-164390 $Y=48640
X59853 1 2 3852 3818 8671 3594 HA_5VX1 $T=-155000 62720 1 180 $X=-164390 $Y=62080
X59854 1 2 8700 3805 8674 3723 HA_5VX1 $T=-155000 89600 0 180 $X=-164390 $Y=84480
X59855 1 2 3869 743 4047 4026 HA_5VX1 $T=-144920 89600 0 0 $X=-145350 $Y=88960
X59856 1 2 8722 4119 4113 8734 HA_5VX1 $T=-139320 53760 1 0 $X=-139750 $Y=48640
X59857 1 2 9929 8749 8776 8758 HA_5VX1 $T=-134840 80640 1 0 $X=-135270 $Y=75520
X59858 1 2 4075 4117 8756 4002 HA_5VX1 $T=-121960 35840 1 180 $X=-131350 $Y=35200
X59859 1 2 8756 8766 9930 4119 HA_5VX1 $T=-129800 44800 0 0 $X=-130230 $Y=44160
X59860 1 2 4207 8781 4222 4148 HA_5VX1 $T=-121400 98560 1 0 $X=-121830 $Y=93440
X59861 1 2 5925 8786 4138 4179 HA_5VX1 $T=-112440 116480 0 180 $X=-121830 $Y=111360
X59862 1 2 278 8782 4264 4117 HA_5VX1 $T=-120840 26880 1 0 $X=-121270 $Y=21760
X59863 1 2 9930 4171 4215 4196 HA_5VX1 $T=-120840 44800 0 0 $X=-121270 $Y=44160
X59864 1 2 4113 4155 4220 4066 HA_5VX1 $T=-120840 71680 0 0 $X=-121270 $Y=71040
X59865 1 2 4137 4127 4221 4197 HA_5VX1 $T=-120840 89600 1 0 $X=-121270 $Y=84480
X59866 1 2 5885 4204 8777 4138 HA_5VX1 $T=-111880 107520 0 180 $X=-121270 $Y=102400
X59867 1 2 4187 745 4149 8784 HA_5VX1 $T=-111880 232960 1 180 $X=-121270 $Y=232320
X59868 1 2 295 310 312 8811 HA_5VX1 $T=-97880 17920 1 0 $X=-98310 $Y=12800
X59869 1 2 4264 4373 305 4215 HA_5VX1 $T=-88920 26880 1 180 $X=-98310 $Y=26240
X59870 1 2 4274 8811 8819 9853 HA_5VX1 $T=-97880 35840 0 0 $X=-98310 $Y=35200
X59871 1 2 4220 4320 4196 8815 HA_5VX1 $T=-97880 62720 1 0 $X=-98310 $Y=57600
X59872 1 2 4221 8808 8815 8818 HA_5VX1 $T=-97880 71680 1 0 $X=-98310 $Y=66560
X59873 1 2 4222 4316 8818 4414 HA_5VX1 $T=-97880 89600 0 0 $X=-98310 $Y=88960
X59874 1 2 4098 8812 8820 4339 HA_5VX1 $T=-97880 116480 1 0 $X=-98310 $Y=111360
X59875 1 2 4198 4339 4360 4305 HA_5VX1 $T=-97880 125440 1 0 $X=-98310 $Y=120320
X59876 1 2 4190 9853 4367 8817 HA_5VX1 $T=-96760 44800 0 0 $X=-97190 $Y=44160
X59877 1 2 8813 4357 8816 4340 HA_5VX1 $T=-96200 134400 0 0 $X=-96630 $Y=133760
X59878 1 2 4333 8817 4394 4374 HA_5VX1 $T=-92840 62720 0 0 $X=-93270 $Y=62080
X59879 1 2 8820 4382 4414 4399 HA_5VX1 $T=-88920 89600 0 0 $X=-89350 $Y=88960
X59880 1 2 8816 4389 8834 4208 HA_5VX1 $T=-87800 143360 0 0 $X=-88230 $Y=142720
X59881 1 2 4360 4386 4443 4357 HA_5VX1 $T=-85000 125440 1 0 $X=-85430 $Y=120320
X59882 1 2 8834 8839 4491 4478 HA_5VX1 $T=-79960 107520 0 0 $X=-80390 $Y=106880
X59883 1 2 4443 8838 4399 4491 HA_5VX1 $T=-79400 107520 1 0 $X=-79830 $Y=102400
X59884 1 2 4200 4493 9854 4180 HA_5VX1 $T=-78840 143360 0 0 $X=-79270 $Y=142720
X59885 1 2 4517 8837 4179 8842 HA_5VX1 $T=-69320 116480 1 180 $X=-78710 $Y=115840
X59886 1 2 4290 4374 4743 4512 HA_5VX1 $T=-75480 71680 0 0 $X=-75910 $Y=71040
X59887 1 2 9854 4478 4569 4539 HA_5VX1 $T=-72680 98560 1 0 $X=-73110 $Y=93440
X59888 1 2 9922 4501 4520 8860 HA_5VX1 $T=-60360 197120 0 180 $X=-69750 $Y=192000
X59889 1 2 4385 4512 4599 4663 HA_5VX1 $T=-68760 107520 1 0 $X=-69190 $Y=102400
X59890 1 2 333 346 339 4637 HA_5VX1 $T=-55320 53760 1 0 $X=-55750 $Y=48640
X59891 1 2 364 350 353 358 HA_5VX1 $T=-44120 26880 1 180 $X=-53510 $Y=26240
X59892 1 2 4701 4702 4654 4685 HA_5VX1 $T=-44120 224000 0 180 $X=-53510 $Y=218880
X59893 1 2 365 4707 4663 8877 HA_5VX1 $T=-43560 107520 1 180 $X=-52950 $Y=106880
X59894 1 2 4664 8877 8884 4699 HA_5VX1 $T=-52520 125440 1 0 $X=-52950 $Y=120320
X59895 1 2 340 362 326 354 HA_5VX1 $T=-49720 26880 1 0 $X=-50150 $Y=21760
X59896 1 2 4719 4699 9916 4760 HA_5VX1 $T=-44680 134400 0 0 $X=-45110 $Y=133760
X59897 1 2 8891 4721 4792 4863 HA_5VX1 $T=-44120 206080 1 0 $X=-44550 $Y=200960
X59898 1 2 4813 4760 8925 4805 HA_5VX1 $T=-32920 143360 1 0 $X=-33350 $Y=138240
X59899 1 2 4537 5036 4918 4926 HA_5VX1 $T=-13880 215040 0 180 $X=-23270 $Y=209920
X59900 1 2 8926 326 339 4912 HA_5VX1 $T=-21720 71680 0 0 $X=-22150 $Y=71040
X59901 1 2 8957 8952 9931 8941 HA_5VX1 $T=-11640 197120 0 180 $X=-21030 $Y=192000
X59902 1 2 4975 4940 4926 4968 HA_5VX1 $T=-10520 259840 0 180 $X=-19910 $Y=254720
X59903 1 2 4424 8941 4965 4974 HA_5VX1 $T=-18920 197120 0 0 $X=-19350 $Y=196480
X59904 1 2 8964 5003 8943 8952 HA_5VX1 $T=-7160 188160 1 180 $X=-16550 $Y=187520
X59905 1 2 5106 4974 5056 5036 HA_5VX1 $T=-9960 197120 0 0 $X=-10390 $Y=196480
X59906 1 2 5007 8965 8982 5053 HA_5VX1 $T=-8840 152320 0 0 $X=-9270 $Y=151680
X59907 1 2 9029 5035 5139 9002 HA_5VX1 $T=14680 197120 1 180 $X=5290 $Y=196480
X59908 1 2 5216 399 5211 5124 HA_5VX1 $T=15800 53760 1 180 $X=6410 $Y=53120
X59909 1 2 5096 4910 5204 5107 HA_5VX1 $T=7400 259840 1 0 $X=6970 $Y=254720
X59910 1 2 5244 5232 8950 5003 HA_5VX1 $T=22520 170240 1 180 $X=13130 $Y=169600
X59911 1 2 5272 5202 5186 5139 HA_5VX1 $T=22520 206080 0 180 $X=13130 $Y=200960
X59912 1 2 5145 320 351 9033 HA_5VX1 $T=14120 71680 0 0 $X=13690 $Y=71040
X59913 1 2 5261 5059 765 9030 HA_5VX1 $T=23640 241920 1 180 $X=14250 $Y=241280
X59914 1 2 5210 9034 5291 5226 HA_5VX1 $T=17480 197120 1 0 $X=17050 $Y=192000
X59915 1 2 9050 5219 5226 5186 HA_5VX1 $T=28680 197120 1 180 $X=19290 $Y=196480
X59916 1 2 9062 5182 763 9051 HA_5VX1 $T=33720 367360 1 180 $X=24330 $Y=366720
X59917 1 2 5432 9071 5268 5381 HA_5VX1 $T=43240 53760 0 180 $X=33850 $Y=48640
X59918 1 2 4559 5420 9932 5367 HA_5VX1 $T=43240 224000 0 180 $X=33850 $Y=218880
X59919 1 2 5437 9077 5374 5408 HA_5VX1 $T=43800 197120 1 180 $X=34410 $Y=196480
X59920 1 2 5447 409 5364 9071 HA_5VX1 $T=44360 26880 1 180 $X=34970 $Y=26240
X59921 1 2 9080 9074 5377 5291 HA_5VX1 $T=44360 188160 1 180 $X=34970 $Y=187520
X59922 1 2 5463 5200 5381 5405 HA_5VX1 $T=44920 80640 0 180 $X=35530 $Y=75520
X59923 1 2 5457 5436 5054 5326 HA_5VX1 $T=45480 152320 1 180 $X=36090 $Y=151680
X59924 1 2 5471 5455 5144 5229 HA_5VX1 $T=47160 107520 0 180 $X=37770 $Y=102400
X59925 1 2 5468 5417 5407 5418 HA_5VX1 $T=47720 161280 1 180 $X=38330 $Y=160640
X59926 1 2 5489 5466 5392 5428 HA_5VX1 $T=48280 80640 1 180 $X=38890 $Y=80000
X59927 1 2 5453 5472 5418 5377 HA_5VX1 $T=48840 179200 0 180 $X=39450 $Y=174080
X59928 1 2 9096 5045 5568 9081 HA_5VX1 $T=49400 250880 1 180 $X=40010 $Y=250240
X59929 1 2 9864 5406 5428 9079 HA_5VX1 $T=49960 98560 1 180 $X=40570 $Y=97920
X59930 1 2 5502 5467 5435 5407 HA_5VX1 $T=49960 143360 1 180 $X=40570 $Y=142720
X59931 1 2 5526 5408 5397 5420 HA_5VX1 $T=49960 206080 0 180 $X=40570 $Y=200960
X59932 1 2 5503 5469 5375 5444 HA_5VX1 $T=49960 241920 0 180 $X=40570 $Y=236800
X59933 1 2 5500 5280 5092 5436 HA_5VX1 $T=50520 134400 1 180 $X=41130 $Y=133760
X59934 1 2 5434 5337 9102 5392 HA_5VX1 $T=43240 53760 1 0 $X=42810 $Y=48640
X59935 1 2 5505 9092 9079 5435 HA_5VX1 $T=52200 125440 0 180 $X=42810 $Y=120320
X59936 1 2 5520 5517 5419 9077 HA_5VX1 $T=52760 197120 1 180 $X=43370 $Y=196480
X59937 1 2 9089 9100 5557 5497 HA_5VX1 $T=48280 107520 1 0 $X=47850 $Y=102400
X59938 1 2 9126 5522 415 9102 HA_5VX1 $T=57800 44800 0 180 $X=48410 $Y=39680
X59939 1 2 5556 5543 5412 9100 HA_5VX1 $T=58360 80640 1 180 $X=48970 $Y=80000
X59940 1 2 5563 5544 5497 5534 HA_5VX1 $T=58920 134400 0 180 $X=49530 $Y=129280
X59941 1 2 5507 9118 5623 5552 HA_5VX1 $T=51640 170240 0 0 $X=51210 $Y=169600
X59942 1 2 5587 5534 5479 9118 HA_5VX1 $T=61160 152320 1 180 $X=51770 $Y=151680
X59943 1 2 5588 5579 5527 5517 HA_5VX1 $T=61720 197120 1 180 $X=52330 $Y=196480
X59944 1 2 9112 5546 5568 5475 HA_5VX1 $T=53880 295680 1 0 $X=53450 $Y=290560
X59945 1 2 5343 5611 5584 5543 HA_5VX1 $T=69000 53760 0 180 $X=59610 $Y=48640
X59946 1 2 5690 5552 9130 5579 HA_5VX1 $T=72360 188160 0 180 $X=62970 $Y=183040
X59947 1 2 5710 5568 5261 5509 HA_5VX1 $T=73480 241920 0 180 $X=64090 $Y=236800
X59948 1 2 5578 426 9867 5584 HA_5VX1 $T=67880 35840 0 0 $X=67450 $Y=35200
X59949 1 2 774 4642 8842 5730 HA_5VX1 $T=81880 125440 1 180 $X=72490 $Y=124800
X59950 1 2 5859 9171 5708 5796 HA_5VX1 $T=89720 98560 1 180 $X=80330 $Y=97920
X59951 1 2 775 5804 5796 9174 HA_5VX1 $T=94760 116480 1 180 $X=85370 $Y=115840
X59952 1 2 5909 9185 9174 5865 HA_5VX1 $T=97000 125440 1 180 $X=87610 $Y=124800
X59953 1 2 9178 5661 5589 6041 HA_5VX1 $T=91960 250880 1 0 $X=91530 $Y=245760
X59954 1 2 5962 5589 5710 5900 HA_5VX1 $T=101480 232960 1 180 $X=92090 $Y=232320
X59955 1 2 5892 9190 9203 5937 HA_5VX1 $T=94200 179200 0 0 $X=93770 $Y=178560
X59956 1 2 6097 5950 5891 9192 HA_5VX1 $T=103720 152320 0 180 $X=94330 $Y=147200
X59957 1 2 5987 5824 5730 5891 HA_5VX1 $T=105960 134400 0 180 $X=96570 $Y=129280
X59958 1 2 6003 5946 9192 9203 HA_5VX1 $T=108200 170240 1 180 $X=98810 $Y=169600
X59959 1 2 6053 5976 5937 5989 HA_5VX1 $T=112120 179200 1 180 $X=102730 $Y=178560
X59960 1 2 5945 5970 5865 6027 HA_5VX1 $T=105400 134400 0 0 $X=104970 $Y=133760
X59961 1 2 9933 5589 5943 5901 HA_5VX1 $T=105960 268800 0 0 $X=105530 $Y=268160
X59962 1 2 9235 6077 5989 9226 HA_5VX1 $T=118840 188160 1 180 $X=109450 $Y=187520
X59963 1 2 9252 6075 6045 6067 HA_5VX1 $T=120520 161280 0 180 $X=111130 $Y=156160
X59964 1 2 6132 9247 6068 6098 HA_5VX1 $T=122760 179200 1 180 $X=113370 $Y=178560
X59965 1 2 9249 6096 6027 6045 HA_5VX1 $T=123320 134400 1 180 $X=113930 $Y=133760
X59966 1 2 6150 6083 6067 6068 HA_5VX1 $T=125560 161280 1 180 $X=116170 $Y=160640
X59967 1 2 6121 9250 9262 6166 HA_5VX1 $T=121080 197120 1 0 $X=120650 $Y=192000
X59968 1 2 6227 6135 5962 6190 HA_5VX1 $T=133960 224000 0 180 $X=124570 $Y=218880
X59969 1 2 6221 6120 6098 9262 HA_5VX1 $T=136760 188160 1 180 $X=127370 $Y=187520
X59970 1 2 6251 483 486 6305 HA_5VX1 $T=151880 17920 1 0 $X=151450 $Y=12800
X59971 1 2 6344 6318 9282 6277 HA_5VX1 $T=160840 35840 0 180 $X=151450 $Y=30720
X59972 1 2 7062 6289 9279 6283 HA_5VX1 $T=160840 71680 1 180 $X=151450 $Y=71040
X59973 1 2 6252 9288 6364 9293 HA_5VX1 $T=151880 89600 0 0 $X=151450 $Y=88960
X59974 1 2 6253 9270 9302 6308 HA_5VX1 $T=151880 143360 1 0 $X=151450 $Y=138240
X59975 1 2 6331 6283 6425 9288 HA_5VX1 $T=161400 80640 1 180 $X=152010 $Y=80000
X59976 1 2 6261 6039 9301 6315 HA_5VX1 $T=152440 134400 1 0 $X=152010 $Y=129280
X59977 1 2 6387 6156 6315 6296 HA_5VX1 $T=152440 134400 0 0 $X=152010 $Y=133760
X59978 1 2 6338 6330 9283 6289 HA_5VX1 $T=161960 53760 1 180 $X=152570 $Y=53120
X59979 1 2 6366 6308 9284 9296 HA_5VX1 $T=163640 152320 1 180 $X=154250 $Y=151680
X59980 1 2 6363 6348 5748 6284 HA_5VX1 $T=164200 89600 0 180 $X=154810 $Y=84480
X59981 1 2 6371 5924 6284 6324 HA_5VX1 $T=164760 98560 1 180 $X=155370 $Y=97920
X59982 1 2 6372 9305 9293 9295 HA_5VX1 $T=164760 116480 0 180 $X=155370 $Y=111360
X59983 1 2 6383 6107 6306 9301 HA_5VX1 $T=166440 116480 1 180 $X=157050 $Y=115840
X59984 1 2 6384 9273 9295 9302 HA_5VX1 $T=166440 125440 1 180 $X=157050 $Y=124800
X59985 1 2 6312 6337 6305 6374 HA_5VX1 $T=158600 26880 0 0 $X=158170 $Y=26240
X59986 1 2 6320 6277 6370 6330 HA_5VX1 $T=158600 44800 1 0 $X=158170 $Y=39680
X59987 1 2 6408 6324 6314 6306 HA_5VX1 $T=168120 107520 0 180 $X=158730 $Y=102400
X59988 1 2 5550 489 487 6318 HA_5VX1 $T=169800 17920 0 180 $X=160410 $Y=12800
X59989 1 2 9325 6296 6307 9308 HA_5VX1 $T=170360 143360 0 180 $X=160970 $Y=138240
X59990 1 2 6409 6418 6346 9312 HA_5VX1 $T=170360 232960 0 180 $X=160970 $Y=227840
X59991 1 2 9877 5980 9327 9322 HA_5VX1 $T=164760 53760 1 0 $X=164330 $Y=48640
X59992 1 2 6436 9322 5957 6348 HA_5VX1 $T=173720 71680 1 180 $X=164330 $Y=71040
X59993 1 2 9317 9320 6374 9327 HA_5VX1 $T=167560 44800 1 0 $X=167130 $Y=39680
X59994 1 2 9900 6346 5204 6429 HA_5VX1 $T=177080 215040 0 180 $X=167690 $Y=209920
X59995 1 2 9377 6561 6547 9882 HA_5VX1 $T=200040 286720 0 180 $X=190650 $Y=281600
X59996 1 2 9408 6786 527 6811 HA_5VX1 $T=218520 26880 0 0 $X=218090 $Y=26240
X59997 1 2 6775 6803 6811 6815 HA_5VX1 $T=221320 44800 0 0 $X=220890 $Y=44160
X59998 1 2 9443 6823 9457 6883 HA_5VX1 $T=233640 62720 0 0 $X=233210 $Y=62080
X59999 1 2 9459 6893 6872 6881 HA_5VX1 $T=243720 89600 0 180 $X=234330 $Y=84480
X60000 1 2 6875 6913 6815 9457 HA_5VX1 $T=247640 62720 0 180 $X=238250 $Y=57600
X60001 1 2 6845 9464 6883 9461 HA_5VX1 $T=253240 80640 0 180 $X=243850 $Y=75520
X60002 1 2 6897 6915 6881 9466 HA_5VX1 $T=247080 98560 0 0 $X=246650 $Y=97920
X60003 1 2 6910 6951 9461 6872 HA_5VX1 $T=256600 80640 1 180 $X=247210 $Y=80000
X60004 1 2 7011 9471 795 7034 HA_5VX1 $T=263320 161280 1 0 $X=262890 $Y=156160
X60005 1 2 7006 9473 9485 7044 HA_5VX1 $T=264440 179200 1 0 $X=264010 $Y=174080
X60006 1 2 7106 9474 7060 7048 HA_5VX1 $T=265000 143360 0 0 $X=264570 $Y=142720
X60007 1 2 7042 7051 9488 7073 HA_5VX1 $T=270040 80640 0 0 $X=269610 $Y=80000
X60008 1 2 7047 9481 9934 7083 HA_5VX1 $T=271160 134400 1 0 $X=270730 $Y=129280
X60009 1 2 7056 7065 7109 9488 HA_5VX1 $T=272840 71680 0 0 $X=272410 $Y=71040
X60010 1 2 9485 7075 9497 7097 HA_5VX1 $T=273400 161280 1 0 $X=272970 $Y=156160
X60011 1 2 7061 7076 9499 7069 HA_5VX1 $T=273400 188160 1 0 $X=272970 $Y=183040
X60012 1 2 9501 7105 9805 7085 HA_5VX1 $T=282920 116480 0 180 $X=273530 $Y=111360
X60013 1 2 9499 9498 7097 7084 HA_5VX1 $T=282920 179200 0 180 $X=273530 $Y=174080
X60014 1 2 7055 9486 9493 7103 HA_5VX1 $T=274520 26880 0 0 $X=274090 $Y=26240
X60015 1 2 795 7086 7122 9497 HA_5VX1 $T=275080 143360 0 0 $X=274650 $Y=142720
X60016 1 2 571 575 576 9493 HA_5VX1 $T=276200 17920 1 0 $X=275770 $Y=12800
X60017 1 2 7071 7088 7103 7109 HA_5VX1 $T=276200 35840 0 0 $X=275770 $Y=35200
X60018 1 2 7082 9490 9506 9496 HA_5VX1 $T=277320 107520 1 0 $X=276890 $Y=102400
X60019 1 2 7029 9492 7073 7090 HA_5VX1 $T=278440 89600 1 0 $X=278010 $Y=84480
X60020 1 2 7078 7111 7144 9503 HA_5VX1 $T=279560 188160 0 0 $X=279130 $Y=187520
X60021 1 2 7148 9508 7104 7121 HA_5VX1 $T=289640 71680 0 180 $X=280250 $Y=66560
X60022 1 2 9934 7117 9510 7132 HA_5VX1 $T=280680 134400 1 0 $X=280250 $Y=129280
X60023 1 2 7060 7118 7132 7122 HA_5VX1 $T=280680 143360 1 0 $X=280250 $Y=138240
X60024 1 2 9805 9504 9512 9510 HA_5VX1 $T=283480 116480 1 0 $X=283050 $Y=111360
X60025 1 2 7144 7113 7084 9507 HA_5VX1 $T=292440 188160 0 180 $X=283050 $Y=183040
X60026 1 2 9506 7149 7185 9512 HA_5VX1 $T=286280 98560 0 0 $X=285850 $Y=97920
X60027 1 2 9517 9513 9507 9511 HA_5VX1 $T=295240 197120 0 180 $X=285850 $Y=192000
X60028 1 2 9516 9515 9509 7127 HA_5VX1 $T=296360 89600 0 180 $X=286970 $Y=84480
X60029 1 2 9505 7159 9517 7173 HA_5VX1 $T=287960 206080 1 0 $X=287530 $Y=200960
X60030 1 2 7104 9521 7228 7215 HA_5VX1 $T=296360 62720 0 0 $X=295930 $Y=62080
X60031 1 2 9509 9519 7215 7185 HA_5VX1 $T=296360 89600 1 0 $X=295930 $Y=84480
X60032 1 2 7267 7216 540 9538 HA_5VX1 $T=318200 134400 0 180 $X=308810 $Y=129280
X60033 1 2 7270 536 535 7287 HA_5VX1 $T=315400 71680 0 0 $X=314970 $Y=71040
X60034 1 2 7312 533 547 7303 HA_5VX1 $T=330520 53760 1 180 $X=321130 $Y=53120
X60035 1 2 9564 9566 7374 7228 HA_5VX1 $T=330520 44800 1 0 $X=330090 $Y=39680
X60036 1 2 7380 9576 9564 9568 HA_5VX1 $T=340600 35840 1 180 $X=331210 $Y=35200
X60037 1 2 7354 7356 9935 7364 HA_5VX1 $T=333320 197120 0 0 $X=332890 $Y=196480
X60038 1 2 7263 7364 9936 7373 HA_5VX1 $T=333880 206080 1 0 $X=333450 $Y=200960
X60039 1 2 9571 9575 7397 9578 HA_5VX1 $T=336680 89600 0 0 $X=336250 $Y=88960
X60040 1 2 7315 9578 9581 7376 HA_5VX1 $T=337800 116480 1 0 $X=337370 $Y=111360
X60041 1 2 7348 7376 7405 7378 HA_5VX1 $T=337800 125440 1 0 $X=337370 $Y=120320
X60042 1 2 7370 7378 9583 7398 HA_5VX1 $T=338360 125440 0 0 $X=337930 $Y=124800
X60043 1 2 7341 7406 7450 7399 HA_5VX1 $T=339480 143360 0 0 $X=339050 $Y=142720
X60044 1 2 7365 7391 7398 7410 HA_5VX1 $T=340600 134400 1 0 $X=340170 $Y=129280
X60045 1 2 7334 7393 7424 7356 HA_5VX1 $T=340600 188160 1 0 $X=340170 $Y=183040
X60046 1 2 616 613 609 7374 HA_5VX1 $T=350120 17920 0 180 $X=340730 $Y=12800
X60047 1 2 7422 7410 7386 7406 HA_5VX1 $T=351240 143360 0 180 $X=341850 $Y=138240
X60048 1 2 7389 7396 9589 7418 HA_5VX1 $T=342840 62720 0 0 $X=342410 $Y=62080
X60049 1 2 9582 7399 9599 9588 HA_5VX1 $T=346200 152320 1 0 $X=345770 $Y=147200
X60050 1 2 7417 9587 7468 9589 HA_5VX1 $T=347880 44800 1 0 $X=347450 $Y=39680
X60051 1 2 7476 7485 7501 9593 HA_5VX1 $T=358520 188160 0 180 $X=349130 $Y=183040
X60052 1 2 7440 7418 9600 7397 HA_5VX1 $T=351800 80640 1 0 $X=351370 $Y=75520
X60053 1 2 7479 9606 540 7462 HA_5VX1 $T=361320 89600 1 180 $X=351930 $Y=88960
X60054 1 2 7402 7610 7505 7393 HA_5VX1 $T=354600 179200 0 0 $X=354170 $Y=178560
X60055 1 2 7472 9604 623 7468 HA_5VX1 $T=357400 26880 0 0 $X=356970 $Y=26240
X60056 1 2 9603 9609 9618 7501 HA_5VX1 $T=359080 188160 1 0 $X=358650 $Y=183040
X60057 1 2 7509 544 550 7560 HA_5VX1 $T=366360 143360 1 0 $X=365930 $Y=138240
X60058 1 2 9622 7514 7567 9618 HA_5VX1 $T=368040 188160 1 0 $X=367610 $Y=183040
X60059 1 2 7541 7552 7586 9637 HA_5VX1 $T=377560 206080 0 0 $X=377130 $Y=205440
X60060 1 2 9648 9641 7638 7567 HA_5VX1 $T=387640 179200 1 180 $X=378250 $Y=178560
X60061 1 2 7523 544 548 7576 HA_5VX1 $T=379240 62720 1 0 $X=378810 $Y=57600
X60062 1 2 7579 546 547 9658 HA_5VX1 $T=402200 35840 1 0 $X=401770 $Y=30720
X60063 1 2 9662 7671 9652 7586 HA_5VX1 $T=411160 206080 0 180 $X=401770 $Y=200960
X60064 1 2 7591 9655 9665 7610 HA_5VX1 $T=402760 179200 1 0 $X=402330 $Y=174080
X60065 1 2 9654 542 544 9661 HA_5VX1 $T=406680 116480 1 0 $X=406250 $Y=111360
X60066 1 2 7615 7621 9937 9665 HA_5VX1 $T=408360 161280 1 0 $X=407930 $Y=156160
X60067 1 2 9660 532 533 637 HA_5VX1 $T=411720 17920 0 0 $X=411290 $Y=17280
X60068 1 2 7661 7688 7658 7621 HA_5VX1 $T=411720 134400 0 0 $X=411290 $Y=133760
X60069 1 2 9673 7633 7631 7638 HA_5VX1 $T=422360 179200 0 180 $X=412970 $Y=174080
X60070 1 2 9663 7635 7659 641 HA_5VX1 $T=413960 53760 0 0 $X=413530 $Y=53120
X60071 1 2 9675 533 547 7636 HA_5VX1 $T=424600 89600 0 180 $X=415210 $Y=84480
X60072 1 2 9669 7712 9682 7671 HA_5VX1 $T=419000 197120 0 0 $X=418570 $Y=196480
X60073 1 2 7680 532 546 7605 HA_5VX1 $T=429640 134400 1 180 $X=420250 $Y=133760
X60074 1 2 7870 7673 7684 7658 HA_5VX1 $T=422920 116480 1 0 $X=422490 $Y=111360
X60075 1 2 7664 9677 9688 7684 HA_5VX1 $T=423480 98560 0 0 $X=423050 $Y=97920
X60076 1 2 7672 536 535 9683 HA_5VX1 $T=425720 44800 1 0 $X=425290 $Y=39680
X60077 1 2 9680 548 550 7698 HA_5VX1 $T=426280 179200 0 0 $X=425850 $Y=178560
X60078 1 2 7919 7686 7709 9688 HA_5VX1 $T=426840 89600 0 0 $X=426410 $Y=88960
X60079 1 2 7707 7702 7683 7631 HA_5VX1 $T=435800 152320 0 180 $X=426410 $Y=147200
X60080 1 2 7733 7682 7692 7683 HA_5VX1 $T=439160 134400 0 180 $X=429770 $Y=129280
X60081 1 2 7693 7704 9691 7712 HA_5VX1 $T=430760 206080 1 0 $X=430330 $Y=200960
X60082 1 2 7703 7716 7731 7686 HA_5VX1 $T=433560 62720 1 0 $X=433130 $Y=57600
X60083 1 2 7714 7736 7745 7716 HA_5VX1 $T=435240 44800 1 0 $X=434810 $Y=39680
X60084 1 2 9705 7708 7710 7692 HA_5VX1 $T=444200 107520 1 180 $X=434810 $Y=106880
X60085 1 2 7695 7726 9704 7704 HA_5VX1 $T=436920 170240 0 0 $X=436490 $Y=169600
X60086 1 2 7719 659 7744 7736 HA_5VX1 $T=438040 26880 1 0 $X=437610 $Y=21760
X60087 1 2 7729 7730 9708 7726 HA_5VX1 $T=439720 161280 1 0 $X=439290 $Y=156160
X60088 1 2 9719 9717 7772 7710 HA_5VX1 $T=454840 80640 1 180 $X=445450 $Y=80000
X60089 1 2 7787 7763 9706 7730 HA_5VX1 $T=457080 134400 1 180 $X=447690 $Y=133760
X60090 1 2 7791 7782 9722 7763 HA_5VX1 $T=462680 116480 1 180 $X=453290 $Y=115840
X60091 1 2 9735 7789 7766 7772 HA_5VX1 $T=464360 80640 1 180 $X=454970 $Y=80000
X60092 1 2 672 528 533 671 HA_5VX1 $T=464920 26880 1 0 $X=464490 $Y=21760
X60093 1 2 9748 9745 7824 7766 HA_5VX1 $T=476120 53760 1 180 $X=466730 $Y=53120
X60094 1 2 7804 7813 9746 7782 HA_5VX1 $T=467160 116480 1 0 $X=466730 $Y=111360
X60095 1 2 9763 9750 7818 7824 HA_5VX1 $T=480600 35840 1 180 $X=471210 $Y=35200
X60096 1 2 805 9747 7844 9749 HA_5VX1 $T=472760 197120 1 0 $X=472330 $Y=192000
X60097 1 2 9758 7845 7826 7813 HA_5VX1 $T=483960 89600 0 180 $X=474570 $Y=84480
X60098 1 2 7835 9752 9760 9756 HA_5VX1 $T=478360 179200 1 0 $X=477930 $Y=174080
X60099 1 2 7806 7836 9756 7844 HA_5VX1 $T=478920 188160 0 0 $X=478490 $Y=187520
X60100 1 2 7840 9754 9767 9760 HA_5VX1 $T=481160 161280 0 0 $X=480730 $Y=160640
X60101 1 2 7864 7859 9772 9767 HA_5VX1 $T=485640 143360 0 0 $X=485210 $Y=142720
X60102 1 2 9938 9770 7855 7845 HA_5VX1 $T=495160 71680 0 180 $X=485770 $Y=66560
X60103 1 2 9766 7858 7885 9772 HA_5VX1 $T=488440 134400 1 0 $X=488010 $Y=129280
X60104 1 2 7865 7877 7890 7871 HA_5VX1 $T=490680 107520 1 0 $X=490250 $Y=102400
X60105 1 2 9781 9771 7871 7872 HA_5VX1 $T=500200 116480 0 180 $X=490810 $Y=111360
X60106 1 2 9780 7891 7872 7885 HA_5VX1 $T=500200 125440 1 180 $X=490810 $Y=124800
X60107 1 2 9785 9768 684 7818 HA_5VX1 $T=503000 17920 1 180 $X=493610 $Y=17280
X60108 1 2 9783 9779 9773 7855 HA_5VX1 $T=503560 53760 0 180 $X=494170 $Y=48640
X60109 1 2 9786 689 9775 9779 HA_5VX1 $T=506360 26880 1 180 $X=496970 $Y=26240
X60110 1 2 9777 7888 9787 7890 HA_5VX1 $T=499640 98560 0 0 $X=499210 $Y=97920
X60111 1 2 1049 1084 BU_5VX8 $T=-539160 44800 0 0 $X=-539590 $Y=44160
X60112 1 2 1790 1491 1817 1808 EO3_5VX1 $T=-406440 259840 1 180 $X=-419190 $Y=259200
X60113 1 2 1815 1661 712 8222 EO3_5VX1 $T=-414280 53760 0 0 $X=-414710 $Y=53120
X60114 1 2 1751 1878 61 1898 EO3_5VX1 $T=-413160 107520 1 0 $X=-413590 $Y=102400
X60115 1 2 58 40 712 8230 EO3_5VX1 $T=-410920 35840 0 0 $X=-411350 $Y=35200
X60116 1 2 1864 1514 1934 8226 EO3_5VX1 $T=-409800 206080 0 0 $X=-410230 $Y=205440
X60117 1 2 8216 8222 1890 8238 EO3_5VX1 $T=-407560 62720 0 0 $X=-407990 $Y=62080
X60118 1 2 2013 1999 2057 2124 EO3_5VX1 $T=-392440 116480 0 0 $X=-392870 $Y=115840
X60119 1 2 70 61 8256 2138 EO3_5VX1 $T=-391320 98560 0 0 $X=-391750 $Y=97920
X60120 1 2 2617 2660 8380 2703 EO3_5VX1 $T=-306760 116480 1 0 $X=-307190 $Y=111360
X60121 1 2 8138 8372 2642 2726 EO3_5VX1 $T=-304520 170240 1 0 $X=-304950 $Y=165120
X60122 1 2 132 139 138 2920 EO3_5VX1 $T=-259160 17920 0 180 $X=-271910 $Y=12800
X60123 1 2 77 154 157 8479 EO3_5VX1 $T=-259160 17920 1 0 $X=-259590 $Y=12800
X60124 1 2 8503 8511 733 3204 EO3_5VX1 $T=-238440 170240 1 0 $X=-238870 $Y=165120
X60125 1 2 3152 199 3304 3096 EO3_5VX1 $T=-217720 44800 0 0 $X=-218150 $Y=44160
X60126 1 2 47 41 3375 8590 EO3_5VX1 $T=-212120 98560 0 0 $X=-212550 $Y=97920
X60127 1 2 9841 8586 3478 3484 EO3_5VX1 $T=-203160 170240 0 0 $X=-203590 $Y=169600
X60128 1 2 40 3425 39 3565 EO3_5VX1 $T=-200360 44800 0 0 $X=-200790 $Y=44160
X60129 1 2 3445 39 17 3538 EO3_5VX1 $T=-197000 80640 0 0 $X=-197430 $Y=80000
X60130 1 2 224 43 1661 220 EO3_5VX1 $T=-182440 17920 0 180 $X=-195190 $Y=12800
X60131 1 2 3377 3403 3682 3604 EO3_5VX1 $T=-191400 188160 1 0 $X=-191830 $Y=183040
X60132 1 2 3524 3565 3621 3637 EO3_5VX1 $T=-187480 44800 0 0 $X=-187910 $Y=44160
X60133 1 2 3716 3206 3695 8672 EO3_5VX1 $T=-152760 349440 1 180 $X=-165510 $Y=348800
X60134 1 2 3947 3927 3856 3286 EO3_5VX1 $T=-144360 44800 1 180 $X=-157110 $Y=44160
X60135 1 2 3839 3746 3875 3865 EO3_5VX1 $T=-142120 304640 0 180 $X=-154870 $Y=299520
X60136 1 2 3965 3953 3922 3768 EO3_5VX1 $T=-139320 125440 0 180 $X=-152070 $Y=120320
X60137 1 2 3981 3990 3971 3645 EO3_5VX1 $T=-137640 71680 0 180 $X=-150390 $Y=66560
X60138 1 2 4007 3997 3939 3808 EO3_5VX1 $T=-137080 116480 0 180 $X=-149830 $Y=111360
X60139 1 2 2804 3954 8725 4027 EO3_5VX1 $T=-148280 161280 0 0 $X=-148710 $Y=160640
X60140 1 2 4024 3757 265 3311 EO3_5VX1 $T=-135400 35840 0 180 $X=-148150 $Y=30720
X60141 1 2 3992 4008 3957 3810 EO3_5VX1 $T=-135400 143360 0 180 $X=-148150 $Y=138240
X60142 1 2 8740 4021 3942 3908 EO3_5VX1 $T=-133720 152320 1 180 $X=-146470 $Y=151680
X60143 1 2 4093 4027 8738 4009 EO3_5VX1 $T=-127000 161280 0 180 $X=-139750 $Y=156160
X60144 1 2 4166 4148 4098 4072 EO3_5VX1 $T=-118600 116480 1 180 $X=-131350 $Y=115840
X60145 1 2 4180 4167 4114 3954 EO3_5VX1 $T=-116920 152320 0 180 $X=-129670 $Y=147200
X60146 1 2 4295 4326 4369 4377 EO3_5VX1 $T=-97880 152320 1 0 $X=-98310 $Y=147200
X60147 1 2 4199 4208 4200 4077 EO3_5VX1 $T=-85560 161280 0 180 $X=-98310 $Y=156160
X60148 1 2 4400 4483 4469 761 EO3_5VX1 $T=-85000 116480 1 0 $X=-85430 $Y=111360
X60149 1 2 4428 4451 4488 4518 EO3_5VX1 $T=-81080 161280 0 0 $X=-81510 $Y=160640
X60150 1 2 4416 4458 4479 4519 EO3_5VX1 $T=-81080 170240 1 0 $X=-81510 $Y=165120
X60151 1 2 4480 4505 4476 4572 EO3_5VX1 $T=-75480 206080 1 0 $X=-75910 $Y=200960
X60152 1 2 4470 4087 4449 4583 EO3_5VX1 $T=-73800 197120 0 0 $X=-74230 $Y=196480
X60153 1 2 4494 4519 4551 4824 EO3_5VX1 $T=-72680 179200 1 0 $X=-73110 $Y=174080
X60154 1 2 337 4540 4507 4483 EO3_5VX1 $T=-58680 107520 1 180 $X=-71430 $Y=106880
X60155 1 2 4502 4518 4564 4611 EO3_5VX1 $T=-71000 170240 0 0 $X=-71430 $Y=169600
X60156 1 2 346 349 339 4560 EO3_5VX1 $T=-53080 35840 1 180 $X=-65830 $Y=35200
X60157 1 2 4616 4662 4591 4569 EO3_5VX1 $T=-50840 89600 1 180 $X=-63590 $Y=88960
X60158 1 2 4584 4578 4613 4654 EO3_5VX1 $T=-61480 206080 0 0 $X=-61910 $Y=205440
X60159 1 2 4693 4605 4504 4623 EO3_5VX1 $T=-46920 179200 0 180 $X=-59670 $Y=174080
X60160 1 2 4623 4644 4666 4740 EO3_5VX1 $T=-58680 188160 1 0 $X=-59110 $Y=183040
X60161 1 2 4636 4583 4606 4721 EO3_5VX1 $T=-56440 206080 1 0 $X=-56870 $Y=200960
X60162 1 2 4401 4612 4638 4751 EO3_5VX1 $T=-54760 197120 0 0 $X=-55190 $Y=196480
X60163 1 2 8888 8889 8875 8872 EO3_5VX1 $T=-41880 98560 1 180 $X=-54630 $Y=97920
X60164 1 2 4775 4460 4700 4694 EO3_5VX1 $T=-36840 206080 1 180 $X=-49590 $Y=205440
X60165 1 2 4673 4572 4633 4792 EO3_5VX1 $T=-48040 215040 1 0 $X=-48470 $Y=209920
X60166 1 2 8896 4776 4702 4854 EO3_5VX1 $T=-40760 215040 0 0 $X=-41190 $Y=214400
X60167 1 2 4377 4549 4533 4563 EO3_5VX1 $T=-27880 161280 0 180 $X=-40630 $Y=156160
X60168 1 2 4958 8951 8933 4783 EO3_5VX1 $T=-11640 134400 1 180 $X=-24390 $Y=133760
X60169 1 2 4990 326 348 8932 EO3_5VX1 $T=-10520 62720 1 180 $X=-23270 $Y=62080
X60170 1 2 8928 4855 4854 4918 EO3_5VX1 $T=-22280 224000 1 0 $X=-22710 $Y=218880
X60171 1 2 4973 362 5024 5073 EO3_5VX1 $T=-13320 170240 1 0 $X=-13750 $Y=165120
X60172 1 2 4996 339 348 5052 EO3_5VX1 $T=-12200 80640 0 0 $X=-12630 $Y=80000
X60173 1 2 4992 4983 8980 5163 EO3_5VX1 $T=-11640 197120 1 0 $X=-12070 $Y=192000
X60174 1 2 9017 359 362 5288 EO3_5VX1 $T=11880 98560 0 0 $X=11450 $Y=97920
X60175 1 2 5220 5173 5304 9055 EO3_5VX1 $T=19160 224000 0 0 $X=18730 $Y=223360
X60176 1 2 5565 5235 5515 5488 EO3_5VX1 $T=59480 376320 1 180 $X=46730 $Y=375680
X60177 1 2 5656 5673 5618 4562 EO3_5VX1 $T=72920 98560 0 180 $X=60170 $Y=93440
X60178 1 2 5750 5760 9153 5678 EO3_5VX1 $T=81880 197120 1 180 $X=69130 $Y=196480
X60179 1 2 430 5707 9154 4532 EO3_5VX1 $T=82440 62720 1 180 $X=69690 $Y=62080
X60180 1 2 436 434 435 4615 EO3_5VX1 $T=94200 35840 0 180 $X=81450 $Y=30720
X60181 1 2 6048 6009 9234 6082 EO3_5VX1 $T=126680 367360 0 180 $X=113930 $Y=362240
X60182 1 2 6155 6188 6193 6235 EO3_5VX1 $T=124440 116480 0 0 $X=124010 $Y=115840
X60183 1 2 348 4739 6165 6237 EO3_5VX1 $T=125560 161280 1 0 $X=125130 $Y=156160
X60184 1 2 6437 6432 6480 9343 EO3_5VX1 $T=172040 179200 1 0 $X=171610 $Y=174080
X60185 1 2 6846 6513 6755 6741 EO3_5VX1 $T=224680 206080 1 180 $X=211930 $Y=205440
X60186 1 2 9939 6741 6759 9437 EO3_5VX1 $T=213480 197120 0 0 $X=213050 $Y=196480
X60187 1 2 9887 9463 6907 6905 EO3_5VX1 $T=254360 134400 1 180 $X=241610 $Y=133760
X60188 1 2 550 6940 540 9458 EO3_5VX1 $T=254920 53760 1 180 $X=242170 $Y=53120
X60189 1 2 6933 6996 9888 6954 EO3_5VX1 $T=265560 71680 0 180 $X=252810 $Y=66560
X60190 1 2 7173 7119 7079 7007 EO3_5VX1 $T=285720 206080 0 180 $X=272970 $Y=200960
X60191 1 2 7099 540 7141 7027 EO3_5VX1 $T=296360 62720 1 180 $X=283610 $Y=62080
X60192 1 2 540 7258 7231 7218 EO3_5VX1 $T=317640 188160 0 180 $X=304890 $Y=183040
X60193 1 2 596 533 547 9537 EO3_5VX1 $T=322120 17920 1 180 $X=309370 $Y=17280
X60194 1 2 7459 9595 7412 7368 EO3_5VX1 $T=355160 206080 1 180 $X=342410 $Y=205440
X60195 1 2 9924 9602 9591 9586 EO3_5VX1 $T=361320 179200 0 180 $X=348570 $Y=174080
X60196 1 2 9615 7484 9605 7463 EO3_5VX1 $T=368600 116480 1 180 $X=355850 $Y=115840
X60197 1 2 7483 550 545 7534 EO3_5VX1 $T=357960 71680 1 0 $X=357530 $Y=66560
X60198 1 2 7519 550 545 9625 EO3_5VX1 $T=359080 53760 1 0 $X=358650 $Y=48640
X60199 1 2 7544 548 550 9643 EO3_5VX1 $T=375320 53760 1 0 $X=374890 $Y=48640
X60200 1 2 7627 7602 7522 9940 EO3_5VX1 $T=413960 80640 1 180 $X=401210 $Y=80000
X60201 1 2 7600 7624 540 9652 EO3_5VX1 $T=415080 197120 0 180 $X=402330 $Y=192000
X60202 1 2 544 7609 550 9671 EO3_5VX1 $T=403880 125440 1 0 $X=403450 $Y=120320
X60203 1 2 7598 544 548 7654 EO3_5VX1 $T=408360 89600 0 0 $X=407930 $Y=88960
X60204 1 2 7605 548 545 7665 EO3_5VX1 $T=411160 152320 0 0 $X=410730 $Y=151680
X60205 1 2 532 648 7672 7663 EO3_5VX1 $T=436920 53760 0 180 $X=424170 $Y=48640
X60206 1 2 528 652 649 7572 EO3_5VX1 $T=439720 26880 1 180 $X=426970 $Y=26240
X60207 1 2 668 528 533 9733 EO3_5VX1 $T=477240 17920 1 180 $X=464490 $Y=17280
X60208 1 2 933 7963 977 1004 986 FA_5VX1 $T=-562120 179200 0 0 $X=-562550 $Y=178560
X60209 1 2 7973 986 7958 7955 972 FA_5VX1 $T=-543080 188160 1 180 $X=-560310 $Y=187520
X60210 1 2 7955 1016 1041 977 975 FA_5VX1 $T=-556520 197120 1 0 $X=-556950 $Y=192000
X60211 1 2 993 7970 973 1004 7967 FA_5VX1 $T=-556520 215040 1 0 $X=-556950 $Y=209920
X60212 1 2 978 7974 1016 7983 1017 FA_5VX1 $T=-552600 232960 1 0 $X=-553030 $Y=227840
X60213 1 2 1087 1052 7972 7971 1040 FA_5VX1 $T=-527400 161280 1 180 $X=-544630 $Y=160640
X60214 1 2 1099 1060 1004 1010 1052 FA_5VX1 $T=-526840 161280 0 180 $X=-544070 $Y=156160
X60215 1 2 8006 1044 7980 1040 1069 FA_5VX1 $T=-522920 179200 0 180 $X=-540150 $Y=174080
X60216 1 2 1103 7998 1053 7981 7993 FA_5VX1 $T=-521800 215040 1 180 $X=-539030 $Y=214400
X60217 1 2 8008 1069 1057 1037 7998 FA_5VX1 $T=-519000 197120 1 180 $X=-536230 $Y=196480
X60218 1 2 1166 8010 7996 1087 1115 FA_5VX1 $T=-513960 152320 0 180 $X=-531190 $Y=147200
X60219 1 2 8026 1099 7999 1095 8010 FA_5VX1 $T=-512280 143360 0 180 $X=-529510 $Y=138240
X60220 1 2 1093 7993 8020 8024 1137 FA_5VX1 $T=-529080 224000 0 0 $X=-529510 $Y=223360
X60221 1 2 7996 8015 1168 1128 8012 FA_5VX1 $T=-528520 152320 0 0 $X=-528950 $Y=151680
X60222 1 2 1149 1116 973 1184 1146 FA_5VX1 $T=-527960 241920 1 0 $X=-528390 $Y=236800
X60223 1 2 1194 8019 1107 1103 1136 FA_5VX1 $T=-510600 197120 0 180 $X=-527830 $Y=192000
X60224 1 2 8034 8006 8002 1115 1140 FA_5VX1 $T=-510040 170240 0 180 $X=-527270 $Y=165120
X60225 1 2 8002 8012 1145 1168 8018 FA_5VX1 $T=-525160 161280 0 0 $X=-525590 $Y=160640
X60226 1 2 1218 1140 8011 8008 8019 FA_5VX1 $T=-505560 179200 0 180 $X=-522790 $Y=174080
X60227 1 2 1129 8030 1169 1213 1172 FA_5VX1 $T=-522360 206080 1 0 $X=-522790 $Y=200960
X60228 1 2 8039 1212 1138 1128 1169 FA_5VX1 $T=-503880 188160 1 180 $X=-521110 $Y=187520
X60229 1 2 1107 8033 8038 8039 8030 FA_5VX1 $T=-519560 188160 1 0 $X=-519990 $Y=183040
X60230 1 2 8011 8018 1145 8047 8033 FA_5VX1 $T=-519000 170240 0 0 $X=-519430 $Y=169600
X60231 1 2 8049 1136 1129 1093 1275 FA_5VX1 $T=-502200 197120 1 180 $X=-519430 $Y=196480
X60232 1 2 1213 1168 1160 1212 1196 FA_5VX1 $T=-518440 215040 1 0 $X=-518870 $Y=209920
X60233 1 2 1269 1226 8027 1218 1211 FA_5VX1 $T=-497160 152320 0 180 $X=-514390 $Y=147200
X60234 1 2 8057 8034 1181 1236 1226 FA_5VX1 $T=-496600 134400 0 180 $X=-513830 $Y=129280
X60235 1 2 1188 1247 901 1265 1228 FA_5VX1 $T=-513400 259840 1 0 $X=-513830 $Y=254720
X60236 1 2 1182 1240 1225 1204 8041 FA_5VX1 $T=-512280 143360 1 0 $X=-512710 $Y=138240
X60237 1 2 1322 1166 1204 1199 1236 FA_5VX1 $T=-492680 125440 1 180 $X=-509910 $Y=124800
X60238 1 2 1309 1211 1195 1194 1241 FA_5VX1 $T=-492120 170240 0 180 $X=-509350 $Y=165120
X60239 1 2 9910 8041 8060 1273 1256 FA_5VX1 $T=-508360 143360 0 0 $X=-508790 $Y=142720
X60240 1 2 1214 1145 1289 1160 1257 FA_5VX1 $T=-508360 224000 0 0 $X=-508790 $Y=223360
X60241 1 2 1205 1288 1302 1204 8055 FA_5VX1 $T=-506680 161280 0 0 $X=-507110 $Y=160640
X60242 1 2 1232 1137 8068 1249 1286 FA_5VX1 $T=-503880 241920 0 0 $X=-504310 $Y=241280
X60243 1 2 1300 8071 930 8040 1276 FA_5VX1 $T=-487080 268800 1 180 $X=-504310 $Y=268160
X60244 1 2 1260 1172 1196 1214 1284 FA_5VX1 $T=-486520 224000 0 180 $X=-503750 $Y=218880
X60245 1 2 1324 1275 1260 1232 1292 FA_5VX1 $T=-483720 215040 1 180 $X=-500950 $Y=214400
X60246 1 2 8077 8044 1263 1259 8061 FA_5VX1 $T=-483160 125440 0 180 $X=-500390 $Y=120320
X60247 1 2 8083 1241 1227 8049 1310 FA_5VX1 $T=-482040 179200 1 180 $X=-499270 $Y=178560
X60248 1 2 1273 1270 1328 1225 1308 FA_5VX1 $T=-497160 152320 1 0 $X=-497590 $Y=147200
X60249 1 2 1395 8077 1315 1306 1336 FA_5VX1 $T=-475880 98560 1 180 $X=-493110 $Y=97920
X60250 1 2 1245 8080 1270 8065 1347 FA_5VX1 $T=-474760 170240 1 180 $X=-491990 $Y=169600
X60251 1 2 1427 1286 8072 8070 1355 FA_5VX1 $T=-473640 259840 0 180 $X=-490870 $Y=254720
X60252 1 2 1375 8075 1325 1089 1356 FA_5VX1 $T=-473640 268800 0 180 $X=-490870 $Y=263680
X60253 1 2 1420 1310 1331 1324 1367 FA_5VX1 $T=-472520 197120 0 180 $X=-489750 $Y=192000
X60254 1 2 9795 8078 1409 1414 1382 FA_5VX1 $T=-488760 250880 1 0 $X=-489190 $Y=245760
X60255 1 2 1399 1322 1337 8061 1371 FA_5VX1 $T=-471400 125440 1 180 $X=-488630 $Y=124800
X60256 1 2 1425 1284 1257 1333 8078 FA_5VX1 $T=-471400 241920 0 180 $X=-488630 $Y=236800
X60257 1 2 1445 1399 1342 1336 1451 FA_5VX1 $T=-470280 107520 1 180 $X=-487510 $Y=106880
X60258 1 2 1457 8057 9816 1371 8084 FA_5VX1 $T=-469160 134400 0 180 $X=-486390 $Y=129280
X60259 1 2 1389 8090 1401 1315 1402 FA_5VX1 $T=-484840 116480 1 0 $X=-485270 $Y=111360
X60260 1 2 1442 8084 1357 1269 1412 FA_5VX1 $T=-468040 143360 1 180 $X=-485270 $Y=142720
X60261 1 2 1337 1329 1200 1110 1396 FA_5VX1 $T=-483160 134400 0 0 $X=-483590 $Y=133760
X60262 1 2 9816 1396 1448 1200 8092 FA_5VX1 $T=-483160 143360 1 0 $X=-483590 $Y=138240
X60263 1 2 1372 1292 1425 1427 1413 FA_5VX1 $T=-482600 232960 0 0 $X=-483030 $Y=232320
X60264 1 2 1373 24 1455 8104 1429 FA_5VX1 $T=-480920 26880 0 0 $X=-481350 $Y=26240
X60265 1 2 1506 8098 8086 8083 1424 FA_5VX1 $T=-463000 170240 0 180 $X=-480230 $Y=165120
X60266 1 2 1385 1355 8106 1463 1533 FA_5VX1 $T=-479800 259840 0 0 $X=-480230 $Y=259200
X60267 1 2 1357 8092 1448 1458 8096 FA_5VX1 $T=-479240 152320 1 0 $X=-479670 $Y=147200
X60268 1 2 1484 1367 8088 1372 1432 FA_5VX1 $T=-462440 206080 1 180 $X=-479670 $Y=205440
X60269 1 2 1478 1412 8085 1309 8098 FA_5VX1 $T=-461880 161280 0 180 $X=-479110 $Y=156160
X60270 1 2 8085 8096 1423 8114 1430 FA_5VX1 $T=-478120 161280 0 0 $X=-478550 $Y=160640
X60271 1 2 8086 1430 1453 1483 1446 FA_5VX1 $T=-478120 179200 0 0 $X=-478550 $Y=178560
X60272 1 2 1468 1402 1417 1407 1452 FA_5VX1 $T=-457960 116480 1 180 $X=-475190 $Y=115840
X60273 1 2 8114 1418 1110 1384 1453 FA_5VX1 $T=-457960 170240 1 180 $X=-475190 $Y=169600
X60274 1 2 1483 1200 1419 1418 1611 FA_5VX1 $T=-457960 188160 0 180 $X=-475190 $Y=183040
X60275 1 2 8093 1492 1167 1509 1504 FA_5VX1 $T=-474200 286720 1 0 $X=-474630 $Y=281600
X60276 1 2 1380 8109 1302 1443 1462 FA_5VX1 $T=-473640 188160 0 0 $X=-474070 $Y=187520
X60277 1 2 1536 1429 25 8095 1471 FA_5VX1 $T=-455160 53760 0 180 $X=-472390 $Y=48640
X60278 1 2 8122 1413 9795 1385 1469 FA_5VX1 $T=-455160 250880 0 180 $X=-472390 $Y=245760
X60279 1 2 1333 1289 1138 1491 1409 FA_5VX1 $T=-471400 241920 0 0 $X=-471830 $Y=241280
X60280 1 2 1407 1513 1529 1401 1555 FA_5VX1 $T=-470280 125440 0 0 $X=-470710 $Y=124800
X60281 1 2 1487 1366 1441 1444 1472 FA_5VX1 $T=-452920 89600 1 180 $X=-470150 $Y=88960
X60282 1 2 1565 1457 8103 1451 8113 FA_5VX1 $T=-451800 107520 1 180 $X=-469030 $Y=106880
X60283 1 2 1558 1471 1460 1464 1505 FA_5VX1 $T=-450120 62720 1 180 $X=-467350 $Y=62080
X60284 1 2 37 1395 1500 1472 1475 FA_5VX1 $T=-449000 98560 0 180 $X=-466230 $Y=93440
X60285 1 2 36 1445 1481 1475 1512 FA_5VX1 $T=-447880 98560 1 180 $X=-465110 $Y=97920
X60286 1 2 1587 8113 1488 1442 1519 FA_5VX1 $T=-447320 116480 0 180 $X=-464550 $Y=111360
X60287 1 2 1421 1567 1379 8137 1515 FA_5VX1 $T=-462440 206080 0 0 $X=-462870 $Y=205440
X60288 1 2 8111 8134 1571 708 1559 FA_5VX1 $T=-460760 197120 0 0 $X=-461190 $Y=196480
X60289 1 2 1622 1424 8119 1420 8126 FA_5VX1 $T=-442280 179200 0 180 $X=-459510 $Y=174080
X60290 1 2 1950 1505 34 8118 8128 FA_5VX1 $T=-441720 71680 1 180 $X=-458950 $Y=71040
X60291 1 2 708 1608 1384 1514 1732 FA_5VX1 $T=-441720 206080 0 180 $X=-458950 $Y=200960
X60292 1 2 8119 1446 1611 1620 8134 FA_5VX1 $T=-457960 188160 1 0 $X=-458390 $Y=183040
X60293 1 2 1526 1533 9819 1597 1578 FA_5VX1 $T=-457960 268800 1 0 $X=-458390 $Y=263680
X60294 1 2 1616 1432 1532 8122 1561 FA_5VX1 $T=-440600 224000 0 180 $X=-457830 $Y=218880
X60295 1 2 1521 1761 1229 1617 1588 FA_5VX1 $T=-456840 295680 1 0 $X=-457270 $Y=290560
X60296 1 2 1620 1448 1608 1419 1571 FA_5VX1 $T=-439480 188160 1 180 $X=-456710 $Y=187520
X60297 1 2 1627 8126 8111 1484 1572 FA_5VX1 $T=-439480 197120 0 180 $X=-456710 $Y=192000
X60298 1 2 1530 8144 1626 1315 1630 FA_5VX1 $T=-455720 134400 1 0 $X=-456150 $Y=129280
X60299 1 2 1974 8128 1262 1651 1607 FA_5VX1 $T=-454040 89600 1 0 $X=-454470 $Y=84480
X60300 1 2 8108 1780 1650 42 1562 FA_5VX1 $T=-452920 17920 1 0 $X=-453350 $Y=12800
X60301 1 2 1540 1624 44 1605 1584 FA_5VX1 $T=-452920 17920 0 0 $X=-453350 $Y=17280
X60302 1 2 1673 8150 1513 8129 1678 FA_5VX1 $T=-435560 143360 1 180 $X=-452790 $Y=142720
X60303 1 2 1569 1382 1649 8164 8146 FA_5VX1 $T=-450120 259840 1 0 $X=-450550 $Y=254720
X60304 1 2 1527 1661 8161 8158 1602 FA_5VX1 $T=-449000 53760 0 0 $X=-449430 $Y=53120
X60305 1 2 1531 1671 1431 1646 1635 FA_5VX1 $T=-448440 215040 0 0 $X=-448870 $Y=214400
X60306 1 2 1653 1469 1569 1526 8172 FA_5VX1 $T=-431080 250880 1 180 $X=-448310 $Y=250240
X60307 1 2 1499 39 8165 1687 1570 FA_5VX1 $T=-446760 44800 0 0 $X=-447190 $Y=44160
X60308 1 2 1605 1702 45 17 1720 FA_5VX1 $T=-444520 26880 1 0 $X=-444950 $Y=21760
X60309 1 2 1551 8160 1633 1720 1595 FA_5VX1 $T=-443960 26880 0 0 $X=-444390 $Y=26240
X60310 1 2 46 1565 8148 1512 8151 FA_5VX1 $T=-427160 107520 0 180 $X=-444390 $Y=102400
X60311 1 2 1731 1572 9820 1616 8154 FA_5VX1 $T=-427160 197120 1 180 $X=-444390 $Y=196480
X60312 1 2 1733 1578 8149 8145 1666 FA_5VX1 $T=-427160 268800 1 180 $X=-444390 $Y=268160
X60313 1 2 1632 1543 8170 1588 1681 FA_5VX1 $T=-443960 286720 0 0 $X=-444390 $Y=286080
X60314 1 2 1667 1498 1325 8147 1767 FA_5VX1 $T=-425480 277760 1 180 $X=-442710 $Y=277120
X60315 1 2 9820 1559 1732 1739 8163 FA_5VX1 $T=-441720 206080 1 0 $X=-442150 $Y=200960
X60316 1 2 1633 1661 39 48 8168 FA_5VX1 $T=-440040 35840 0 0 $X=-440470 $Y=35200
X60317 1 2 1575 17 8180 8182 1613 FA_5VX1 $T=-440040 71680 1 0 $X=-440470 $Y=66560
X60318 1 2 1267 1587 1662 8151 1706 FA_5VX1 $T=-422120 107520 1 180 $X=-439350 $Y=106880
X60319 1 2 8184 1519 1663 1478 8166 FA_5VX1 $T=-422120 134400 0 180 $X=-439350 $Y=129280
X60320 1 2 1718 8173 1626 1652 8167 FA_5VX1 $T=-422120 152320 0 180 $X=-439350 $Y=147200
X60321 1 2 1745 1561 1665 1653 1703 FA_5VX1 $T=-422120 232960 1 180 $X=-439350 $Y=232320
X60322 1 2 1576 1763 9823 8191 1676 FA_5VX1 $T=-435000 80640 1 0 $X=-435430 $Y=75520
X60323 1 2 1803 8166 1689 1506 1725 FA_5VX1 $T=-418200 134400 1 180 $X=-435430 $Y=133760
X60324 1 2 1684 8163 1748 8188 8174 FA_5VX1 $T=-435000 215040 1 0 $X=-435430 $Y=209920
X60325 1 2 8198 8146 1289 1707 1817 FA_5VX1 $T=-415400 259840 0 180 $X=-432630 $Y=254720
X60326 1 2 1711 8172 8198 1733 1778 FA_5VX1 $T=-431080 250880 0 0 $X=-431510 $Y=250240
X60327 1 2 1704 8183 1598 1784 1829 FA_5VX1 $T=-431080 286720 1 0 $X=-431510 $Y=281600
X60328 1 2 1714 1838 8199 1831 1782 FA_5VX1 $T=-429960 44800 0 0 $X=-430390 $Y=44160
X60329 1 2 1765 8174 1608 1828 1934 FA_5VX1 $T=-413160 206080 1 180 $X=-430390 $Y=205440
X60330 1 2 1685 8196 1426 8203 1797 FA_5VX1 $T=-429960 232960 1 0 $X=-430390 $Y=227840
X60331 1 2 8204 1666 1728 1704 1766 FA_5VX1 $T=-413160 277760 0 180 $X=-430390 $Y=272640
X60332 1 2 1723 8193 1603 8207 1872 FA_5VX1 $T=-428840 170240 1 0 $X=-429270 $Y=165120
X60333 1 2 8160 1815 55 56 8192 FA_5VX1 $T=-427160 26880 0 0 $X=-427590 $Y=26240
X60334 1 2 1585 8192 8168 1736 1786 FA_5VX1 $T=-410360 44800 0 180 $X=-427590 $Y=39680
X60335 1 2 1861 1607 1378 1770 1951 FA_5VX1 $T=-410360 98560 0 180 $X=-427590 $Y=93440
X60336 1 2 1863 8154 1684 1745 8190 FA_5VX1 $T=-410360 197120 1 180 $X=-427590 $Y=196480
X60337 1 2 1754 1703 8176 1711 1789 FA_5VX1 $T=-410360 250880 0 180 $X=-427590 $Y=245760
X60338 1 2 1893 1725 1759 1622 1804 FA_5VX1 $T=-408680 143360 1 180 $X=-425910 $Y=142720
X60339 1 2 1895 8190 1765 1754 1806 FA_5VX1 $T=-408120 206080 0 180 $X=-425350 $Y=200960
X60340 1 2 1312 1706 1775 8184 1813 FA_5VX1 $T=-407000 116480 1 180 $X=-424230 $Y=115840
X60341 1 2 1736 17 59 8214 1831 FA_5VX1 $T=-421000 35840 1 0 $X=-421430 $Y=30720
X60342 1 2 1918 1766 1436 1791 2006 FA_5VX1 $T=-404200 277760 1 180 $X=-421430 $Y=277120
X60343 1 2 1780 1815 63 62 1624 FA_5VX1 $T=-417640 17920 1 0 $X=-418070 $Y=12800
X60344 1 2 1943 1804 8200 1627 1871 FA_5VX1 $T=-400280 152320 1 180 $X=-417510 $Y=151680
X60345 1 2 1820 1889 712 1334 8216 FA_5VX1 $T=-415400 62720 1 0 $X=-415830 $Y=57600
X60346 1 2 1762 8221 1915 1815 1908 FA_5VX1 $T=-414840 53760 1 0 $X=-415270 $Y=48640
X60347 1 2 8229 1778 1808 8204 1888 FA_5VX1 $T=-398040 259840 0 180 $X=-415270 $Y=254720
X60348 1 2 1834 1789 1936 8229 8219 FA_5VX1 $T=-414280 250880 0 0 $X=-414710 $Y=250240
X60349 1 2 1783 1935 1628 8233 1917 FA_5VX1 $T=-413720 241920 1 0 $X=-414150 $Y=236800
X60350 1 2 1838 1815 8230 17 8221 FA_5VX1 $T=-413160 44800 0 0 $X=-413590 $Y=44160
X60351 1 2 1894 1954 1698 8236 1879 FA_5VX1 $T=-412600 170240 0 0 $X=-413030 $Y=169600
X60352 1 2 1854 1823 8231 1917 1928 FA_5VX1 $T=-412600 241920 0 0 $X=-413030 $Y=241280
X60353 1 2 1900 1955 710 8235 2095 FA_5VX1 $T=-412040 179200 0 0 $X=-412470 $Y=178560
X60354 1 2 1234 1813 8211 1803 1922 FA_5VX1 $T=-394680 125440 1 180 $X=-411910 $Y=124800
X60355 1 2 2039 1871 2009 1731 1968 FA_5VX1 $T=-389080 161280 1 180 $X=-406310 $Y=160640
X60356 1 2 2061 1951 1065 1812 2030 FA_5VX1 $T=-387400 98560 0 180 $X=-404630 $Y=93440
X60357 1 2 2100 61 1948 1941 1998 FA_5VX1 $T=-385160 53760 1 180 $X=-402390 $Y=53120
X60358 1 2 1282 1922 1953 1893 8239 FA_5VX1 $T=-385160 134400 1 180 $X=-402390 $Y=133760
X60359 1 2 2074 1806 8226 1834 2000 FA_5VX1 $T=-385160 197120 1 180 $X=-402390 $Y=196480
X60360 1 2 1932 69 8250 2080 2025 FA_5VX1 $T=-400840 35840 1 0 $X=-401270 $Y=30720
X60361 1 2 2099 65 66 1966 2011 FA_5VX1 $T=-382920 26880 0 180 $X=-400150 $Y=21760
X60362 1 2 8252 70 1973 65 2012 FA_5VX1 $T=-382920 71680 1 180 $X=-400150 $Y=71040
X60363 1 2 2120 1888 1972 1918 2058 FA_5VX1 $T=-382920 259840 1 180 $X=-400150 $Y=259200
X60364 1 2 2059 3172 47 67 1948 FA_5VX1 $T=-381800 35840 1 180 $X=-399030 $Y=35200
X60365 1 2 1941 39 41 40 8247 FA_5VX1 $T=-398600 62720 1 0 $X=-399030 $Y=57600
X60366 1 2 68 71 75 76 2049 FA_5VX1 $T=-397480 17920 1 0 $X=-397910 $Y=12800
X60367 1 2 1966 41 77 79 8250 FA_5VX1 $T=-395800 17920 0 0 $X=-396230 $Y=17280
X60368 1 2 2137 8243 1986 2963 2067 FA_5VX1 $T=-379000 89600 1 180 $X=-396230 $Y=88960
X60369 1 2 8260 8244 1929 1996 2047 FA_5VX1 $T=-379000 241920 1 180 $X=-396230 $Y=241280
X60370 1 2 8268 1968 1994 1863 2185 FA_5VX1 $T=-378440 170240 1 180 $X=-395670 $Y=169600
X60371 1 2 1995 2105 1764 8261 8251 FA_5VX1 $T=-395240 188160 0 0 $X=-395670 $Y=187520
X60372 1 2 1990 8219 8260 2120 2075 FA_5VX1 $T=-395240 250880 0 0 $X=-395670 $Y=250240
X60373 1 2 2123 8247 71 1846 2056 FA_5VX1 $T=-377880 62720 1 180 $X=-395110 $Y=62080
X60374 1 2 8264 2030 2013 1877 2057 FA_5VX1 $T=-377880 116480 0 180 $X=-395110 $Y=111360
X60375 1 2 2111 2058 8246 8242 2076 FA_5VX1 $T=-376200 268800 0 180 $X=-393430 $Y=263680
X60376 1 2 2183 73 2055 2059 8259 FA_5VX1 $T=-371160 44800 0 180 $X=-388390 $Y=39680
X60377 1 2 2080 40 74 72 2055 FA_5VX1 $T=-370600 26880 1 180 $X=-387830 $Y=26240
X60378 1 2 1049 2184 73 2067 8256 FA_5VX1 $T=-370600 98560 0 180 $X=-387830 $Y=93440
X60379 1 2 2214 2000 2032 1990 2125 FA_5VX1 $T=-370040 215040 0 180 $X=-387270 $Y=209920
X60380 1 2 2157 2081 2087 1857 2139 FA_5VX1 $T=-369480 143360 0 180 $X=-386710 $Y=138240
X60381 1 2 2181 2062 2068 8251 2186 FA_5VX1 $T=-368920 188160 0 180 $X=-386150 $Y=183040
X60382 1 2 2168 8239 2109 1943 8266 FA_5VX1 $T=-367800 134400 1 180 $X=-385030 $Y=133760
X60383 1 2 2068 8253 2031 2096 2213 FA_5VX1 $T=-367800 206080 0 180 $X=-385030 $Y=200960
X60384 1 2 2126 2075 8258 2111 8271 FA_5VX1 $T=-366120 250880 0 180 $X=-383350 $Y=245760
X60385 1 2 2239 2125 2063 2126 2331 FA_5VX1 $T=-364440 215040 1 180 $X=-381670 $Y=214400
X60386 1 2 8290 8266 8257 2039 8273 FA_5VX1 $T=-363880 152320 0 180 $X=-381110 $Y=147200
X60387 1 2 2271 8271 2153 8263 2350 FA_5VX1 $T=-362200 241920 1 180 $X=-379430 $Y=241280
X60388 1 2 2151 2231 8291 2261 2194 FA_5VX1 $T=-378440 53760 0 0 $X=-378870 $Y=53120
X60389 1 2 2131 2194 2177 2218 2224 FA_5VX1 $T=-378440 71680 0 0 $X=-378870 $Y=71040
X60390 1 2 2169 8273 2158 8268 2208 FA_5VX1 $T=-361640 170240 0 180 $X=-378870 $Y=165120
X60391 1 2 2307 2185 9827 1895 8276 FA_5VX1 $T=-361640 170240 1 180 $X=-378870 $Y=169600
X60392 1 2 8296 8276 2160 2074 2209 FA_5VX1 $T=-361640 188160 1 180 $X=-378870 $Y=187520
X60393 1 2 2277 2224 2404 2412 2368 FA_5VX1 $T=-348200 89600 0 0 $X=-348630 $Y=88960
X60394 1 2 2362 2330 718 2087 8313 FA_5VX1 $T=-330280 161280 1 180 $X=-347510 $Y=160640
X60395 1 2 8324 2331 1864 2271 8311 FA_5VX1 $T=-330280 224000 0 180 $X=-347510 $Y=218880
X60396 1 2 2353 2208 8299 2307 2346 FA_5VX1 $T=-329720 170240 0 180 $X=-346950 $Y=165120
X60397 1 2 8325 2346 2313 8296 8310 FA_5VX1 $T=-329720 179200 0 180 $X=-346950 $Y=174080
X60398 1 2 8333 2347 2094 8298 8312 FA_5VX1 $T=-329720 188160 0 180 $X=-346950 $Y=183040
X60399 1 2 8293 8314 2427 8324 2375 FA_5VX1 $T=-346520 206080 0 0 $X=-346950 $Y=205440
X60400 1 2 8331 8310 2094 2314 2347 FA_5VX1 $T=-329160 179200 1 180 $X=-346390 $Y=178560
X60401 1 2 8298 2392 2427 2239 8314 FA_5VX1 $T=-345960 197120 0 0 $X=-346390 $Y=196480
X60402 1 2 8326 8311 1864 2315 2363 FA_5VX1 $T=-329160 224000 1 180 $X=-346390 $Y=223360
X60403 1 2 2314 2209 2246 2214 2392 FA_5VX1 $T=-327480 197120 0 180 $X=-344710 $Y=192000
X60404 1 2 2467 8312 2094 8293 8340 FA_5VX1 $T=-326920 188160 1 180 $X=-344150 $Y=187520
X60405 1 2 91 8328 17 2465 2411 FA_5VX1 $T=-342040 17920 0 0 $X=-342470 $Y=17280
X60406 1 2 2538 100 96 94 2452 FA_5VX1 $T=-316840 17920 0 180 $X=-334070 $Y=12800
X60407 1 2 2542 2452 97 2417 2231 FA_5VX1 $T=-316280 35840 0 180 $X=-333510 $Y=30720
X60408 1 2 8328 1661 115 8349 2512 FA_5VX1 $T=-329720 26880 1 0 $X=-330150 $Y=21760
X60409 1 2 2485 2375 2427 8326 8342 FA_5VX1 $T=-311800 197120 1 180 $X=-329030 $Y=196480
X60410 1 2 2540 8342 2427 8335 2523 FA_5VX1 $T=-309560 206080 0 180 $X=-326790 $Y=200960
X60411 1 2 2349 8352 2596 2589 2518 FA_5VX1 $T=-325800 44800 1 0 $X=-326230 $Y=39680
X60412 1 2 8358 8340 2094 2485 2536 FA_5VX1 $T=-309000 188160 1 180 $X=-326230 $Y=187520
X60413 1 2 2604 2368 104 8317 8344 FA_5VX1 $T=-307880 98560 1 180 $X=-325110 $Y=97920
X60414 1 2 2612 8344 106 8339 8347 FA_5VX1 $T=-306760 116480 0 180 $X=-323990 $Y=111360
X60415 1 2 723 8347 1358 2528 2565 FA_5VX1 $T=-302840 134400 0 180 $X=-320070 $Y=129280
X60416 1 2 2439 2565 2635 2641 2600 FA_5VX1 $T=-319080 143360 0 0 $X=-319510 $Y=142720
X60417 1 2 2506 2616 2512 2678 2433 FA_5VX1 $T=-318520 35840 0 0 $X=-318950 $Y=35200
X60418 1 2 2661 2536 2094 2540 2643 FA_5VX1 $T=-301720 188160 0 180 $X=-318950 $Y=183040
X60419 1 2 8349 40 120 119 8362 FA_5VX1 $T=-316840 17920 1 0 $X=-317270 $Y=12800
X60420 1 2 2461 2646 2668 8375 2489 FA_5VX1 $T=-315160 44800 0 0 $X=-315590 $Y=44160
X60421 1 2 2578 43 123 8384 2638 FA_5VX1 $T=-312920 26880 0 0 $X=-313350 $Y=26240
X60422 1 2 2539 2659 2683 8378 2519 FA_5VX1 $T=-312920 62720 1 0 $X=-313350 $Y=57600
X60423 1 2 2721 2624 2601 2591 2642 FA_5VX1 $T=-293880 161280 1 180 $X=-311110 $Y=160640
X60424 1 2 2472 2694 2678 9941 2490 FA_5VX1 $T=-310120 80640 1 0 $X=-310550 $Y=75520
X60425 1 2 2534 8377 2715 2717 2556 FA_5VX1 $T=-310120 89600 0 0 $X=-310550 $Y=88960
X60426 1 2 2613 2600 1695 722 2624 FA_5VX1 $T=-293320 152320 0 180 $X=-310550 $Y=147200
X60427 1 2 2616 17 8362 2578 2589 FA_5VX1 $T=-292760 35840 0 180 $X=-309990 $Y=30720
X60428 1 2 8352 2678 39 2638 2646 FA_5VX1 $T=-309000 44800 1 0 $X=-309430 $Y=39680
X60429 1 2 2724 2678 2622 8363 2660 FA_5VX1 $T=-291080 98560 1 180 $X=-308310 $Y=97920
X60430 1 2 8363 17 1973 2736 2639 FA_5VX1 $T=-307880 107520 0 0 $X=-308310 $Y=106880
X60431 1 2 2742 2643 2094 2611 2662 FA_5VX1 $T=-291080 188160 1 180 $X=-308310 $Y=187520
X60432 1 2 8396 8387 2636 2647 2727 FA_5VX1 $T=-286600 277760 0 180 $X=-303830 $Y=272640
X60433 1 2 2680 8393 2594 2654 2711 FA_5VX1 $T=-303400 295680 1 0 $X=-303830 $Y=290560
X60434 1 2 9913 8381 2671 2654 8387 FA_5VX1 $T=-285480 259840 1 180 $X=-302710 $Y=259200
X60435 1 2 2596 2741 129 2747 2668 FA_5VX1 $T=-301720 35840 0 0 $X=-302150 $Y=35200
X60436 1 2 8377 8395 2781 2788 8394 FA_5VX1 $T=-298920 107520 1 0 $X=-299350 $Y=102400
X60437 1 2 2647 2541 2723 2671 2655 FA_5VX1 $T=-298920 277760 0 0 $X=-299350 $Y=277120
X60438 1 2 2672 8399 2541 8407 2759 FA_5VX1 $T=-297800 313600 0 0 $X=-298230 $Y=312960
X60439 1 2 2679 2760 2802 1581 2702 FA_5VX1 $T=-296680 89600 1 0 $X=-297110 $Y=84480
X60440 1 2 8384 2713 131 133 2741 FA_5VX1 $T=-295560 26880 1 0 $X=-295990 $Y=21760
X60441 1 2 2719 8405 2776 8411 2684 FA_5VX1 $T=-295560 125440 0 0 $X=-295990 $Y=124800
X60442 1 2 2725 43 47 41 2776 FA_5VX1 $T=-293880 116480 0 0 $X=-294310 $Y=115840
X60443 1 2 2683 127 41 134 2787 FA_5VX1 $T=-293320 62720 1 0 $X=-293750 $Y=57600
X60444 1 2 9941 2551 2787 2833 2717 FA_5VX1 $T=-293320 80640 1 0 $X=-293750 $Y=75520
X60445 1 2 2629 8394 2827 61 2739 FA_5VX1 $T=-293320 125440 1 0 $X=-293750 $Y=120320
X60446 1 2 2659 17 125 2687 2694 FA_5VX1 $T=-275960 53760 0 180 $X=-293190 $Y=48640
X60447 1 2 2745 8419 2594 2837 2815 FA_5VX1 $T=-290520 331520 1 0 $X=-290950 $Y=326400
X60448 1 2 2833 8417 2761 40 2715 FA_5VX1 $T=-272040 71680 1 180 $X=-289270 $Y=71040
X60449 1 2 2827 2753 2725 39 8411 FA_5VX1 $T=-270920 116480 0 180 $X=-288150 $Y=111360
X60450 1 2 8430 8409 2654 2767 9832 FA_5VX1 $T=-270360 241920 1 180 $X=-287590 $Y=241280
X60451 1 2 2879 8421 2779 8401 2824 FA_5VX1 $T=-269800 304640 0 180 $X=-287030 $Y=299520
X60452 1 2 8436 9832 2819 8403 8416 FA_5VX1 $T=-268680 259840 0 180 $X=-285910 $Y=254720
X60453 1 2 2797 74 146 8435 2855 FA_5VX1 $T=-283240 35840 0 0 $X=-283670 $Y=35200
X60454 1 2 2928 8426 2813 8408 8421 FA_5VX1 $T=-266440 286720 0 180 $X=-283670 $Y=281600
X60455 1 2 8449 2769 8415 8416 8426 FA_5VX1 $T=-263640 268800 0 180 $X=-280870 $Y=263680
X60456 1 2 2823 8437 2934 8445 2884 FA_5VX1 $T=-279320 134400 0 0 $X=-279750 $Y=133760
X60457 1 2 8417 41 77 74 2781 FA_5VX1 $T=-278760 89600 0 0 $X=-279190 $Y=88960
X60458 1 2 8453 39 2797 2848 2887 FA_5VX1 $T=-259720 62720 0 180 $X=-276950 $Y=57600
X60459 1 2 2895 8451 2657 8425 2891 FA_5VX1 $T=-259160 349440 0 180 $X=-276390 $Y=344320
X60460 1 2 8465 2824 8431 8429 2930 FA_5VX1 $T=-255240 322560 0 180 $X=-272470 $Y=317440
X60461 1 2 2988 47 144 74 3019 FA_5VX1 $T=-254680 26880 1 180 $X=-271910 $Y=26240
X60462 1 2 8434 8460 3001 8468 2946 FA_5VX1 $T=-268680 152320 1 0 $X=-269110 $Y=147200
X60463 1 2 2899 8461 3044 2900 8457 FA_5VX1 $T=-268680 259840 0 0 $X=-269110 $Y=259200
X60464 1 2 147 1661 3007 158 2973 FA_5VX1 $T=-268120 35840 1 0 $X=-268550 $Y=30720
X60465 1 2 3012 8459 8439 8436 2916 FA_5VX1 $T=-251320 250880 0 180 $X=-268550 $Y=245760
X60466 1 2 8476 2932 40 2906 3001 FA_5VX1 $T=-250760 143360 1 180 $X=-267990 $Y=142720
X60467 1 2 2913 2986 8469 17 2914 FA_5VX1 $T=-267000 125440 1 0 $X=-267430 $Y=120320
X60468 1 2 3021 8450 8440 2914 2962 FA_5VX1 $T=-250200 134400 0 180 $X=-267430 $Y=129280
X60469 1 2 8475 8430 2927 2957 8459 FA_5VX1 $T=-250200 241920 1 180 $X=-267430 $Y=241280
X60470 1 2 8481 8449 2899 2916 8456 FA_5VX1 $T=-250200 259840 0 180 $X=-267430 $Y=254720
X60471 1 2 3007 40 2920 2939 2965 FA_5VX1 $T=-249640 35840 1 180 $X=-266870 $Y=35200
X60472 1 2 2990 1661 150 2921 2954 FA_5VX1 $T=-249640 80640 1 180 $X=-266870 $Y=80000
X60473 1 2 8440 2869 2736 3000 2934 FA_5VX1 $T=-266440 125440 0 0 $X=-266870 $Y=124800
X60474 1 2 8437 2968 1661 8476 8460 FA_5VX1 $T=-266440 143360 1 0 $X=-266870 $Y=138240
X60475 1 2 8439 2999 2900 2893 8461 FA_5VX1 $T=-266440 250880 0 0 $X=-266870 $Y=250240
X60476 1 2 3031 41 149 8443 2972 FA_5VX1 $T=-249080 26880 0 180 $X=-266310 $Y=21760
X60477 1 2 2933 2968 8478 3034 2991 FA_5VX1 $T=-264760 107520 0 0 $X=-265190 $Y=106880
X60478 1 2 2986 1661 2922 729 2974 FA_5VX1 $T=-247960 116480 0 180 $X=-265190 $Y=111360
X60479 1 2 8446 8457 3044 8466 2997 FA_5VX1 $T=-264760 277760 1 0 $X=-265190 $Y=272640
X60480 1 2 3224 3026 9914 2942 2978 FA_5VX1 $T=-247400 241920 0 180 $X=-264630 $Y=236800
X60481 1 2 2942 8456 8446 2928 2987 FA_5VX1 $T=-246280 268800 0 180 $X=-263510 $Y=263680
X60482 1 2 3077 2991 2954 2913 2992 FA_5VX1 $T=-245720 116480 1 180 $X=-262950 $Y=115840
X60483 1 2 8450 2968 17 2974 8445 FA_5VX1 $T=-262520 134400 0 0 $X=-262950 $Y=133760
X60484 1 2 2935 8470 3050 2968 3008 FA_5VX1 $T=-262520 161280 0 0 $X=-262950 $Y=160640
X60485 1 2 9835 43 2953 2793 2921 FA_5VX1 $T=-245160 89600 1 180 $X=-262390 $Y=88960
X60486 1 2 3084 8485 2969 8454 8467 FA_5VX1 $T=-244040 322560 1 180 $X=-261270 $Y=321920
X60487 1 2 8454 2930 8495 8441 8477 FA_5VX1 $T=-259720 340480 1 0 $X=-260150 $Y=335360
X60488 1 2 9942 3075 2985 17 2982 FA_5VX1 $T=-241240 89600 0 180 $X=-258470 $Y=84480
X60489 1 2 3101 2933 2990 2982 3020 FA_5VX1 $T=-240680 98560 1 180 $X=-257910 $Y=97920
X60490 1 2 3043 2987 8464 2879 8482 FA_5VX1 $T=-240120 286720 0 180 $X=-257350 $Y=281600
X60491 1 2 3327 3012 2909 2995 3036 FA_5VX1 $T=-239560 224000 0 180 $X=-256790 $Y=218880
X60492 1 2 8464 2997 3045 3116 8486 FA_5VX1 $T=-255240 286720 0 0 $X=-255670 $Y=286080
X60493 1 2 3081 8482 9834 8465 8485 FA_5VX1 $T=-238440 304640 0 180 $X=-255670 $Y=299520
X60494 1 2 2969 8492 3068 3112 3061 FA_5VX1 $T=-255240 322560 1 0 $X=-255670 $Y=317440
X60495 1 2 3118 1661 2886 2965 3041 FA_5VX1 $T=-237880 26880 1 180 $X=-255110 $Y=26240
X60496 1 2 3119 3018 2859 43 2985 FA_5VX1 $T=-237880 53760 1 180 $X=-255110 $Y=53120
X60497 1 2 3120 8481 731 3036 3026 FA_5VX1 $T=-237880 232960 1 180 $X=-255110 $Y=232320
X60498 1 2 9834 8486 3066 3139 8492 FA_5VX1 $T=-253000 295680 0 0 $X=-253430 $Y=295040
X60499 1 2 3116 3015 2738 2893 3066 FA_5VX1 $T=-235640 295680 0 180 $X=-252870 $Y=290560
X60500 1 2 3139 2900 3038 3015 3068 FA_5VX1 $T=-235640 313600 0 180 $X=-252870 $Y=308480
X60501 1 2 3075 9835 2981 39 3034 FA_5VX1 $T=-235080 98560 0 180 $X=-252310 $Y=93440
X60502 1 2 8509 43 8479 3019 3074 FA_5VX1 $T=-234520 35840 0 180 $X=-251750 $Y=30720
X60503 1 2 8510 2887 8480 1661 3083 FA_5VX1 $T=-234520 80640 0 180 $X=-251750 $Y=75520
X60504 1 2 3032 17 8509 3091 3099 FA_5VX1 $T=-250200 44800 1 0 $X=-250630 $Y=39680
X60505 1 2 8478 39 3105 40 8469 FA_5VX1 $T=-250200 125440 1 0 $X=-250630 $Y=120320
X60506 1 2 3166 3032 3118 2973 3047 FA_5VX1 $T=-232840 35840 1 180 $X=-250070 $Y=35200
X60507 1 2 3112 3044 3039 3038 8494 FA_5VX1 $T=-232840 313600 1 180 $X=-250070 $Y=312960
X60508 1 2 171 39 2988 2972 3091 FA_5VX1 $T=-232280 26880 0 180 $X=-249510 $Y=21760
X60509 1 2 3163 2978 3052 3043 8498 FA_5VX1 $T=-232280 259840 0 180 $X=-249510 $Y=254720
X60510 1 2 173 39 3031 2989 165 FA_5VX1 $T=-230040 17920 0 180 $X=-247270 $Y=12800
X60511 1 2 3097 3061 8494 8493 3129 FA_5VX1 $T=-227800 331520 0 180 $X=-245030 $Y=326400
X60512 1 2 3209 8498 3090 3081 3135 FA_5VX1 $T=-227240 268800 1 180 $X=-244470 $Y=268160
X60513 1 2 8493 3039 2738 3206 3158 FA_5VX1 $T=-244040 331520 0 0 $X=-244470 $Y=330880
X60514 1 2 3214 8467 3097 8496 3140 FA_5VX1 $T=-226680 322560 1 180 $X=-243910 $Y=321920
X60515 1 2 3088 8516 8526 3109 3103 FA_5VX1 $T=-242920 241920 1 0 $X=-243350 $Y=236800
X60516 1 2 3159 8487 3110 2835 3144 FA_5VX1 $T=-226120 349440 0 180 $X=-243350 $Y=344320
X60517 1 2 3003 8521 3064 2909 8516 FA_5VX1 $T=-242360 224000 0 0 $X=-242790 $Y=223360
X60518 1 2 3095 3182 2794 3233 3171 FA_5VX1 $T=-242360 358400 1 0 $X=-242790 $Y=353280
X60519 1 2 8496 8477 3164 3130 3175 FA_5VX1 $T=-241800 340480 1 0 $X=-242230 $Y=335360
X60520 1 2 3250 8527 3083 9942 3136 FA_5VX1 $T=-224440 89600 0 180 $X=-241670 $Y=84480
X60521 1 2 3102 3197 3212 2909 8517 FA_5VX1 $T=-241240 250880 1 0 $X=-241670 $Y=245760
X60522 1 2 3109 2665 3221 3064 3180 FA_5VX1 $T=-240680 241920 0 0 $X=-241110 $Y=241280
X60523 1 2 3245 3135 3127 3084 3176 FA_5VX1 $T=-222200 286720 0 180 $X=-239430 $Y=281600
X60524 1 2 3122 3218 3236 3099 3199 FA_5VX1 $T=-237880 53760 0 0 $X=-238310 $Y=53120
X60525 1 2 3218 2968 8453 3041 3184 FA_5VX1 $T=-221080 62720 0 180 $X=-238310 $Y=57600
X60526 1 2 8546 8510 3119 2968 8527 FA_5VX1 $T=-217720 80640 0 180 $X=-234950 $Y=75520
X60527 1 2 8549 3087 3196 3190 8557 FA_5VX1 $T=-214360 224000 0 180 $X=-231590 $Y=218880
X60528 1 2 3114 8533 2665 3198 8536 FA_5VX1 $T=-213800 259840 1 180 $X=-231030 $Y=259200
X60529 1 2 3236 17 2966 3074 9838 FA_5VX1 $T=-211000 53760 0 180 $X=-228230 $Y=48640
X60530 1 2 3289 3129 3158 3229 3277 FA_5VX1 $T=-208760 340480 1 180 $X=-225990 $Y=339840
X60531 1 2 3281 3175 3232 8537 3278 FA_5VX1 $T=-208760 349440 0 180 $X=-225990 $Y=344320
X60532 1 2 3234 8564 2785 8571 3388 FA_5VX1 $T=-223880 376320 1 0 $X=-224310 $Y=371200
X60533 1 2 3186 8567 3212 3295 8553 FA_5VX1 $T=-222200 286720 1 0 $X=-222630 $Y=281600
X60534 1 2 3349 3176 3256 3214 3299 FA_5VX1 $T=-204840 304640 0 180 $X=-222070 $Y=299520
X60535 1 2 3334 8546 9838 3184 3243 FA_5VX1 $T=-203720 71680 0 180 $X=-220950 $Y=66560
X60536 1 2 3370 8549 2191 3264 3308 FA_5VX1 $T=-203720 206080 0 180 $X=-220950 $Y=200960
X60537 1 2 3374 77 3096 132 3306 FA_5VX1 $T=-203160 71680 1 180 $X=-220390 $Y=71040
X60538 1 2 3373 8577 74 3316 3312 FA_5VX1 $T=-202040 44800 0 180 $X=-219270 $Y=39680
X60539 1 2 8583 8573 3344 2191 3318 FA_5VX1 $T=-201480 215040 0 180 $X=-218710 $Y=209920
X60540 1 2 3379 3140 3289 3281 3322 FA_5VX1 $T=-201480 340480 0 180 $X=-218710 $Y=335360
X60541 1 2 3280 8574 2258 2399 8570 FA_5VX1 $T=-217720 241920 0 0 $X=-218150 $Y=241280
X60542 1 2 3319 8570 2258 3267 3328 FA_5VX1 $T=-200920 250880 0 180 $X=-218150 $Y=245760
X60543 1 2 3288 3260 2399 3244 8574 FA_5VX1 $T=-217160 241920 1 0 $X=-217590 $Y=236800
X60544 1 2 8596 3120 3280 3298 8569 FA_5VX1 $T=-198680 224000 1 180 $X=-215910 $Y=223360
X60545 1 2 3331 47 3390 3374 3356 FA_5VX1 $T=-214360 62720 1 0 $X=-214790 $Y=57600
X60546 1 2 3427 3327 3288 8557 3298 FA_5VX1 $T=-197560 224000 0 180 $X=-214790 $Y=218880
X60547 1 2 3307 3395 39 8592 3363 FA_5VX1 $T=-213800 116480 1 0 $X=-214230 $Y=111360
X60548 1 2 8592 40 47 41 3343 FA_5VX1 $T=-197000 125440 0 180 $X=-214230 $Y=120320
X60549 1 2 3421 8587 8562 3209 8575 FA_5VX1 $T=-197000 259840 1 180 $X=-214230 $Y=259200
X60550 1 2 3305 77 3342 8593 8577 FA_5VX1 $T=-213240 35840 1 0 $X=-213670 $Y=30720
X60551 1 2 3455 8569 3319 3224 3347 FA_5VX1 $T=-196440 232960 0 180 $X=-213670 $Y=227840
X60552 1 2 8562 8578 8591 3435 3378 FA_5VX1 $T=-213240 268800 1 0 $X=-213670 $Y=263680
X60553 1 2 3449 8575 3321 3245 3348 FA_5VX1 $T=-196440 277760 1 180 $X=-213670 $Y=277120
X60554 1 2 3353 3328 3302 3320 8578 FA_5VX1 $T=-195320 259840 0 180 $X=-212550 $Y=254720
X60555 1 2 8605 132 210 209 3333 FA_5VX1 $T=-194760 17920 0 180 $X=-211990 $Y=12800
X60556 1 2 8606 41 3333 3305 3425 FA_5VX1 $T=-194760 26880 1 180 $X=-211990 $Y=26240
X60557 1 2 3316 132 221 8603 3390 FA_5VX1 $T=-211000 35840 0 0 $X=-211430 $Y=35200
X60558 1 2 3459 43 3312 3331 3380 FA_5VX1 $T=-194200 53760 0 180 $X=-211430 $Y=48640
X60559 1 2 3325 8590 3446 3452 3392 FA_5VX1 $T=-211000 107520 1 0 $X=-211430 $Y=102400
X60560 1 2 3461 3427 3337 3308 9842 FA_5VX1 $T=-194200 197120 0 180 $X=-211430 $Y=192000
X60561 1 2 3382 47 219 8605 3406 FA_5VX1 $T=-209320 17920 0 0 $X=-209750 $Y=17280
X60562 1 2 8572 2963 3975 1986 3366 FA_5VX1 $T=-208760 161280 1 0 $X=-209190 $Y=156160
X60563 1 2 3320 2259 3244 2266 8591 FA_5VX1 $T=-208760 268800 0 0 $X=-209190 $Y=268160
X60564 1 2 3497 3476 3345 8572 3402 FA_5VX1 $T=-190840 152320 0 180 $X=-208070 $Y=147200
X60565 1 2 3498 3347 3353 3163 8587 FA_5VX1 $T=-190840 250880 1 180 $X=-208070 $Y=250240
X60566 1 2 3512 3382 213 40 3413 FA_5VX1 $T=-189720 26880 0 180 $X=-206950 $Y=21760
X60567 1 2 3503 156 3365 3401 3419 FA_5VX1 $T=-189720 143360 0 180 $X=-206950 $Y=138240
X60568 1 2 3445 3356 41 8585 3418 FA_5VX1 $T=-188600 80640 0 180 $X=-205830 $Y=75520
X60569 1 2 3479 8602 8611 8619 3450 FA_5VX1 $T=-205400 286720 0 0 $X=-205830 $Y=286080
X60570 1 2 3520 3363 2963 8580 3426 FA_5VX1 $T=-188040 134400 0 180 $X=-205270 $Y=129280
X60571 1 2 3309 8609 3255 3422 3387 FA_5VX1 $T=-204840 295680 0 0 $X=-205270 $Y=295040
X60572 1 2 3517 3299 8584 3379 3439 FA_5VX1 $T=-188040 313600 0 180 $X=-205270 $Y=308480
X60573 1 2 3456 3278 9843 8581 3457 FA_5VX1 $T=-188040 358400 0 180 $X=-205270 $Y=353280
X60574 1 2 3435 2399 3385 2259 3436 FA_5VX1 $T=-187480 277760 0 180 $X=-204710 $Y=272640
X60575 1 2 3321 3378 3436 8618 8602 FA_5VX1 $T=-204280 286720 1 0 $X=-204710 $Y=281600
X60576 1 2 8580 3343 3465 2906 3365 FA_5VX1 $T=-203720 134400 0 0 $X=-204150 $Y=133760
X60577 1 2 3540 3476 3392 3307 3453 FA_5VX1 $T=-186360 116480 1 180 $X=-203590 $Y=115840
X60578 1 2 3555 8596 3396 9842 3447 FA_5VX1 $T=-186360 197120 1 180 $X=-203590 $Y=196480
X60579 1 2 3397 3434 3504 3344 3485 FA_5VX1 $T=-201480 215040 0 0 $X=-201910 $Y=214400
X60580 1 2 8588 3509 2984 3545 3636 FA_5VX1 $T=-201480 376320 0 0 $X=-201910 $Y=375680
X60581 1 2 3448 3318 3428 3397 3507 FA_5VX1 $T=-183000 206080 1 180 $X=-200230 $Y=205440
X60582 1 2 3572 3457 8595 3423 3487 FA_5VX1 $T=-182440 358400 1 180 $X=-199670 $Y=357760
X60583 1 2 8627 8608 3444 2191 3492 FA_5VX1 $T=-181880 224000 1 180 $X=-199110 $Y=223360
X60584 1 2 8594 3277 735 8630 8615 FA_5VX1 $T=-198680 349440 1 0 $X=-199110 $Y=344320
X60585 1 2 3595 3325 17 3539 3496 FA_5VX1 $T=-181320 98560 1 180 $X=-198550 $Y=97920
X60586 1 2 3559 3476 1661 3383 3500 FA_5VX1 $T=-180760 62720 0 180 $X=-197990 $Y=57600
X60587 1 2 8633 8606 3406 43 3474 FA_5VX1 $T=-179640 35840 0 180 $X=-196870 $Y=30720
X60588 1 2 3405 8622 3261 3543 3529 FA_5VX1 $T=-196440 304640 0 0 $X=-196870 $Y=304000
X60589 1 2 3571 3322 8594 3456 8647 FA_5VX1 $T=-179640 340480 1 180 $X=-196870 $Y=339840
X60590 1 2 3679 8612 3476 8641 3535 FA_5VX1 $T=-195880 98560 1 0 $X=-196310 $Y=93440
X60591 1 2 8599 3323 3110 3655 3544 FA_5VX1 $T=-195320 367360 1 0 $X=-195750 $Y=362240
X60592 1 2 3483 40 3460 3433 3452 FA_5VX1 $T=-177960 89600 1 180 $X=-195190 $Y=88960
X60593 1 2 3627 3348 3479 3349 3527 FA_5VX1 $T=-177960 277760 1 180 $X=-195190 $Y=277120
X60594 1 2 3611 8633 3413 1661 3524 FA_5VX1 $T=-177400 35840 1 180 $X=-194630 $Y=35200
X60595 1 2 3621 17 3373 3474 8616 FA_5VX1 $T=-177400 53760 0 180 $X=-194630 $Y=48640
X60596 1 2 8641 1661 3418 3483 3539 FA_5VX1 $T=-176280 89600 0 180 $X=-193510 $Y=84480
X60597 1 2 8610 3506 3631 3636 8628 FA_5VX1 $T=-192520 376320 1 0 $X=-192950 $Y=371200
X60598 1 2 3673 3447 3515 3455 3567 FA_5VX1 $T=-173480 206080 0 180 $X=-190710 $Y=200960
X60599 1 2 3670 3559 3459 8616 3566 FA_5VX1 $T=-172920 62720 1 180 $X=-190150 $Y=62080
X60600 1 2 3660 8626 3434 8617 3583 FA_5VX1 $T=-172920 232960 0 180 $X=-190150 $Y=227840
X60601 1 2 8618 2258 3570 3385 8611 FA_5VX1 $T=-188040 286720 0 0 $X=-188470 $Y=286080
X60602 1 2 3708 3500 3380 3538 3607 FA_5VX1 $T=-169560 71680 1 180 $X=-186790 $Y=71040
X60603 1 2 8619 3570 2266 3746 3714 FA_5VX1 $T=-186360 295680 0 0 $X=-186790 $Y=295040
X60604 1 2 3720 3527 8625 3517 3628 FA_5VX1 $T=-169000 286720 0 180 $X=-186230 $Y=281600
X60605 1 2 8625 3450 3714 3667 3653 FA_5VX1 $T=-184680 295680 1 0 $X=-185110 $Y=290560
X60606 1 2 3713 3439 3578 3571 3634 FA_5VX1 $T=-167880 322560 1 180 $X=-185110 $Y=321920
X60607 1 2 3949 3370 3770 3699 8642 FA_5VX1 $T=-167320 197120 1 180 $X=-184550 $Y=196480
X60608 1 2 3563 8654 3389 3705 3740 FA_5VX1 $T=-183560 376320 0 0 $X=-183990 $Y=375680
X60609 1 2 3591 8615 3039 3722 3695 FA_5VX1 $T=-181880 349440 1 0 $X=-182310 $Y=344320
X60610 1 2 3757 229 3258 3598 3669 FA_5VX1 $T=-164520 26880 0 180 $X=-181750 $Y=21760
X60611 1 2 9905 3567 3734 3498 3674 FA_5VX1 $T=-163400 215040 0 180 $X=-180630 $Y=209920
X60612 1 2 3776 3665 3300 3614 3682 FA_5VX1 $T=-162840 179200 1 180 $X=-180070 $Y=178560
X60613 1 2 3721 8647 3591 3572 3694 FA_5VX1 $T=-162840 340480 1 180 $X=-180070 $Y=339840
X60614 1 2 3775 8660 9909 3612 8653 FA_5VX1 $T=-162280 152320 1 180 $X=-179510 $Y=151680
X60615 1 2 4172 3672 3613 8640 3665 FA_5VX1 $T=-162280 179200 0 180 $X=-179510 $Y=174080
X60616 1 2 3769 3461 3615 8642 3698 FA_5VX1 $T=-161720 188160 0 180 $X=-178950 $Y=183040
X60617 1 2 3796 8653 3646 3633 3672 FA_5VX1 $T=-161160 170240 0 180 $X=-178390 $Y=165120
X60618 1 2 3782 3360 3640 8643 3699 FA_5VX1 $T=-161160 197120 0 180 $X=-178390 $Y=192000
X60619 1 2 3756 3487 3642 3563 8656 FA_5VX1 $T=-161160 367360 1 180 $X=-178390 $Y=366720
X60620 1 2 9906 8670 3467 8649 8660 FA_5VX1 $T=-159480 152320 0 180 $X=-176710 $Y=147200
X60621 1 2 3712 3676 3444 3625 3739 FA_5VX1 $T=-157800 250880 0 180 $X=-175030 $Y=245760
X60622 1 2 3609 3786 3386 3816 3762 FA_5VX1 $T=-174040 322560 1 0 $X=-174470 $Y=317440
X60623 1 2 3856 3669 3677 3678 3748 FA_5VX1 $T=-156680 44800 1 180 $X=-173910 $Y=44160
X60624 1 2 3832 3674 3703 3421 3753 FA_5VX1 $T=-156120 232960 0 180 $X=-173350 $Y=227840
X60625 1 2 3704 8684 3570 738 3875 FA_5VX1 $T=-172360 304640 1 0 $X=-172790 $Y=299520
X60626 1 2 3844 8678 3717 3702 8670 FA_5VX1 $T=-155000 143360 0 180 $X=-172230 $Y=138240
X60627 1 2 3864 3628 3727 3713 8681 FA_5VX1 $T=-154440 286720 1 180 $X=-171670 $Y=286080
X60628 1 2 253 242 8659 8657 3764 FA_5VX1 $T=-153880 17920 0 180 $X=-171110 $Y=12800
X60629 1 2 3761 3634 8662 3721 3779 FA_5VX1 $T=-153880 331520 1 180 $X=-171110 $Y=330880
X60630 1 2 3857 8686 3731 9903 8678 FA_5VX1 $T=-153320 125440 1 180 $X=-170550 $Y=124800
X60631 1 2 3760 8688 3597 8667 3780 FA_5VX1 $T=-152200 259840 0 180 $X=-169430 $Y=254720
X60632 1 2 255 3764 3730 3733 8683 FA_5VX1 $T=-151640 53760 1 180 $X=-168870 $Y=53120
X60633 1 2 3727 3653 8661 3735 8684 FA_5VX1 $T=-151640 295680 1 180 $X=-168870 $Y=295040
X60634 1 2 3887 8691 3750 9904 8686 FA_5VX1 $T=-151080 116480 0 180 $X=-168310 $Y=111360
X60635 1 2 3915 8696 3560 3758 8691 FA_5VX1 $T=-148840 89600 1 180 $X=-166070 $Y=88960
X60636 1 2 3905 8681 3704 3761 3815 FA_5VX1 $T=-148840 295680 0 180 $X=-166070 $Y=290560
X60637 1 2 3932 3694 8672 3756 3823 FA_5VX1 $T=-148280 349440 0 180 $X=-165510 $Y=344320
X60638 1 2 3921 8683 3868 3773 8696 FA_5VX1 $T=-147160 62720 0 180 $X=-164390 $Y=57600
X60639 1 2 3919 3753 8682 3449 3833 FA_5VX1 $T=-146600 241920 0 180 $X=-163830 $Y=236800
X60640 1 2 3914 8704 736 3778 3835 FA_5VX1 $T=-146600 268800 0 180 $X=-163830 $Y=263680
X60641 1 2 3943 3555 8687 3698 8699 FA_5VX1 $T=-145480 188160 1 180 $X=-162710 $Y=187520
X60642 1 2 3885 8656 3253 3798 4012 FA_5VX1 $T=-143800 367360 1 180 $X=-161030 $Y=366720
X60643 1 2 3993 3833 3854 3627 3904 FA_5VX1 $T=-139880 250880 0 180 $X=-157110 $Y=245760
X60644 1 2 4010 3673 3870 8699 3853 FA_5VX1 $T=-137640 197120 0 180 $X=-154870 $Y=192000
X60645 1 2 3971 3748 3246 3883 8711 FA_5VX1 $T=-135400 62720 1 180 $X=-152630 $Y=62080
X60646 1 2 4030 3823 8705 3885 3951 FA_5VX1 $T=-135400 349440 1 180 $X=-152630 $Y=348800
X60647 1 2 3882 3779 8733 3932 3980 FA_5VX1 $T=-151080 340480 0 0 $X=-151510 $Y=339840
X60648 1 2 4047 8711 3907 3901 8713 FA_5VX1 $T=-133720 80640 1 180 $X=-150950 $Y=80000
X60649 1 2 8741 8713 2822 4048 8714 FA_5VX1 $T=-133720 98560 0 180 $X=-150950 $Y=93440
X60650 1 2 4049 3815 3865 3882 3961 FA_5VX1 $T=-133720 295680 1 180 $X=-150950 $Y=295040
X60651 1 2 3899 3841 8737 3995 8721 FA_5VX1 $T=-150520 331520 0 0 $X=-150950 $Y=330880
X60652 1 2 3807 3964 4033 8741 4007 FA_5VX1 $T=-149960 98560 0 0 $X=-150390 $Y=97920
X60653 1 2 3763 4017 3522 4044 3995 FA_5VX1 $T=-149400 331520 1 0 $X=-149830 $Y=326400
X60654 1 2 4069 3950 8708 3791 3982 FA_5VX1 $T=-131480 197120 1 180 $X=-148710 $Y=196480
X60655 1 2 3973 8729 3718 3924 3959 FA_5VX1 $T=-131480 268800 1 180 $X=-148710 $Y=268160
X60656 1 2 3939 8714 2945 4072 8720 FA_5VX1 $T=-130920 116480 1 180 $X=-148150 $Y=115840
X60657 1 2 742 3951 8712 3945 4001 FA_5VX1 $T=-129800 358400 0 180 $X=-147030 $Y=353280
X60658 1 2 3942 4038 8432 4077 8725 FA_5VX1 $T=-146040 152320 1 0 $X=-146470 $Y=147200
X60659 1 2 3922 8720 2905 4076 8735 FA_5VX1 $T=-145480 134400 1 0 $X=-145910 $Y=129280
X60660 1 2 3968 4063 744 4104 4042 FA_5VX1 $T=-143240 250880 0 0 $X=-143670 $Y=250240
X60661 1 2 4000 8742 4035 4115 4057 FA_5VX1 $T=-141000 277760 1 0 $X=-141430 $Y=272640
X60662 1 2 3957 8735 2798 4118 4038 FA_5VX1 $T=-140440 134400 0 0 $X=-140870 $Y=133760
X60663 1 2 4121 3982 8726 3832 8744 FA_5VX1 $T=-123640 206080 0 180 $X=-140870 $Y=200960
X60664 1 2 4285 8744 8736 3919 8757 FA_5VX1 $T=-120840 206080 1 180 $X=-138070 $Y=205440
X60665 1 2 8780 8752 3898 4028 4203 FA_5VX1 $T=-119720 340480 0 180 $X=-136950 $Y=335360
X60666 1 2 4085 3904 8745 3720 8764 FA_5VX1 $T=-118600 259840 1 180 $X=-135830 $Y=259200
X60667 1 2 8743 3980 8780 4030 8769 FA_5VX1 $T=-135400 349440 1 0 $X=-135830 $Y=344320
X60668 1 2 8783 8757 8747 3993 4095 FA_5VX1 $T=-118040 215040 0 180 $X=-135270 $Y=209920
X60669 1 2 4035 8775 3944 4135 8771 FA_5VX1 $T=-134840 295680 1 0 $X=-135270 $Y=290560
X60670 1 2 4192 3961 4050 8743 8767 FA_5VX1 $T=-118040 304640 1 180 $X=-135270 $Y=304000
X60671 1 2 4056 9849 9802 3905 8773 FA_5VX1 $T=-114680 268800 0 180 $X=-131910 $Y=263680
X60672 1 2 4214 8751 4104 3902 8772 FA_5VX1 $T=-114120 224000 0 180 $X=-131350 $Y=218880
X60673 1 2 4209 8764 4022 3864 9849 FA_5VX1 $T=-113560 259840 0 180 $X=-130790 $Y=254720
X60674 1 2 8760 8769 8788 742 8779 FA_5VX1 $T=-130360 340480 0 0 $X=-130790 $Y=339840
X60675 1 2 4230 8767 8765 8760 8778 FA_5VX1 $T=-113000 313600 0 180 $X=-130230 $Y=308480
X60676 1 2 3202 4095 4101 4085 4140 FA_5VX1 $T=-112440 215040 1 180 $X=-129670 $Y=214400
X60677 1 2 3999 8785 3846 8792 4115 FA_5VX1 $T=-129240 268800 0 0 $X=-129670 $Y=268160
X60678 1 2 8790 8773 4105 4049 4143 FA_5VX1 $T=-112440 277760 1 180 $X=-129670 $Y=277120
X60679 1 2 4261 4015 8762 8763 4142 FA_5VX1 $T=-111880 250880 0 180 $X=-129110 $Y=245760
X60680 1 2 4262 8824 745 8807 4355 FA_5VX1 $T=-81080 277760 0 180 $X=-98310 $Y=272640
X60681 1 2 750 8778 3839 4280 4356 FA_5VX1 $T=-81080 313600 0 180 $X=-98310 $Y=308480
X60682 1 2 8833 8830 4269 750 8825 FA_5VX1 $T=-97320 295680 0 0 $X=-97750 $Y=295040
X60683 1 2 8810 8823 745 4418 8824 FA_5VX1 $T=-96760 268800 1 0 $X=-97190 $Y=263680
X60684 1 2 3897 4404 745 8832 4380 FA_5VX1 $T=-96200 268800 0 0 $X=-96630 $Y=268160
X60685 1 2 4418 4143 4322 4192 8822 FA_5VX1 $T=-79400 286720 0 180 $X=-96630 $Y=281600
X60686 1 2 8808 4403 4433 9943 8829 FA_5VX1 $T=-95640 53760 0 0 $X=-96070 $Y=53120
X60687 1 2 3848 4142 4228 8790 8823 FA_5VX1 $T=-78840 259840 1 180 $X=-96070 $Y=259200
X60688 1 2 8807 8822 4269 4230 8830 FA_5VX1 $T=-95640 295680 1 0 $X=-96070 $Y=290560
X60689 1 2 4280 8779 4210 4331 4376 FA_5VX1 $T=-77720 340480 1 180 $X=-94950 $Y=339840
X60690 1 2 4373 313 321 4473 8835 FA_5VX1 $T=-88920 17920 1 0 $X=-89350 $Y=12800
X60691 1 2 4366 4538 4671 8847 4432 FA_5VX1 $T=-88920 35840 1 0 $X=-89350 $Y=30720
X60692 1 2 4171 8835 8844 4506 4410 FA_5VX1 $T=-88920 35840 0 0 $X=-89350 $Y=35200
X60693 1 2 4316 8829 8849 4442 8836 FA_5VX1 $T=-88920 71680 1 0 $X=-89350 $Y=66560
X60694 1 2 4371 4471 4446 4499 4436 FA_5VX1 $T=-88920 277760 0 0 $X=-89350 $Y=277120
X60695 1 2 4437 4356 3839 8828 4419 FA_5VX1 $T=-71560 313600 1 180 $X=-88790 $Y=312960
X60696 1 2 4320 4410 8852 4490 4403 FA_5VX1 $T=-87800 44800 0 0 $X=-88230 $Y=44160
X60697 1 2 4528 8848 4269 4405 4465 FA_5VX1 $T=-67640 304640 1 180 $X=-84870 $Y=304000
X60698 1 2 4289 4516 3147 4532 8845 FA_5VX1 $T=-83320 62720 0 0 $X=-83750 $Y=62080
X60699 1 2 4382 8836 8854 8857 8846 FA_5VX1 $T=-83320 80640 1 0 $X=-83750 $Y=75520
X60700 1 2 4450 4355 4446 8833 4471 FA_5VX1 $T=-64280 277760 0 180 $X=-81510 $Y=272640
X60701 1 2 4499 8825 4269 4437 8848 FA_5VX1 $T=-63720 295680 1 180 $X=-80950 $Y=295040
X60702 1 2 4434 8845 3364 4562 4507 FA_5VX1 $T=-79960 89600 0 0 $X=-80390 $Y=88960
X60703 1 2 8838 8846 8859 8862 4513 FA_5VX1 $T=-79400 80640 0 0 $X=-79830 $Y=80000
X60704 1 2 4342 749 4219 4396 4003 FA_5VX1 $T=-61480 215040 0 180 $X=-78710 $Y=209920
X60705 1 2 8839 4513 4598 8864 4591 FA_5VX1 $T=-77720 89600 1 0 $X=-78150 $Y=84480
X60706 1 2 4468 330 338 4589 4538 FA_5VX1 $T=-76600 26880 1 0 $X=-77030 $Y=21760
X60707 1 2 8840 4468 4560 4590 8855 FA_5VX1 $T=-76600 26880 0 0 $X=-77030 $Y=26240
X60708 1 2 4288 322 342 4615 4516 FA_5VX1 $T=-74360 44800 1 0 $X=-74790 $Y=39680
X60709 1 2 8847 8866 347 348 4575 FA_5VX1 $T=-72120 35840 1 0 $X=-72550 $Y=30720
X60710 1 2 4635 334 326 324 4556 FA_5VX1 $T=-55320 53760 0 180 $X=-72550 $Y=48640
X60711 1 2 9855 4641 4635 330 4561 FA_5VX1 $T=-67640 62720 1 0 $X=-68070 $Y=57600
X60712 1 2 4486 4436 745 4528 4404 FA_5VX1 $T=-47480 277760 0 180 $X=-64710 $Y=272640
X60713 1 2 4523 348 8881 4717 4641 FA_5VX1 $T=-59800 53760 0 0 $X=-60230 $Y=53120
X60714 1 2 4687 330 339 4730 4474 FA_5VX1 $T=-58120 44800 0 0 $X=-58550 $Y=44160
X60715 1 2 4568 348 4725 8894 4648 FA_5VX1 $T=-57000 71680 0 0 $X=-57430 $Y=71040
X60716 1 2 8867 8893 4724 346 4725 FA_5VX1 $T=-54760 71680 1 0 $X=-55190 $Y=66560
X60717 1 2 4531 348 370 371 4590 FA_5VX1 $T=-50840 17920 1 0 $X=-51270 $Y=12800
X60718 1 2 8866 326 4652 4788 4730 FA_5VX1 $T=-48600 35840 1 0 $X=-49030 $Y=30720
X60719 1 2 4789 753 374 4851 4780 FA_5VX1 $T=-44120 26880 0 0 $X=-44550 $Y=26240
X60720 1 2 4731 4840 8927 4892 4803 FA_5VX1 $T=-43560 80640 0 0 $X=-43990 $Y=80000
X60721 1 2 4894 4825 8899 8891 4800 FA_5VX1 $T=-25640 197120 1 180 $X=-42870 $Y=196480
X60722 1 2 4790 8915 4822 4872 4758 FA_5VX1 $T=-41880 98560 1 0 $X=-42310 $Y=93440
X60723 1 2 4742 4852 4916 4859 8911 FA_5VX1 $T=-41320 53760 0 0 $X=-41750 $Y=53120
X60724 1 2 4746 8919 4991 4924 4831 FA_5VX1 $T=-41320 125440 1 0 $X=-41750 $Y=120320
X60725 1 2 4901 348 8898 4784 4806 FA_5VX1 $T=-24520 188160 1 180 $X=-41750 $Y=187520
X60726 1 2 4764 8908 8922 4885 4802 FA_5VX1 $T=-40760 44800 0 0 $X=-41190 $Y=44160
X60727 1 2 8901 8903 4886 4899 4726 FA_5VX1 $T=-39640 107520 0 0 $X=-40070 $Y=106880
X60728 1 2 4759 8920 4887 4831 4814 FA_5VX1 $T=-39640 134400 1 0 $X=-40070 $Y=129280
X60729 1 2 4808 8910 4871 4911 4738 FA_5VX1 $T=-37960 71680 1 0 $X=-38390 $Y=66560
X60730 1 2 8903 4873 339 9944 8919 FA_5VX1 $T=-36840 116480 1 0 $X=-37270 $Y=111360
X60731 1 2 8939 339 8913 8909 4939 FA_5VX1 $T=-17240 179200 1 180 $X=-34470 $Y=178560
X60732 1 2 8908 4930 8947 4873 4852 FA_5VX1 $T=-32920 44800 1 0 $X=-33350 $Y=39680
X60733 1 2 8910 4931 5051 4873 4840 FA_5VX1 $T=-32920 80640 1 0 $X=-33350 $Y=75520
X60734 1 2 4936 326 4839 8912 4900 FA_5VX1 $T=-16120 170240 0 180 $X=-33350 $Y=165120
X60735 1 2 4822 4934 326 8942 4886 FA_5VX1 $T=-32360 89600 1 0 $X=-32790 $Y=84480
X60736 1 2 4844 8936 4945 4557 4915 FA_5VX1 $T=-32360 304640 1 0 $X=-32790 $Y=299520
X60737 1 2 753 4873 4898 8944 4885 FA_5VX1 $T=-31800 35840 1 0 $X=-32230 $Y=30720
X60738 1 2 4887 4938 8949 4873 4880 FA_5VX1 $T=-31800 125440 0 0 $X=-32230 $Y=124800
X60739 1 2 8915 4913 348 4873 4899 FA_5VX1 $T=-29560 98560 0 0 $X=-29990 $Y=97920
X60740 1 2 4859 8932 755 8955 4911 FA_5VX1 $T=-27880 62720 1 0 $X=-28310 $Y=57600
X60741 1 2 4879 379 382 350 4948 FA_5VX1 $T=-27320 26880 0 0 $X=-27750 $Y=26240
X60742 1 2 8922 8948 4976 339 4916 FA_5VX1 $T=-25640 53760 1 0 $X=-26070 $Y=48640
X60743 1 2 377 339 381 384 8944 FA_5VX1 $T=-25080 17920 1 0 $X=-25510 $Y=12800
X60744 1 2 4908 4979 4834 8961 4967 FA_5VX1 $T=-25080 313600 0 0 $X=-25510 $Y=312960
X60745 1 2 4898 326 4963 756 8948 FA_5VX1 $T=-23960 44800 0 0 $X=-24390 $Y=44160
X60746 1 2 4851 348 8934 380 4930 FA_5VX1 $T=-4920 17920 1 180 $X=-22150 $Y=17280
X60747 1 2 5013 346 4935 9859 4953 FA_5VX1 $T=-4920 143360 1 180 $X=-22150 $Y=142720
X60748 1 2 8934 362 5028 5032 8958 FA_5VX1 $T=-21160 26880 1 0 $X=-21590 $Y=21760
X60749 1 2 9944 8962 362 346 4991 FA_5VX1 $T=-20040 116480 1 0 $X=-20470 $Y=111360
X60750 1 2 9035 8972 4856 8940 4999 FA_5VX1 $T=-1560 286720 1 180 $X=-18790 $Y=286080
X60751 1 2 8940 4834 4970 5059 8960 FA_5VX1 $T=-18360 295680 1 0 $X=-18790 $Y=290560
X60752 1 2 4985 8969 4945 8983 5014 FA_5VX1 $T=-17800 322560 0 0 $X=-18230 $Y=321920
X60753 1 2 4963 353 392 389 5020 FA_5VX1 $T=-16120 44800 1 0 $X=-16550 $Y=39680
X60754 1 2 8947 8958 388 346 755 FA_5VX1 $T=-15560 35840 0 0 $X=-15990 $Y=35200
X60755 1 2 4892 5052 5021 5080 4872 FA_5VX1 $T=-15560 80640 1 0 $X=-15990 $Y=75520
X60756 1 2 5042 8975 5059 4557 8972 FA_5VX1 $T=-15560 268800 0 0 $X=-15990 $Y=268160
X60757 1 2 5084 5029 5073 348 8977 FA_5VX1 $T=-13880 179200 1 0 $X=-14310 $Y=174080
X60758 1 2 4986 8987 757 8991 5046 FA_5VX1 $T=-12760 340480 1 0 $X=-13190 $Y=335360
X60759 1 2 8955 346 397 8993 4917 FA_5VX1 $T=-12200 53760 0 0 $X=-12630 $Y=53120
X60760 1 2 5117 362 5022 8963 5033 FA_5VX1 $T=7960 125440 0 180 $X=-9270 $Y=120320
X60761 1 2 5068 8992 5026 9945 5103 FA_5VX1 $T=-7720 358400 1 0 $X=-8150 $Y=353280
X60762 1 2 5102 8977 5029 4997 5085 FA_5VX1 $T=9640 188160 0 180 $X=-7590 $Y=183040
X60763 1 2 5127 4977 8979 8974 8984 FA_5VX1 $T=11320 98560 1 180 $X=-5910 $Y=97920
X60764 1 2 5185 5084 5058 5055 8989 FA_5VX1 $T=12440 179200 1 180 $X=-4790 $Y=178560
X60765 1 2 5063 9007 9019 348 5055 FA_5VX1 $T=-3240 170240 0 0 $X=-3670 $Y=169600
X60766 1 2 5051 9005 362 5137 5080 FA_5VX1 $T=-2680 71680 0 0 $X=-3110 $Y=71040
X60767 1 2 5075 8996 4857 5158 5136 FA_5VX1 $T=-2680 367360 0 0 $X=-3110 $Y=366720
X60768 1 2 5195 339 5083 326 5128 FA_5VX1 $T=15800 170240 0 180 $X=-1430 $Y=165120
X60769 1 2 5203 9018 5096 5086 5133 FA_5VX1 $T=15800 232960 0 180 $X=-1430 $Y=227840
X60770 1 2 5101 5165 5164 5180 9001 FA_5VX1 $T=120 80640 0 0 $X=-310 $Y=80000
X60771 1 2 9026 9021 8989 5102 5119 FA_5VX1 $T=17480 197120 0 180 $X=250 $Y=192000
X60772 1 2 5240 5114 5112 8995 5179 FA_5VX1 $T=20840 35840 1 180 $X=3610 $Y=35200
X60773 1 2 5217 351 398 9000 9017 FA_5VX1 $T=21960 62720 0 180 $X=4730 $Y=57600
X60774 1 2 5263 5221 9003 5089 5177 FA_5VX1 $T=23080 313600 0 180 $X=5850 $Y=308480
X60775 1 2 5250 9030 4557 5134 9018 FA_5VX1 $T=23640 241920 0 180 $X=6410 $Y=236800
X60776 1 2 5143 5227 9037 5171 5199 FA_5VX1 $T=6840 349440 0 0 $X=6410 $Y=348800
X60777 1 2 5281 9038 5128 5063 5168 FA_5VX1 $T=24760 179200 0 180 $X=7530 $Y=174080
X60778 1 2 5152 9014 5264 5262 764 FA_5VX1 $T=7960 349440 1 0 $X=7530 $Y=344320
X60779 1 2 5167 5246 4987 5205 5223 FA_5VX1 $T=9640 394240 1 0 $X=9210 $Y=389120
X60780 1 2 5198 362 403 9048 5242 FA_5VX1 $T=12440 107520 0 0 $X=12010 $Y=106880
X60781 1 2 5333 5177 5192 5135 9036 FA_5VX1 $T=30360 322560 1 180 $X=13130 $Y=321920
X60782 1 2 9052 5029 5198 9020 5225 FA_5VX1 $T=30920 143360 1 180 $X=13690 $Y=142720
X60783 1 2 5189 9028 5320 5223 5276 FA_5VX1 $T=14120 385280 0 0 $X=13690 $Y=384640
X60784 1 2 5332 5313 9022 5122 5221 FA_5VX1 $T=31480 304640 0 180 $X=14250 $Y=299520
X60785 1 2 5342 9036 9860 5157 5227 FA_5VX1 $T=31480 340480 0 180 $X=14250 $Y=335360
X60786 1 2 5330 339 5208 5181 5258 FA_5VX1 $T=32600 125440 0 180 $X=15370 $Y=120320
X60787 1 2 9060 5209 5214 5029 9038 FA_5VX1 $T=32600 170240 0 180 $X=15370 $Y=165120
X60788 1 2 9932 9054 5220 9029 5304 FA_5VX1 $T=34280 224000 0 180 $X=17050 $Y=218880
X60789 1 2 9061 346 5217 9031 9044 FA_5VX1 $T=34840 89600 1 180 $X=17610 $Y=88960
X60790 1 2 5212 5330 5334 5323 5303 FA_5VX1 $T=18040 116480 0 0 $X=17610 $Y=115840
X60791 1 2 5357 9041 5231 5225 5311 FA_5VX1 $T=35400 161280 0 180 $X=18170 $Y=156160
X60792 1 2 5231 8998 5242 5230 5290 FA_5VX1 $T=36520 152320 1 180 $X=19290 $Y=151680
X60793 1 2 5237 326 5286 5345 5323 FA_5VX1 $T=20280 107520 1 0 $X=19850 $Y=102400
X60794 1 2 5385 9053 5253 9032 5314 FA_5VX1 $T=37640 376320 1 180 $X=20410 $Y=375680
X60795 1 2 9069 5199 5275 9039 9053 FA_5VX1 $T=38760 358400 1 180 $X=21530 $Y=357760
X60796 1 2 5248 5370 5365 9067 5424 FA_5VX1 $T=22520 62720 0 0 $X=22090 $Y=62080
X60797 1 2 5404 9061 5257 5270 5322 FA_5VX1 $T=39320 89600 0 180 $X=22090 $Y=84480
X60798 1 2 5352 9060 5195 5290 5259 FA_5VX1 $T=39320 170240 1 180 $X=22090 $Y=169600
X60799 1 2 5397 9064 5282 5272 9054 FA_5VX1 $T=40440 215040 0 180 $X=23210 $Y=209920
X60800 1 2 5370 362 9047 4948 5270 FA_5VX1 $T=41000 35840 1 180 $X=23770 $Y=35200
X60801 1 2 5415 5298 4879 406 5308 FA_5VX1 $T=41000 44800 1 180 $X=23770 $Y=44160
X60802 1 2 5393 5237 5288 9044 5338 FA_5VX1 $T=41000 98560 1 180 $X=23770 $Y=97920
X60803 1 2 5419 9862 5292 5210 9056 FA_5VX1 $T=41000 206080 0 180 $X=23770 $Y=200960
X60804 1 2 5389 348 5297 9946 5289 FA_5VX1 $T=41560 134400 1 180 $X=24330 $Y=133760
X60805 1 2 5394 5389 5184 5258 5346 FA_5VX1 $T=42120 134400 0 180 $X=24890 $Y=129280
X60806 1 2 5347 9052 5243 5289 5348 FA_5VX1 $T=42120 152320 0 180 $X=24890 $Y=147200
X60807 1 2 5374 9056 5260 9050 9064 FA_5VX1 $T=43800 215040 1 180 $X=26570 $Y=214400
X60808 1 2 5403 9057 5172 5315 5431 FA_5VX1 $T=43800 394240 0 180 $X=26570 $Y=389120
X60809 1 2 9947 9072 9059 5125 5313 FA_5VX1 $T=46600 286720 0 180 $X=29370 $Y=281600
X60810 1 2 5527 5433 9863 9080 9862 FA_5VX1 $T=30360 197120 1 0 $X=29930 $Y=192000
X60811 1 2 5353 5429 5475 9090 5421 FA_5VX1 $T=31480 304640 1 0 $X=31050 $Y=299520
X60812 1 2 9918 9063 5264 9088 9076 FA_5VX1 $T=31480 376320 1 0 $X=31050 $Y=371200
X60813 1 2 5482 5251 5148 5133 9072 FA_5VX1 $T=48840 277760 1 180 $X=31610 $Y=277120
X60814 1 2 9104 9081 5376 5045 9075 FA_5VX1 $T=50520 259840 0 180 $X=33290 $Y=254720
X60815 1 2 5375 5250 9096 5509 5450 FA_5VX1 $T=35400 250880 1 0 $X=34970 $Y=245760
X60816 1 2 9115 9075 5390 5376 9078 FA_5VX1 $T=53320 277760 0 180 $X=36090 $Y=272640
X60817 1 2 5530 5510 5353 5332 5451 FA_5VX1 $T=53880 295680 1 180 $X=36650 $Y=295040
X60818 1 2 5483 9078 5390 9112 5429 FA_5VX1 $T=37640 286720 0 0 $X=37210 $Y=286080
X60819 1 2 5541 5314 9073 5403 5454 FA_5VX1 $T=55000 385280 1 180 $X=37770 $Y=384640
X60820 1 2 5399 9097 9107 9948 5485 FA_5VX1 $T=38760 322560 0 0 $X=38330 $Y=321920
X60821 1 2 5412 5518 5533 5489 5490 FA_5VX1 $T=39880 89600 1 0 $X=39450 $Y=84480
X60822 1 2 5484 5421 5452 9082 9097 FA_5VX1 $T=60040 313600 0 180 $X=42810 $Y=308480
X60823 1 2 9082 5376 5583 5555 9107 FA_5VX1 $T=43800 313600 0 0 $X=43370 $Y=312960
X60824 1 2 9130 9122 9085 5453 5433 FA_5VX1 $T=61160 188160 1 180 $X=43930 $Y=187520
X60825 1 2 5608 9113 5399 5333 9101 FA_5VX1 $T=61160 322560 0 180 $X=43930 $Y=317440
X60826 1 2 5465 5554 5581 5590 5537 FA_5VX1 $T=45480 268800 0 0 $X=45050 $Y=268160
X60827 1 2 5479 9124 9132 5502 5535 FA_5VX1 $T=46600 161280 1 0 $X=46170 $Y=156160
X60828 1 2 5590 9129 5483 9947 5510 FA_5VX1 $T=63400 286720 0 180 $X=46170 $Y=281600
X60829 1 2 5607 5451 5484 5263 9113 FA_5VX1 $T=63400 304640 1 180 $X=46170 $Y=304000
X60830 1 2 5672 9101 9093 5342 9108 FA_5VX1 $T=63400 331520 0 180 $X=46170 $Y=326400
X60831 1 2 5557 5490 9094 9864 5528 FA_5VX1 $T=64520 107520 1 180 $X=47290 $Y=106880
X60832 1 2 5626 9108 9095 5143 9109 FA_5VX1 $T=64520 349440 0 180 $X=47290 $Y=344320
X60833 1 2 5611 5597 769 5434 5518 FA_5VX1 $T=65080 53760 1 180 $X=47850 $Y=53120
X60834 1 2 5623 5535 5506 5468 9122 FA_5VX1 $T=65640 179200 0 180 $X=48410 $Y=174080
X60835 1 2 5653 9109 9099 9069 9116 FA_5VX1 $T=65640 358400 1 180 $X=48410 $Y=357760
X60836 1 2 9142 9116 9098 5385 9123 FA_5VX1 $T=65640 376320 0 180 $X=48410 $Y=371200
X60837 1 2 9095 5576 5569 5627 9125 FA_5VX1 $T=49400 349440 0 0 $X=48970 $Y=348800
X60838 1 2 5664 9123 5488 5541 5548 FA_5VX1 $T=66200 385280 0 180 $X=48970 $Y=380160
X60839 1 2 5544 5528 9103 5505 9124 FA_5VX1 $T=66760 143360 1 180 $X=49530 $Y=142720
X60840 1 2 9098 9128 5615 5632 5515 FA_5VX1 $T=49960 367360 0 0 $X=49530 $Y=366720
X60841 1 2 5660 5450 9104 5203 5559 FA_5VX1 $T=67320 259840 0 180 $X=50090 $Y=254720
X60842 1 2 9093 5485 9135 9140 5576 FA_5VX1 $T=50520 331520 0 0 $X=50090 $Y=330880
X60843 1 2 9099 9125 9136 5640 9128 FA_5VX1 $T=50520 367360 1 0 $X=50090 $Y=362240
X60844 1 2 9140 5615 5546 5235 5569 FA_5VX1 $T=67880 340480 1 180 $X=50650 $Y=339840
X60845 1 2 5592 5454 763 5494 5705 FA_5VX1 $T=67880 394240 0 180 $X=50650 $Y=389120
X60846 1 2 9090 5555 5546 5045 5452 FA_5VX1 $T=52200 304640 1 0 $X=51770 $Y=299520
X60847 1 2 5685 5482 9115 5559 9129 FA_5VX1 $T=70120 277760 0 180 $X=52890 $Y=272640
X60848 1 2 9948 5390 5615 5583 9135 FA_5VX1 $T=55560 322560 0 0 $X=55130 $Y=321920
X60849 1 2 9867 420 5255 9126 5597 FA_5VX1 $T=74600 44800 0 180 $X=57370 $Y=39680
X60850 1 2 5753 5548 5603 5592 5647 FA_5VX1 $T=76840 385280 1 180 $X=59610 $Y=384640
X60851 1 2 4540 9151 5749 6919 9147 FA_5VX1 $T=62840 116480 0 0 $X=62410 $Y=115840
X60852 1 2 4613 5739 5765 5769 9153 FA_5VX1 $T=65080 206080 0 0 $X=64650 $Y=205440
X60853 1 2 4326 9147 5777 4921 5731 FA_5VX1 $T=66760 143360 0 0 $X=66330 $Y=142720
X60854 1 2 6058 9155 5679 5672 5726 FA_5VX1 $T=85240 322560 0 180 $X=68010 $Y=317440
X60855 1 2 5827 9159 5686 5608 9155 FA_5VX1 $T=85800 304640 0 180 $X=68570 $Y=299520
X60856 1 2 5684 9162 5805 9949 5770 FA_5VX1 $T=70120 259840 0 0 $X=69690 $Y=259200
X60857 1 2 5832 5537 5695 5530 5740 FA_5VX1 $T=86920 277760 0 180 $X=69690 $Y=272640
X60858 1 2 5825 5685 9149 5691 5554 FA_5VX1 $T=87480 268800 0 180 $X=70250 $Y=263680
X60859 1 2 5826 5740 5696 5607 9159 FA_5VX1 $T=87480 295680 0 180 $X=70250 $Y=290560
X60860 1 2 9172 5660 772 5444 5691 FA_5VX1 $T=88040 241920 1 180 $X=70810 $Y=241280
X60861 1 2 9145 5787 5469 772 9162 FA_5VX1 $T=71240 250880 0 0 $X=70810 $Y=250240
X60862 1 2 4605 9167 5831 5839 9164 FA_5VX1 $T=72920 179200 1 0 $X=72490 $Y=174080
X60863 1 2 4479 9168 5837 5849 9167 FA_5VX1 $T=74040 161280 1 0 $X=73610 $Y=156160
X60864 1 2 5715 5820 5745 9175 9163 FA_5VX1 $T=74040 304640 0 0 $X=73610 $Y=304000
X60865 1 2 4428 5731 9177 5871 9168 FA_5VX1 $T=75720 152320 0 0 $X=75290 $Y=151680
X60866 1 2 4520 9164 5852 5860 9169 FA_5VX1 $T=75720 188160 0 0 $X=75290 $Y=187520
X60867 1 2 5819 5840 5745 772 5724 FA_5VX1 $T=92520 277760 1 180 $X=75290 $Y=277120
X60868 1 2 5867 5647 5747 9158 5851 FA_5VX1 $T=92520 385280 0 180 $X=75290 $Y=380160
X60869 1 2 5743 5842 5857 5868 5822 FA_5VX1 $T=76840 35840 0 0 $X=76410 $Y=35200
X60870 1 2 6136 5808 5773 5653 5855 FA_5VX1 $T=95880 358400 0 180 $X=78650 $Y=353280
X60871 1 2 9195 348 438 339 5816 FA_5VX1 $T=96440 26880 0 180 $X=79210 $Y=21760
X60872 1 2 5916 5726 9166 5626 5808 FA_5VX1 $T=97000 331520 1 180 $X=79770 $Y=330880
X60873 1 2 5940 9180 5786 5816 5834 FA_5VX1 $T=97560 26880 1 180 $X=80330 $Y=26240
X60874 1 2 4449 9169 5912 5922 5861 FA_5VX1 $T=81880 206080 0 0 $X=81450 $Y=205440
X60875 1 2 5782 5907 5919 5858 5878 FA_5VX1 $T=82440 62720 0 0 $X=82010 $Y=62080
X60876 1 2 4505 5861 5929 5938 5739 FA_5VX1 $T=83000 197120 0 0 $X=82570 $Y=196480
X60877 1 2 5799 5906 5864 5874 5883 FA_5VX1 $T=83560 340480 1 0 $X=83130 $Y=335360
X60878 1 2 9197 9191 442 339 5858 FA_5VX1 $T=100920 53760 0 180 $X=83690 $Y=48640
X60879 1 2 5803 9189 5918 9197 5843 FA_5VX1 $T=84680 53760 0 0 $X=84250 $Y=53120
X60880 1 2 5806 5923 5661 5943 5895 FA_5VX1 $T=84680 286720 1 0 $X=84250 $Y=281600
X60881 1 2 5786 444 446 346 5856 FA_5VX1 $T=85240 17920 1 0 $X=84810 $Y=12800
X60882 1 2 5725 5927 5847 9202 5812 FA_5VX1 $T=85800 322560 1 0 $X=85370 $Y=317440
X60883 1 2 9949 5766 5951 5469 5863 FA_5VX1 $T=86920 259840 0 0 $X=86490 $Y=259200
X60884 1 2 6128 5855 9176 9142 9184 FA_5VX1 $T=103720 376320 0 180 $X=86490 $Y=371200
X60885 1 2 5835 9198 5904 5935 5884 FA_5VX1 $T=87480 80640 0 0 $X=87050 $Y=80000
X60886 1 2 5857 326 5956 450 5918 FA_5VX1 $T=88040 44800 0 0 $X=87610 $Y=44160
X60887 1 2 5669 9194 5766 9207 5807 FA_5VX1 $T=88040 286720 0 0 $X=87610 $Y=286080
X60888 1 2 6113 9184 5876 5664 5902 FA_5VX1 $T=105400 376320 1 180 $X=88170 $Y=375680
X60889 1 2 5846 9201 5971 9933 9193 FA_5VX1 $T=89160 268800 0 0 $X=88730 $Y=268160
X60890 1 2 5842 5904 445 5856 9189 FA_5VX1 $T=107080 17920 1 180 $X=89850 $Y=17280
X60891 1 2 6004 5503 9178 5900 5879 FA_5VX1 $T=107640 241920 0 180 $X=90410 $Y=236800
X60892 1 2 9214 9172 5894 5879 5880 FA_5VX1 $T=108760 241920 1 180 $X=91530 $Y=241280
X60893 1 2 6008 5825 9181 5880 9196 FA_5VX1 $T=108760 250880 1 180 $X=91530 $Y=250240
X60894 1 2 9180 5904 455 348 5868 FA_5VX1 $T=94200 35840 1 0 $X=93770 $Y=30720
X60895 1 2 9181 5999 5971 5983 9201 FA_5VX1 $T=94200 259840 1 0 $X=93770 $Y=254720
X60896 1 2 9869 9193 5901 5806 5952 FA_5VX1 $T=111000 277760 1 180 $X=93770 $Y=277120
X60897 1 2 5887 9209 5848 9218 5932 FA_5VX1 $T=94200 358400 0 0 $X=93770 $Y=357760
X60898 1 2 6031 9196 5846 5465 6055 FA_5VX1 $T=111560 268800 0 180 $X=94330 $Y=263680
X60899 1 2 5915 5971 9227 6016 9211 FA_5VX1 $T=97560 313600 1 0 $X=97130 $Y=308480
X60900 1 2 5936 9220 6030 6018 6086 FA_5VX1 $T=98120 125440 1 0 $X=97690 $Y=120320
X60901 1 2 5905 9204 6064 6012 5969 FA_5VX1 $T=98680 89600 1 0 $X=98250 $Y=84480
X60902 1 2 9229 9195 448 9199 5964 FA_5VX1 $T=116600 26880 0 180 $X=99370 $Y=21760
X60903 1 2 5935 6038 6063 6037 6012 FA_5VX1 $T=99800 71680 0 0 $X=99370 $Y=71040
X60904 1 2 5947 5983 6016 5923 9216 FA_5VX1 $T=100360 295680 1 0 $X=99930 $Y=290560
X60905 1 2 9233 5984 9205 326 6018 FA_5VX1 $T=118280 107520 1 180 $X=101050 $Y=106880
X60906 1 2 5939 9215 9870 6060 9221 FA_5VX1 $T=101480 385280 0 0 $X=101050 $Y=384640
X60907 1 2 9191 6199 461 6049 5877 FA_5VX1 $T=102040 53760 1 0 $X=101610 $Y=48640
X60908 1 2 6063 9210 5968 362 6064 FA_5VX1 $T=118840 80640 0 180 $X=101610 $Y=75520
X60909 1 2 5959 9224 9233 4739 5981 FA_5VX1 $T=102040 107520 1 0 $X=101610 $Y=102400
X60910 1 2 9205 346 359 366 6030 FA_5VX1 $T=102040 116480 1 0 $X=101610 $Y=111360
X60911 1 2 9204 6074 6051 6095 9224 FA_5VX1 $T=102600 89600 0 0 $X=102170 $Y=88960
X60912 1 2 6102 9213 9208 348 6021 FA_5VX1 $T=119400 98560 0 180 $X=102170 $Y=93440
X60913 1 2 5919 6101 366 463 6037 FA_5VX1 $T=103160 62720 1 0 $X=102730 $Y=57600
X60914 1 2 9248 6081 6073 9238 6043 FA_5VX1 $T=103160 322560 0 0 $X=102730 $Y=321920
X60915 1 2 9210 366 351 353 6051 FA_5VX1 $T=104280 80640 0 0 $X=103850 $Y=80000
X60916 1 2 5972 6090 5833 9241 6060 FA_5VX1 $T=104280 376320 1 0 $X=103850 $Y=371200
X60917 1 2 9246 5902 5991 5753 9223 FA_5VX1 $T=121080 385280 0 180 $X=103850 $Y=380160
X60918 1 2 5982 9214 9240 6183 6054 FA_5VX1 $T=104840 250880 1 0 $X=104410 $Y=245760
X60919 1 2 6072 5952 5895 5947 9225 FA_5VX1 $T=121640 286720 1 180 $X=104410 $Y=286080
X60920 1 2 6029 9225 9216 5915 6056 FA_5VX1 $T=123880 304640 0 180 $X=106650 $Y=299520
X60921 1 2 6080 9227 5943 6009 6073 FA_5VX1 $T=123880 313600 1 180 $X=106650 $Y=312960
X60922 1 2 5894 6041 5983 5661 5999 FA_5VX1 $T=125560 250880 1 180 $X=108330 $Y=250240
X60923 1 2 6168 9244 6029 5827 9230 FA_5VX1 $T=125560 295680 1 180 $X=108330 $Y=295040
X60924 1 2 6159 6055 9869 5832 9232 FA_5VX1 $T=126120 277760 0 180 $X=108890 $Y=272640
X60925 1 2 9251 9245 9227 6020 9234 FA_5VX1 $T=127240 340480 1 180 $X=110010 $Y=339840
X60926 1 2 5991 9872 6017 779 6114 FA_5VX1 $T=111000 394240 0 0 $X=110570 $Y=393600
X60927 1 2 6206 9232 6072 5826 9244 FA_5VX1 $T=130040 286720 0 180 $X=112810 $Y=281600
X60928 1 2 6207 9230 6057 6058 6111 FA_5VX1 $T=130040 304640 1 180 $X=112810 $Y=304000
X60929 1 2 6143 6043 9228 6211 9245 FA_5VX1 $T=130040 340480 0 180 $X=112810 $Y=335360
X60930 1 2 6057 6056 9211 6080 6081 FA_5VX1 $T=131720 313600 0 180 $X=114490 $Y=308480
X60931 1 2 6092 6203 6198 6194 6165 FA_5VX1 $T=117160 152320 1 0 $X=116730 $Y=147200
X60932 1 2 9265 472 319 350 6124 FA_5VX1 $T=135080 26880 0 180 $X=117850 $Y=21760
X60933 1 2 6129 353 320 464 6139 FA_5VX1 $T=135080 35840 0 180 $X=117850 $Y=30720
X60934 1 2 465 6198 477 9265 476 FA_5VX1 $T=118840 17920 1 0 $X=118410 $Y=12800
X60935 1 2 6659 6192 6082 6113 9253 FA_5VX1 $T=135640 367360 1 180 $X=118410 $Y=366720
X60936 1 2 6229 359 350 466 6125 FA_5VX1 $T=136200 44800 0 180 $X=118970 $Y=39680
X60937 1 2 6119 326 366 362 6163 FA_5VX1 $T=136200 107520 0 180 $X=118970 $Y=102400
X60938 1 2 481 4739 6124 467 6169 FA_5VX1 $T=136760 17920 1 180 $X=119530 $Y=17280
X60939 1 2 6115 366 351 468 6130 FA_5VX1 $T=136760 44800 1 180 $X=119530 $Y=44160
X60940 1 2 9276 470 6125 6115 6170 FA_5VX1 $T=136760 53760 0 180 $X=119530 $Y=48640
X60941 1 2 9269 346 359 469 6131 FA_5VX1 $T=136760 71680 1 180 $X=119530 $Y=71040
X60942 1 2 6106 6198 6186 9269 6225 FA_5VX1 $T=119960 80640 1 0 $X=119530 $Y=75520
X60943 1 2 782 348 346 470 9255 FA_5VX1 $T=136760 134400 0 180 $X=119530 $Y=129280
X60944 1 2 6548 6111 9248 5916 9256 FA_5VX1 $T=136760 322560 1 180 $X=119530 $Y=321920
X60945 1 2 6287 475 6129 471 6177 FA_5VX1 $T=137320 26880 1 180 $X=120090 $Y=26240
X60946 1 2 6248 474 6130 6118 6178 FA_5VX1 $T=137320 62720 0 180 $X=120090 $Y=57600
X60947 1 2 6239 4739 6131 6119 6226 FA_5VX1 $T=137320 98560 0 180 $X=120090 $Y=93440
X60948 1 2 6234 6163 473 339 6189 FA_5VX1 $T=137320 98560 1 180 $X=120090 $Y=97920
X60949 1 2 6241 6004 6195 6190 6183 FA_5VX1 $T=137320 232960 0 180 $X=120090 $Y=227840
X60950 1 2 6244 6161 9873 6123 9257 FA_5VX1 $T=137320 358400 1 180 $X=120090 $Y=357760
X60951 1 2 6721 9253 6137 9246 6161 FA_5VX1 $T=137320 376320 1 180 $X=120090 $Y=375680
X60952 1 2 6288 473 6139 6229 6184 FA_5VX1 $T=137880 35840 1 180 $X=120650 $Y=35200
X60953 1 2 6118 362 353 472 6186 FA_5VX1 $T=137880 62720 1 180 $X=120650 $Y=62080
X60954 1 2 6122 9264 9268 6195 6210 FA_5VX1 $T=121080 268800 0 0 $X=120650 $Y=268160
X60955 1 2 6638 9260 9251 6128 6192 FA_5VX1 $T=137880 349440 0 180 $X=120650 $Y=344320
X60956 1 2 6123 9223 9266 5867 9261 FA_5VX1 $T=121080 385280 1 0 $X=120650 $Y=380160
X60957 1 2 9277 9254 6021 6108 6193 FA_5VX1 $T=138440 125440 0 180 $X=121210 $Y=120320
X60958 1 2 6216 6087 326 339 6194 FA_5VX1 $T=138440 152320 1 180 $X=121210 $Y=151680
X60959 1 2 6109 6191 6135 6195 9263 FA_5VX1 $T=121640 250880 1 0 $X=121210 $Y=245760
X60960 1 2 9281 6146 6153 6135 6196 FA_5VX1 $T=138440 259840 1 180 $X=121210 $Y=259200
X60961 1 2 6228 9258 6146 9272 6215 FA_5VX1 $T=121640 286720 0 0 $X=121210 $Y=286080
X60962 1 2 6620 9256 6143 6136 9260 FA_5VX1 $T=138440 331520 0 180 $X=121210 $Y=326400
X60963 1 2 6481 6008 6410 6054 9875 FA_5VX1 $T=168680 241920 1 180 $X=151450 $Y=241280
X60964 1 2 6399 9263 9280 9281 6232 FA_5VX1 $T=168680 250880 0 180 $X=151450 $Y=245760
X60965 1 2 6400 9875 6242 6031 6325 FA_5VX1 $T=168680 250880 1 180 $X=151450 $Y=250240
X60966 1 2 6401 6325 6243 6159 9294 FA_5VX1 $T=168680 268800 1 180 $X=151450 $Y=268160
X60967 1 2 6413 9294 6273 6206 6333 FA_5VX1 $T=169240 277760 1 180 $X=152010 $Y=277120
X60968 1 2 6420 9300 6048 9289 6342 FA_5VX1 $T=169800 358400 0 180 $X=152570 $Y=353280
X60969 1 2 6326 9315 9268 6274 6341 FA_5VX1 $T=170360 295680 0 180 $X=153130 $Y=290560
X60970 1 2 6414 9257 6048 6286 9300 FA_5VX1 $T=170920 358400 1 180 $X=153690 $Y=357760
X60971 1 2 6286 9261 6258 5973 6329 FA_5VX1 $T=170920 385280 0 180 $X=153690 $Y=380160
X60972 1 2 6458 6227 6280 6429 6382 FA_5VX1 $T=175400 215040 1 180 $X=158170 $Y=214400
X60973 1 2 6460 6335 6224 6285 6479 FA_5VX1 $T=176520 313600 0 180 $X=159290 $Y=308480
X60974 1 2 6473 488 6352 6251 9314 FA_5VX1 $T=177080 17920 1 180 $X=159850 $Y=17280
X60975 1 2 6447 9314 6359 6312 6393 FA_5VX1 $T=177640 35840 0 180 $X=160410 $Y=30720
X60976 1 2 6493 9329 6375 9877 6516 FA_5VX1 $T=181000 71680 0 180 $X=163770 $Y=66560
X60977 1 2 6407 6393 6406 9317 9329 FA_5VX1 $T=183240 44800 1 180 $X=166010 $Y=44160
X60978 1 2 9950 6241 6397 6382 6417 FA_5VX1 $T=183240 224000 0 180 $X=166010 $Y=218880
X60979 1 2 9350 9340 6388 6261 9331 FA_5VX1 $T=184360 152320 0 180 $X=167130 $Y=147200
X60980 1 2 9342 6419 6349 9319 6552 FA_5VX1 $T=184360 313600 1 180 $X=167130 $Y=312960
X60981 1 2 9347 9331 9321 6387 9333 FA_5VX1 $T=186040 161280 0 180 $X=168810 $Y=156160
X60982 1 2 9353 5982 6409 6417 787 FA_5VX1 $T=186040 224000 1 180 $X=168810 $Y=223360
X60983 1 2 9951 9333 6396 9325 6480 FA_5VX1 $T=187160 179200 1 180 $X=169930 $Y=178560
X60984 1 2 6532 9345 9328 6363 6485 FA_5VX1 $T=188280 98560 0 180 $X=171050 $Y=93440
X60985 1 2 6575 9337 6268 6435 6496 FA_5VX1 $T=188280 331520 0 180 $X=171050 $Y=326400
X60986 1 2 6550 6544 9330 6383 9340 FA_5VX1 $T=189400 125440 1 180 $X=172170 $Y=124800
X60987 1 2 6574 6333 6456 6168 9341 FA_5VX1 $T=189960 295680 0 180 $X=172730 $Y=290560
X60988 1 2 9358 6481 9334 787 6495 FA_5VX1 $T=191080 232960 0 180 $X=173850 $Y=227840
X60989 1 2 6605 9341 6488 6207 6523 FA_5VX1 $T=193320 304640 0 180 $X=176090 $Y=299520
X60990 1 2 9952 6400 9338 6495 9349 FA_5VX1 $T=195000 232960 1 180 $X=177770 $Y=232320
X60991 1 2 6566 6516 6452 6436 9345 FA_5VX1 $T=195560 80640 1 180 $X=178330 $Y=80000
X60992 1 2 6576 6485 6497 6371 6539 FA_5VX1 $T=195560 107520 1 180 $X=178330 $Y=106880
X60993 1 2 6582 6617 6275 6511 6536 FA_5VX1 $T=197240 340480 0 180 $X=180010 $Y=335360
X60994 1 2 6873 9349 9881 6401 6559 FA_5VX1 $T=197800 241920 1 180 $X=180570 $Y=241280
X60995 1 2 6525 9365 6465 6571 6655 FA_5VX1 $T=183800 349440 1 0 $X=183370 $Y=344320
X60996 1 2 6649 9356 6525 6536 6596 FA_5VX1 $T=201160 331520 1 180 $X=183930 $Y=330880
X60997 1 2 6660 9367 498 6543 6592 FA_5VX1 $T=201720 71680 0 180 $X=184490 $Y=66560
X60998 1 2 6673 506 502 499 9361 FA_5VX1 $T=202840 26880 0 180 $X=185610 $Y=21760
X60999 1 2 6665 6523 6562 6548 6607 FA_5VX1 $T=202840 304640 1 180 $X=185610 $Y=304000
X61000 1 2 9381 9361 505 503 9367 FA_5VX1 $T=205080 53760 0 180 $X=187850 $Y=48640
X61001 1 2 6614 6539 6533 6408 6544 FA_5VX1 $T=205640 125440 0 180 $X=188410 $Y=120320
X61002 1 2 6661 6592 6002 6584 6629 FA_5VX1 $T=207320 89600 1 180 $X=190090 $Y=88960
X61003 1 2 9397 6559 6602 6413 9371 FA_5VX1 $T=207880 250880 0 180 $X=190650 $Y=245760
X61004 1 2 6653 9371 6612 6574 6641 FA_5VX1 $T=208440 250880 1 180 $X=191210 $Y=250240
X61005 1 2 9386 9370 6557 6604 9884 FA_5VX1 $T=208440 286720 1 180 $X=191210 $Y=286080
X61006 1 2 6684 6607 9362 6620 9376 FA_5VX1 $T=211240 322560 0 180 $X=194010 $Y=317440
X61007 1 2 6664 9373 6604 6501 6658 FA_5VX1 $T=211800 268800 0 180 $X=194570 $Y=263680
X61008 1 2 6747 6731 6639 6633 6687 FA_5VX1 $T=214600 134400 0 180 $X=197370 $Y=129280
X61009 1 2 6654 9376 791 6638 9383 FA_5VX1 $T=214600 322560 1 180 $X=197370 $Y=321920
X61010 1 2 6670 6641 9883 6605 9384 FA_5VX1 $T=215160 259840 0 180 $X=197930 $Y=254720
X61011 1 2 6651 514 511 6673 6692 FA_5VX1 $T=215720 17920 1 180 $X=198490 $Y=17280
X61012 1 2 6680 9383 9378 6659 6706 FA_5VX1 $T=217400 331520 0 180 $X=200170 $Y=326400
X61013 1 2 6703 9398 6667 6661 6710 FA_5VX1 $T=217960 89600 0 180 $X=200730 $Y=84480
X61014 1 2 6773 6727 6676 6654 9389 FA_5VX1 $T=217960 295680 1 180 $X=200730 $Y=295040
X61015 1 2 6724 6629 6677 6662 9394 FA_5VX1 $T=219080 116480 1 180 $X=201850 $Y=115840
X61016 1 2 6768 9384 6679 6665 9392 FA_5VX1 $T=219080 259840 1 180 $X=201850 $Y=259200
X61017 1 2 6770 6709 6685 6660 9398 FA_5VX1 $T=219640 71680 1 180 $X=202410 $Y=71040
X61018 1 2 6848 9389 9375 6680 6728 FA_5VX1 $T=219640 304640 0 180 $X=202410 $Y=299520
X61019 1 2 6732 9392 9380 6684 6727 FA_5VX1 $T=220200 286720 0 180 $X=202970 $Y=281600
X61020 1 2 6787 6692 517 9381 6709 FA_5VX1 $T=221320 44800 1 180 $X=204090 $Y=44160
X61021 1 2 6681 6760 9411 6775 6745 FA_5VX1 $T=204520 62720 1 0 $X=204090 $Y=57600
X61022 1 2 6633 9394 6781 6918 9404 FA_5VX1 $T=205640 125440 1 0 $X=205210 $Y=120320
X61023 1 2 6694 9404 6782 6792 9402 FA_5VX1 $T=205640 134400 0 0 $X=205210 $Y=133760
X61024 1 2 6806 9406 6730 9387 9401 FA_5VX1 $T=224120 161280 1 180 $X=206890 $Y=160640
X61025 1 2 9433 9401 6718 9388 9403 FA_5VX1 $T=224120 170240 1 180 $X=206890 $Y=169600
X61026 1 2 9424 6783 6725 9395 9405 FA_5VX1 $T=225240 143360 1 180 $X=208010 $Y=142720
X61027 1 2 9390 9409 9348 6820 6755 FA_5VX1 $T=208440 206080 1 0 $X=208010 $Y=200960
X61028 1 2 9425 9405 6726 9396 9406 FA_5VX1 $T=225800 161280 0 180 $X=208570 $Y=156160
X61029 1 2 9387 9414 6818 6812 9407 FA_5VX1 $T=209000 170240 1 0 $X=208570 $Y=165120
X61030 1 2 9393 9415 6799 9426 9409 FA_5VX1 $T=209000 188160 0 0 $X=208570 $Y=187520
X61031 1 2 6785 6706 6743 6721 6758 FA_5VX1 $T=225800 340480 0 180 $X=208570 $Y=335360
X61032 1 2 6772 6710 6733 6724 6731 FA_5VX1 $T=226360 98560 1 180 $X=209130 $Y=97920
X61033 1 2 9395 9402 6824 6817 6761 FA_5VX1 $T=209560 152320 1 0 $X=209130 $Y=147200
X61034 1 2 9428 9412 6712 9390 6759 FA_5VX1 $T=226360 197120 0 180 $X=209130 $Y=192000
X61035 1 2 9396 6761 7092 6830 9414 FA_5VX1 $T=210680 152320 0 0 $X=210250 $Y=151680
X61036 1 2 9388 9407 6777 6819 9415 FA_5VX1 $T=210680 179200 1 0 $X=210250 $Y=174080
X61037 1 2 9953 9403 9954 9393 9412 FA_5VX1 $T=227480 188160 0 180 $X=210250 $Y=183040
X61038 1 2 6746 9423 6838 6845 6795 FA_5VX1 $T=212920 107520 0 0 $X=212490 $Y=106880
X61039 1 2 9885 9421 6737 6526 6778 FA_5VX1 $T=229720 313600 1 180 $X=212490 $Y=312960
X61040 1 2 6829 6687 6886 6694 6783 FA_5VX1 $T=231400 134400 0 180 $X=214170 $Y=129280
X61041 1 2 6774 6758 6737 6244 9418 FA_5VX1 $T=231400 331520 1 180 $X=214170 $Y=330880
X61042 1 2 6697 9429 6561 6854 6808 FA_5VX1 $T=215160 268800 0 0 $X=214730 $Y=268160
X61043 1 2 9444 9427 6737 6420 9421 FA_5VX1 $T=231960 322560 1 180 $X=214730 $Y=321920
X61044 1 2 6764 9432 6561 9885 9429 FA_5VX1 $T=216280 277760 1 0 $X=215850 $Y=272640
X61045 1 2 9442 9430 6561 6774 6810 FA_5VX1 $T=233640 295680 0 180 $X=216410 $Y=290560
X61046 1 2 7587 524 9410 9408 6760 FA_5VX1 $T=234200 35840 0 180 $X=216970 $Y=30720
X61047 1 2 6790 9418 6737 6414 9427 FA_5VX1 $T=234200 331520 0 180 $X=216970 $Y=326400
X61048 1 2 6767 9434 9886 9443 9423 FA_5VX1 $T=217960 89600 1 0 $X=217530 $Y=84480
X61049 1 2 6769 6836 6561 9444 9432 FA_5VX1 $T=217960 277760 0 0 $X=217530 $Y=277120
X61050 1 2 6780 6745 6862 6875 9434 FA_5VX1 $T=219080 71680 1 0 $X=218650 $Y=66560
X61051 1 2 9449 6728 6561 6785 9430 FA_5VX1 $T=235880 295680 1 180 $X=218650 $Y=295040
X61052 1 2 9450 6810 6561 6790 6836 FA_5VX1 $T=237000 286720 1 180 $X=219770 $Y=286080
X61053 1 2 6802 6880 6885 6887 6861 FA_5VX1 $T=224120 35840 0 0 $X=223690 $Y=35200
X61054 1 2 6816 9451 9456 6897 6907 FA_5VX1 $T=225240 134400 0 0 $X=224810 $Y=133760
X61055 1 2 530 9455 538 539 6849 FA_5VX1 $T=228040 17920 1 0 $X=227610 $Y=12800
X61056 1 2 6858 9452 6876 9459 9451 FA_5VX1 $T=229160 125440 1 0 $X=228730 $Y=120320
X61057 1 2 6850 6795 9955 6910 9452 FA_5VX1 $T=229720 107520 0 0 $X=229290 $Y=106880
X61058 1 2 6938 534 6932 550 6887 FA_5VX1 $T=235880 26880 0 0 $X=235450 $Y=26240
X61059 1 2 6871 9462 553 6938 6899 FA_5VX1 $T=237000 26880 1 0 $X=236570 $Y=21760
X61060 1 2 792 9458 9465 6939 6867 FA_5VX1 $T=237000 44800 0 0 $X=236570 $Y=44160
X61061 1 2 9455 543 9483 554 9462 FA_5VX1 $T=240360 17920 0 0 $X=239930 $Y=17280
X61062 1 2 6906 543 9889 6959 6933 FA_5VX1 $T=242600 35840 0 0 $X=242170 $Y=35200
X61063 1 2 6880 545 9469 559 6939 FA_5VX1 $T=246520 35840 1 0 $X=246090 $Y=30720
X61064 1 2 6888 9467 6995 9956 6966 FA_5VX1 $T=247640 62720 1 0 $X=247210 $Y=57600
X61065 1 2 6885 9475 528 568 6940 FA_5VX1 $T=254920 44800 1 0 $X=254490 $Y=39680
X61066 1 2 9465 9476 542 569 6995 FA_5VX1 $T=254920 44800 0 0 $X=254490 $Y=44160
X61067 1 2 9483 564 533 557 6932 FA_5VX1 $T=274520 17920 1 180 $X=257290 $Y=17280
X61068 1 2 6982 7050 548 7064 7031 FA_5VX1 $T=259400 35840 0 0 $X=258970 $Y=35200
X61069 1 2 9957 9482 7069 7078 9480 FA_5VX1 $T=260520 197120 1 0 $X=260090 $Y=192000
X61070 1 2 6993 7067 7048 7011 7030 FA_5VX1 $T=261080 161280 0 0 $X=260650 $Y=160640
X61071 1 2 6914 9484 6982 540 9479 FA_5VX1 $T=261640 62720 0 0 $X=261210 $Y=62080
X61072 1 2 6975 7030 7034 7006 7040 FA_5VX1 $T=261640 179200 0 0 $X=261210 $Y=178560
X61073 1 2 6999 7040 7044 7061 9482 FA_5VX1 $T=262760 188160 0 0 $X=262330 $Y=187520
X61074 1 2 9956 9487 9489 7072 9484 FA_5VX1 $T=264440 62720 1 0 $X=264010 $Y=57600
X61075 1 2 7021 7077 7083 7106 7067 FA_5VX1 $T=265560 152320 1 0 $X=265130 $Y=147200
X61076 1 2 7033 9491 9496 9501 7066 FA_5VX1 $T=267800 116480 0 0 $X=267370 $Y=115840
X61077 1 2 7024 7066 7085 7047 7077 FA_5VX1 $T=268360 134400 0 0 $X=267930 $Y=133760
X61078 1 2 9476 547 532 533 9489 FA_5VX1 $T=269480 35840 1 0 $X=269050 $Y=30720
X61079 1 2 7018 9480 9503 9505 7079 FA_5VX1 $T=269480 197120 0 0 $X=269050 $Y=196480
X61080 1 2 9477 7110 7127 7082 9491 FA_5VX1 $T=270040 107520 0 0 $X=269610 $Y=106880
X61081 1 2 7002 7037 570 7031 6926 FA_5VX1 $T=290200 44800 0 180 $X=272970 $Y=39680
X61082 1 2 7091 7154 9890 545 7139 FA_5VX1 $T=277880 161280 0 0 $X=277450 $Y=160640
X61083 1 2 7096 7164 7121 9516 7110 FA_5VX1 $T=279000 89600 0 0 $X=278570 $Y=88960
X61084 1 2 7098 9514 584 7171 7141 FA_5VX1 $T=281800 53760 0 0 $X=281370 $Y=53120
X61085 1 2 6956 577 7094 545 6955 FA_5VX1 $T=298600 71680 1 180 $X=281370 $Y=71040
X61086 1 2 7136 9806 550 9500 7150 FA_5VX1 $T=298600 152320 1 180 $X=281370 $Y=151680
X61087 1 2 9500 7182 9520 544 9890 FA_5VX1 $T=283480 161280 1 0 $X=283050 $Y=156160
X61088 1 2 7120 7176 548 550 7171 FA_5VX1 $T=284040 53760 1 0 $X=283610 $Y=48640
X61089 1 2 7126 9522 587 550 7158 FA_5VX1 $T=290760 26880 1 0 $X=290330 $Y=21760
X61090 1 2 573 540 589 7244 7137 FA_5VX1 $T=293000 17920 0 0 $X=292570 $Y=17280
X61091 1 2 7244 548 547 542 9522 FA_5VX1 $T=312040 17920 0 180 $X=294810 $Y=12800
X61092 1 2 7154 548 542 9539 7230 FA_5VX1 $T=295240 170240 1 0 $X=294810 $Y=165120
X61093 1 2 7128 9531 7230 7226 7188 FA_5VX1 $T=295240 170240 0 0 $X=294810 $Y=169600
X61094 1 2 7253 9529 7195 7184 9524 FA_5VX1 $T=312600 89600 1 180 $X=295370 $Y=88960
X61095 1 2 9544 548 7197 7286 7207 FA_5VX1 $T=313160 26880 1 180 $X=295930 $Y=26240
X61096 1 2 9518 7246 7204 7226 7152 FA_5VX1 $T=296360 152320 1 0 $X=295930 $Y=147200
X61097 1 2 7184 9540 9542 9543 9530 FA_5VX1 $T=297480 80640 1 0 $X=297050 $Y=75520
X61098 1 2 7197 528 7257 7260 7239 FA_5VX1 $T=298040 35840 0 0 $X=297610 $Y=35200
X61099 1 2 7203 9526 9544 9545 9535 FA_5VX1 $T=298600 35840 1 0 $X=298170 $Y=30720
X61100 1 2 9546 7226 7209 7207 9529 FA_5VX1 $T=315400 71680 1 180 $X=298170 $Y=71040
X61101 1 2 7204 7251 548 9958 9806 FA_5VX1 $T=298600 152320 0 0 $X=298170 $Y=151680
X61102 1 2 7166 7262 7249 7241 7208 FA_5VX1 $T=300840 116480 1 0 $X=300410 $Y=111360
X61103 1 2 7151 7099 544 593 7124 FA_5VX1 $T=301400 44800 1 0 $X=300970 $Y=39680
X61104 1 2 7214 550 7272 7278 9540 FA_5VX1 $T=301400 62720 1 0 $X=300970 $Y=57600
X61105 1 2 7181 9547 9548 9551 7175 FA_5VX1 $T=303080 116480 0 0 $X=302650 $Y=115840
X61106 1 2 7193 9532 9530 7229 7186 FA_5VX1 $T=320440 107520 0 180 $X=303210 $Y=102400
X61107 1 2 9526 545 7261 9552 7266 FA_5VX1 $T=304200 44800 0 0 $X=303770 $Y=44160
X61108 1 2 7209 544 7270 7239 9543 FA_5VX1 $T=304760 71680 1 0 $X=304330 $Y=66560
X61109 1 2 7200 9534 7282 7288 7179 FA_5VX1 $T=304760 134400 0 0 $X=304330 $Y=133760
X61110 1 2 9528 9546 7214 7266 7198 FA_5VX1 $T=305320 62720 0 0 $X=304890 $Y=62080
X61111 1 2 9532 9550 7297 7268 7262 FA_5VX1 $T=307000 98560 0 0 $X=306570 $Y=97920
X61112 1 2 9557 550 9537 588 9545 FA_5VX1 $T=324360 26880 0 180 $X=307130 $Y=21760
X61113 1 2 7195 545 598 548 9550 FA_5VX1 $T=308680 98560 1 0 $X=308250 $Y=93440
X61114 1 2 7249 9553 9554 545 9551 FA_5VX1 $T=309240 107520 0 0 $X=308810 $Y=106880
X61115 1 2 7288 545 7254 7250 7246 FA_5VX1 $T=326600 143360 0 180 $X=309370 $Y=138240
X61116 1 2 7305 544 592 591 9552 FA_5VX1 $T=329400 17920 0 180 $X=312170 $Y=12800
X61117 1 2 7261 542 602 546 7278 FA_5VX1 $T=313160 53760 1 0 $X=312730 $Y=48640
X61118 1 2 7268 595 535 9561 9554 FA_5VX1 $T=313720 80640 0 0 $X=313290 $Y=80000
X61119 1 2 7340 533 532 546 7254 FA_5VX1 $T=330520 125440 1 180 $X=313290 $Y=124800
X61120 1 2 7250 544 7293 547 7251 FA_5VX1 $T=313720 152320 1 0 $X=313290 $Y=147200
X61121 1 2 9542 7316 7287 542 7297 FA_5VX1 $T=314280 80640 1 0 $X=313850 $Y=75520
X61122 1 2 9958 542 546 547 7182 FA_5VX1 $T=315960 152320 0 0 $X=315530 $Y=151680
X61123 1 2 9548 7327 542 7340 7282 FA_5VX1 $T=318200 125440 1 0 $X=317770 $Y=120320
X61124 1 2 9553 548 7332 7322 7235 FA_5VX1 $T=320440 107520 1 0 $X=320010 $Y=102400
X61125 1 2 606 9557 7305 597 7326 FA_5VX1 $T=338920 17920 1 180 $X=321690 $Y=17280
X61126 1 2 7272 547 7330 532 7316 FA_5VX1 $T=322120 62720 0 0 $X=321690 $Y=62080
X61127 1 2 7343 607 614 7380 7375 FA_5VX1 $T=333320 26880 1 0 $X=332890 $Y=21760
X61128 1 2 7433 7375 9568 7148 7164 FA_5VX1 $T=351800 80640 0 180 $X=334570 $Y=75520
X61129 1 2 7438 9596 7439 7477 7444 FA_5VX1 $T=343400 62720 1 0 $X=342970 $Y=57600
X61130 1 2 9935 7467 7482 9603 7435 FA_5VX1 $T=343960 197120 0 0 $X=343530 $Y=196480
X61131 1 2 9936 7435 7459 7476 7412 FA_5VX1 $T=344520 206080 1 0 $X=344090 $Y=200960
X61132 1 2 7423 7474 7497 7499 7447 FA_5VX1 $T=348440 143360 0 0 $X=348010 $Y=142720
X61133 1 2 7431 9611 9617 9613 7471 FA_5VX1 $T=350680 152320 0 0 $X=350250 $Y=151680
X61134 1 2 9590 9601 9616 7513 7458 FA_5VX1 $T=352360 107520 1 0 $X=351930 $Y=102400
X61135 1 2 7430 7503 7517 7473 7455 FA_5VX1 $T=354040 107520 0 0 $X=353610 $Y=106880
X61136 1 2 9596 9614 7524 9959 7488 FA_5VX1 $T=354600 53760 0 0 $X=354170 $Y=53120
X61137 1 2 7424 9619 7516 9622 7467 FA_5VX1 $T=354600 188160 0 0 $X=354170 $Y=187520
X61138 1 2 7480 9607 9625 7542 7453 FA_5VX1 $T=357960 44800 1 0 $X=357530 $Y=39680
X61139 1 2 7427 9624 7478 7488 7408 FA_5VX1 $T=377560 80640 0 180 $X=360330 $Y=75520
X61140 1 2 9607 9626 7543 9631 7477 FA_5VX1 $T=361320 44800 0 0 $X=360890 $Y=44160
X61141 1 2 7496 9632 7539 9628 7490 FA_5VX1 $T=367480 125440 1 0 $X=367050 $Y=120320
X61142 1 2 7474 7565 9636 545 9611 FA_5VX1 $T=368040 152320 0 0 $X=367610 $Y=151680
X61143 1 2 7493 7555 7553 9643 7486 FA_5VX1 $T=369160 35840 0 0 $X=368730 $Y=35200
X61144 1 2 9640 7534 7525 7521 7513 FA_5VX1 $T=385960 71680 1 180 $X=368730 $Y=71040
X61145 1 2 799 7564 7535 9640 7457 FA_5VX1 $T=369160 98560 0 0 $X=368730 $Y=97920
X61146 1 2 7518 7611 9639 9646 7520 FA_5VX1 $T=369720 170240 1 0 $X=369290 $Y=165120
X61147 1 2 9616 7563 7574 548 7517 FA_5VX1 $T=370280 107520 1 0 $X=369850 $Y=102400
X61148 1 2 7441 9633 7595 7559 7469 FA_5VX1 $T=370280 125440 0 0 $X=369850 $Y=124800
X61149 1 2 7555 9638 7533 9623 7542 FA_5VX1 $T=387640 35840 0 180 $X=370410 $Y=30720
X61150 1 2 7529 627 629 9645 7553 FA_5VX1 $T=371400 17920 1 0 $X=370970 $Y=12800
X61151 1 2 625 7529 630 7561 9621 FA_5VX1 $T=371400 17920 0 0 $X=370970 $Y=17280
X61152 1 2 9623 7566 7572 542 7543 FA_5VX1 $T=371400 26880 0 0 $X=370970 $Y=26240
X61153 1 2 9959 548 9960 7578 7562 FA_5VX1 $T=371400 53760 0 0 $X=370970 $Y=53120
X61154 1 2 9624 7530 7562 7577 7556 FA_5VX1 $T=371400 71680 1 0 $X=370970 $Y=66560
X61155 1 2 7530 9628 7580 9940 7557 FA_5VX1 $T=371400 80640 0 0 $X=370970 $Y=80000
X61156 1 2 7428 7569 7557 7556 7434 FA_5VX1 $T=371400 89600 0 0 $X=370970 $Y=88960
X61157 1 2 7416 9634 9642 7558 7409 FA_5VX1 $T=371400 98560 1 0 $X=370970 $Y=93440
X61158 1 2 7554 542 533 546 7537 FA_5VX1 $T=388200 143360 1 180 $X=370970 $Y=142720
X61159 1 2 9646 9635 7537 545 7499 FA_5VX1 $T=388200 152320 0 180 $X=370970 $Y=147200
X61160 1 2 7505 7642 7575 9648 9619 FA_5VX1 $T=371400 188160 0 0 $X=370970 $Y=187520
X61161 1 2 9668 9657 9653 7565 7611 FA_5VX1 $T=418440 161280 1 180 $X=401210 $Y=160640
X61162 1 2 9672 9668 9647 7590 7570 FA_5VX1 $T=419000 170240 1 180 $X=401770 $Y=169600
X61163 1 2 9670 9664 542 7594 7521 FA_5VX1 $T=419560 80640 0 180 $X=402330 $Y=75520
X61164 1 2 9642 7618 7644 9670 7564 FA_5VX1 $T=403880 98560 0 0 $X=403450 $Y=97920
X61165 1 2 7650 545 7608 7603 7618 FA_5VX1 $T=422360 107520 0 180 $X=405130 $Y=102400
X61166 1 2 9631 544 7663 7657 7524 FA_5VX1 $T=407800 44800 0 0 $X=407370 $Y=44160
X61167 1 2 7569 7650 7654 7653 9634 FA_5VX1 $T=407800 98560 1 0 $X=407370 $Y=93440
X61168 1 2 9655 7651 7667 9673 7642 FA_5VX1 $T=407800 179200 0 0 $X=407370 $Y=178560
X61169 1 2 7670 7606 550 545 7624 FA_5VX1 $T=425160 188160 0 180 $X=407930 $Y=183040
X61170 1 2 9678 7565 9659 7616 9667 FA_5VX1 $T=426280 116480 1 180 $X=409050 $Y=115840
X61171 1 2 9679 7614 7623 7619 7590 FA_5VX1 $T=426280 143360 0 180 $X=409050 $Y=138240
X61172 1 2 7620 9667 7665 9679 7648 FA_5VX1 $T=410040 152320 1 0 $X=409610 $Y=147200
X61173 1 2 7577 550 803 7649 7653 FA_5VX1 $T=411160 71680 1 0 $X=410730 $Y=66560
X61174 1 2 9659 542 7675 7680 7623 FA_5VX1 $T=411160 125440 0 0 $X=410730 $Y=124800
X61175 1 2 7470 542 7666 9687 7580 FA_5VX1 $T=416760 62720 1 0 $X=416330 $Y=57600
X61176 1 2 9645 547 655 653 7533 FA_5VX1 $T=418440 17920 1 0 $X=418010 $Y=12800
X61177 1 2 7711 9678 9671 7656 7679 FA_5VX1 $T=436360 125440 0 180 $X=419130 $Y=120320
X61178 1 2 9937 7696 7724 7707 7651 FA_5VX1 $T=421240 161280 1 0 $X=420810 $Y=156160
X61179 1 2 9696 545 7641 7669 7656 FA_5VX1 $T=439720 107520 0 180 $X=422490 $Y=102400
X61180 1 2 7741 7606 9681 9680 7697 FA_5VX1 $T=441400 179200 0 180 $X=424170 $Y=174080
X61181 1 2 7676 545 9693 7698 7652 FA_5VX1 $T=425160 188160 1 0 $X=424730 $Y=183040
X61182 1 2 7681 548 7784 9699 7616 FA_5VX1 $T=428520 80640 1 0 $X=428090 $Y=75520
X61183 1 2 7690 9696 7681 9700 7720 FA_5VX1 $T=429080 98560 1 0 $X=428650 $Y=93440
X61184 1 2 7688 9697 7740 7733 7696 FA_5VX1 $T=429640 134400 0 0 $X=429210 $Y=133760
X61185 1 2 7694 544 7743 9703 7717 FA_5VX1 $T=430200 35840 0 0 $X=429770 $Y=35200
X61186 1 2 7673 9701 7746 9705 9697 FA_5VX1 $T=431880 116480 1 0 $X=431450 $Y=111360
X61187 1 2 7752 9689 7705 7700 9694 FA_5VX1 $T=449240 62720 1 180 $X=432010 $Y=62080
X61188 1 2 7699 548 9961 7742 7700 FA_5VX1 $T=433000 53760 0 0 $X=432570 $Y=53120
X61189 1 2 9689 550 9721 9715 9700 FA_5VX1 $T=435240 71680 1 0 $X=434810 $Y=66560
X61190 1 2 9715 547 546 7715 9699 FA_5VX1 $T=452040 71680 1 180 $X=434810 $Y=71040
X61191 1 2 7713 547 667 9714 7742 FA_5VX1 $T=435800 17920 0 0 $X=435370 $Y=17280
X61192 1 2 7761 7699 7721 7717 7739 FA_5VX1 $T=453720 53760 0 180 $X=436490 $Y=48640
X61193 1 2 9677 7753 7773 9719 9701 FA_5VX1 $T=436920 98560 0 0 $X=436490 $Y=97920
X61194 1 2 7756 546 528 660 9703 FA_5VX1 $T=456520 35840 0 180 $X=439290 $Y=30720
X61195 1 2 7728 9718 9724 7741 7685 FA_5VX1 $T=439720 179200 0 0 $X=439290 $Y=178560
X61196 1 2 9731 532 664 662 9714 FA_5VX1 $T=459880 17920 0 180 $X=442650 $Y=12800
X61197 1 2 7721 9727 7777 542 9721 FA_5VX1 $T=444200 44800 0 0 $X=443770 $Y=44160
X61198 1 2 7705 544 7781 7778 7669 FA_5VX1 $T=445320 62720 1 0 $X=444890 $Y=57600
X61199 1 2 7748 9729 9731 542 7749 FA_5VX1 $T=447000 26880 1 0 $X=446570 $Y=21760
X61200 1 2 7793 7694 7749 7713 7762 FA_5VX1 $T=463800 44800 0 180 $X=446570 $Y=39680
X61201 1 2 7799 7748 7756 666 7765 FA_5VX1 $T=464920 26880 1 180 $X=447690 $Y=26240
X61202 1 2 7743 533 670 532 9727 FA_5VX1 $T=448120 35840 0 0 $X=447690 $Y=35200
X61203 1 2 7709 7780 7790 9735 7753 FA_5VX1 $T=448120 89600 1 0 $X=447690 $Y=84480
X61204 1 2 7758 550 9895 9710 9725 FA_5VX1 $T=464920 152320 1 180 $X=447690 $Y=151680
X61205 1 2 7759 545 9707 9711 9724 FA_5VX1 $T=464920 170240 1 180 $X=447690 $Y=169600
X61206 1 2 9961 533 673 546 7778 FA_5VX1 $T=449800 53760 0 0 $X=449370 $Y=53120
X61207 1 2 7768 548 9720 7794 7771 FA_5VX1 $T=468840 143360 0 180 $X=451610 $Y=138240
X61208 1 2 7830 675 9733 669 9738 FA_5VX1 $T=477800 17920 0 180 $X=460570 $Y=12800
X61209 1 2 7801 544 7786 7785 7807 FA_5VX1 $T=477800 125440 1 180 $X=460570 $Y=124800
X61210 1 2 7731 7821 7831 9748 7780 FA_5VX1 $T=462120 62720 1 0 $X=461690 $Y=57600
X61211 1 2 7838 9740 9737 547 7819 FA_5VX1 $T=481160 80640 1 180 $X=463930 $Y=80000
X61212 1 2 7846 7800 7828 546 7823 FA_5VX1 $T=482840 71680 0 180 $X=465610 $Y=66560
X61213 1 2 7829 542 9743 7808 7809 FA_5VX1 $T=484520 107520 1 180 $X=467290 $Y=106880
X61214 1 2 7745 7850 9762 9763 7821 FA_5VX1 $T=472760 44800 1 0 $X=472330 $Y=39680
X61215 1 2 7874 9755 9751 533 7851 FA_5VX1 $T=493480 53760 0 180 $X=476250 $Y=48640
X61216 1 2 683 7849 7842 532 7854 FA_5VX1 $T=495720 26880 1 180 $X=478490 $Y=26240
X61217 1 2 7744 686 7894 9785 7850 FA_5VX1 $T=490680 26880 1 0 $X=490250 $Y=21760
X61218 1 2 7966 993 975 972 CAG_5VX1 $T=-546440 206080 1 180 $X=-553590 $Y=205435
X61219 1 2 1006 978 7967 7966 CAG_5VX1 $T=-544760 224000 1 180 $X=-551910 $Y=223355
X61220 1 2 8022 1149 1017 1006 CAG_5VX1 $T=-513960 241920 1 180 $X=-521110 $Y=241275
X61221 1 2 1206 1188 1146 8022 CAG_5VX1 $T=-507800 250880 1 180 $X=-514950 $Y=250235
X61222 1 2 1299 1245 8055 1283 CAG_5VX1 $T=-491560 170240 1 180 $X=-498710 $Y=169595
X61223 1 2 1283 1205 1308 1256 CAG_5VX1 $T=-497160 161280 1 0 $X=-497590 $Y=156160
X61224 1 2 1316 1300 1228 1206 CAG_5VX1 $T=-490440 268800 0 180 $X=-497590 $Y=263680
X61225 1 2 1403 1380 1347 1299 CAG_5VX1 $T=-478120 188160 0 180 $X=-485270 $Y=183040
X61226 1 2 1400 8093 1276 1316 CAG_5VX1 $T=-475320 277760 0 180 $X=-482470 $Y=272640
X61227 1 2 1497 1421 1462 1403 CAG_5VX1 $T=-458520 206080 0 180 $X=-465670 $Y=200960
X61228 1 2 1516 8108 29 31 CAG_5VX1 $T=-456280 17920 0 180 $X=-463430 $Y=12800
X61229 1 2 1517 1499 30 32 CAG_5VX1 $T=-456280 35840 1 180 $X=-463430 $Y=35195
X61230 1 2 1543 1521 1504 1400 CAG_5VX1 $T=-455160 286720 1 180 $X=-462310 $Y=286075
X61231 1 2 1560 1531 1515 1497 CAG_5VX1 $T=-452920 215040 0 180 $X=-460070 $Y=209920
X61232 1 2 1615 1530 1555 1452 CAG_5VX1 $T=-446760 125440 1 180 $X=-453910 $Y=124795
X61233 1 2 1592 1540 1562 1516 CAG_5VX1 $T=-445080 26880 1 180 $X=-452230 $Y=26235
X61234 1 2 8139 1551 1584 1592 CAG_5VX1 $T=-442840 35840 0 180 $X=-449990 $Y=30720
X61235 1 2 1612 1595 1585 8139 CAG_5VX1 $T=-442840 44800 0 180 $X=-449990 $Y=39680
X61236 1 2 1606 1527 1570 1517 CAG_5VX1 $T=-441160 53760 0 180 $X=-448310 $Y=48640
X61237 1 2 1625 1575 1602 1606 CAG_5VX1 $T=-440600 62720 1 180 $X=-447750 $Y=62075
X61238 1 2 1670 1673 1630 1615 CAG_5VX1 $T=-435560 134400 1 180 $X=-442710 $Y=133755
X61239 1 2 1688 1576 1613 1625 CAG_5VX1 $T=-433880 71680 1 180 $X=-441030 $Y=71035
X61240 1 2 1649 1491 1680 1212 CAG_5VX1 $T=-438920 259840 0 0 $X=-439350 $Y=259195
X61241 1 2 1710 1685 1635 1560 CAG_5VX1 $T=-431640 232960 0 180 $X=-438790 $Y=227840
X61242 1 2 1743 1683 1676 1688 CAG_5VX1 $T=-430520 89600 0 180 $X=-437670 $Y=84480
X61243 1 2 1777 1718 1678 1670 CAG_5VX1 $T=-426600 143360 1 180 $X=-433750 $Y=142715
X61244 1 2 1751 1737 1721 1743 CAG_5VX1 $T=-423800 89600 0 180 $X=-430950 $Y=84480
X61245 1 2 1784 1579 1674 1802 CAG_5VX1 $T=-420440 295680 1 180 $X=-427590 $Y=295035
X61246 1 2 1810 1723 8167 1777 CAG_5VX1 $T=-418200 152320 1 180 $X=-425350 $Y=151675
X61247 1 2 1748 1514 1848 1418 CAG_5VX1 $T=-424360 224000 1 0 $X=-424790 $Y=218880
X61248 1 2 1800 1714 1786 1612 CAG_5VX1 $T=-415960 53760 1 180 $X=-423110 $Y=53115
X61249 1 2 1816 1782 1762 1800 CAG_5VX1 $T=-415400 62720 0 180 $X=-422550 $Y=57600
X61250 1 2 1823 1783 1797 1710 CAG_5VX1 $T=-414840 232960 1 180 $X=-421990 $Y=232315
X61251 1 2 1721 1774 8206 17 CAG_5VX1 $T=-417640 89600 1 0 $X=-418070 $Y=84480
X61252 1 2 1890 1908 1820 1816 CAG_5VX1 $T=-407560 71680 0 180 $X=-414710 $Y=66560
X61253 1 2 8220 1491 1790 8212 CAG_5VX1 $T=-405320 268800 0 180 $X=-412470 $Y=263680
X61254 1 2 1887 1894 1872 1810 CAG_5VX1 $T=-404760 170240 0 180 $X=-411910 $Y=165120
X61255 1 2 1926 1900 1879 1887 CAG_5VX1 $T=-404200 179200 0 180 $X=-411350 $Y=174080
X61256 1 2 1992 1878 1763 1751 CAG_5VX1 $T=-403080 89600 1 180 $X=-410230 $Y=88955
X61257 1 2 1923 1514 1864 1906 CAG_5VX1 $T=-402520 215040 0 180 $X=-409670 $Y=209920
X61258 1 2 1878 17 1661 1763 CAG_5VX1 $T=-408120 80640 0 0 $X=-408550 $Y=79995
X61259 1 2 2028 1830 1436 2006 CAG_5VX1 $T=-389080 277760 1 180 $X=-396230 $Y=277115
X61260 1 2 1996 1859 2069 2052 CAG_5VX1 $T=-391320 241920 1 0 $X=-391750 $Y=236800
X61261 1 2 8255 2183 2025 2193 CAG_5VX1 $T=-382920 44800 1 180 $X=-390070 $Y=44155
X61262 1 2 2026 1998 2123 2066 CAG_5VX1 $T=-389640 71680 1 0 $X=-390070 $Y=66560
X61263 1 2 2060 8252 2056 2026 CAG_5VX1 $T=-381240 80640 1 180 $X=-388390 $Y=79995
X61264 1 2 2062 1995 2095 1926 CAG_5VX1 $T=-386280 179200 0 0 $X=-386710 $Y=178555
X61265 1 2 2066 2100 8259 8255 CAG_5VX1 $T=-385160 53760 0 0 $X=-385590 $Y=53115
X61266 1 2 2201 2099 2049 80 CAG_5VX1 $T=-371720 26880 0 180 $X=-378870 $Y=21760
X61267 1 2 2236 2213 2118 2186 CAG_5VX1 $T=-368360 197120 1 180 $X=-375510 $Y=196475
X61268 1 2 716 2048 1790 2076 CAG_5VX1 $T=-367800 259840 1 180 $X=-374950 $Y=259195
X61269 1 2 2193 1932 2011 2201 CAG_5VX1 $T=-373400 35840 1 0 $X=-373830 $Y=30720
X61270 1 2 2184 2137 2012 2060 CAG_5VX1 $T=-369480 80640 0 0 $X=-369910 $Y=79995
X61271 1 2 8309 2272 2153 2350 CAG_5VX1 $T=-341480 241920 1 180 $X=-348630 $Y=241275
X61272 1 2 2386 2372 1864 2363 CAG_5VX1 $T=-335320 215040 1 180 $X=-342470 $Y=214395
X61273 1 2 2471 2349 2433 2418 CAG_5VX1 $T=-325800 44800 0 180 $X=-332950 $Y=39680
X61274 1 2 8350 2497 2427 2523 CAG_5VX1 $T=-316280 197120 0 180 $X=-323430 $Y=192000
X61275 1 2 2550 2461 2518 2471 CAG_5VX1 $T=-315160 44800 1 180 $X=-322310 $Y=44155
X61276 1 2 2479 2472 2519 2533 CAG_5VX1 $T=-317400 71680 0 0 $X=-317830 $Y=71035
X61277 1 2 2597 2534 2490 2479 CAG_5VX1 $T=-310120 89600 1 180 $X=-317270 $Y=88955
X61278 1 2 2418 2506 2411 113 CAG_5VX1 $T=-316280 35840 1 0 $X=-316710 $Y=30720
X61279 1 2 2533 2539 2489 2550 CAG_5VX1 $T=-315160 62720 0 0 $X=-315590 $Y=62075
X61280 1 2 2811 2556 2629 2597 CAG_5VX1 $T=-300040 125440 0 180 $X=-307190 $Y=120320
X61281 1 2 2682 2672 2711 2656 CAG_5VX1 $T=-297800 304640 1 180 $X=-304950 $Y=303995
X61282 1 2 2718 2679 2684 2695 CAG_5VX1 $T=-293320 125440 0 180 $X=-300470 $Y=120320
X61283 1 2 8389 2709 2094 2662 CAG_5VX1 $T=-293320 188160 0 180 $X=-300470 $Y=183040
X61284 1 2 8380 2724 2702 2718 CAG_5VX1 $T=-294440 116480 1 0 $X=-294870 $Y=111360
X61285 1 2 2656 2680 2655 2727 CAG_5VX1 $T=-293320 286720 0 0 $X=-293750 $Y=286075
X61286 1 2 2800 2745 2759 2682 CAG_5VX1 $T=-282680 322560 1 180 $X=-289830 $Y=321915
X61287 1 2 2695 2739 2719 2811 CAG_5VX1 $T=-288280 134400 1 0 $X=-288710 $Y=129280
X61288 1 2 2761 130 132 47 CAG_5VX1 $T=-284920 35840 1 0 $X=-285350 $Y=30720
X61289 1 2 2832 138 139 2801 CAG_5VX1 $T=-278200 17920 1 0 $X=-278630 $Y=12800
X61290 1 2 2869 41 2860 43 CAG_5VX1 $T=-270360 107520 1 180 $X=-277510 $Y=106875
X61291 1 2 2955 2946 2935 2941 CAG_5VX1 $T=-259720 170240 1 180 $X=-266870 $Y=169595
X61292 1 2 2970 2895 2815 2800 CAG_5VX1 $T=-259720 340480 1 180 $X=-266870 $Y=339835
X61293 1 2 2882 157 154 137 CAG_5VX1 $T=-256360 17920 0 0 $X=-256790 $Y=17275
X61294 1 2 3029 3095 2891 2970 CAG_5VX1 $T=-249080 349440 1 180 $X=-256230 $Y=348795
X61295 1 2 8470 1827 3035 156 CAG_5VX1 $T=-253560 161280 1 0 $X=-253990 $Y=156160
X61296 1 2 2941 2884 8434 3022 CAG_5VX1 $T=-251880 152320 0 0 $X=-252310 $Y=151675
X61297 1 2 3022 2823 2962 3056 CAG_5VX1 $T=-249640 143360 0 0 $X=-250070 $Y=142715
X61298 1 2 3028 3077 3020 3076 CAG_5VX1 $T=-241240 116480 0 180 $X=-248390 $Y=111360
X61299 1 2 733 3008 3023 2955 CAG_5VX1 $T=-240680 170240 1 180 $X=-247830 $Y=169595
X61300 1 2 3107 39 43 1661 CAG_5VX1 $T=-239560 161280 0 180 $X=-246710 $Y=156160
X61301 1 2 3056 3021 2992 3028 CAG_5VX1 $T=-244600 125440 0 0 $X=-245030 $Y=124795
X61302 1 2 3151 169 166 167 CAG_5VX1 $T=-233960 17920 1 180 $X=-241110 $Y=17275
X61303 1 2 3076 3101 3136 3167 CAG_5VX1 $T=-240680 98560 0 0 $X=-241110 $Y=97915
X61304 1 2 3153 3122 3047 3017 CAG_5VX1 $T=-232280 44800 1 180 $X=-239430 $Y=44155
X61305 1 2 8503 17 3113 3107 CAG_5VX1 $T=-237880 161280 1 0 $X=-238310 $Y=156160
X61306 1 2 3213 3114 8517 8522 CAG_5VX1 $T=-227800 268800 0 180 $X=-234950 $Y=263680
X61307 1 2 3017 3166 172 3151 CAG_5VX1 $T=-232840 35840 0 0 $X=-233270 $Y=35195
X61308 1 2 8522 3102 3180 3103 CAG_5VX1 $T=-232280 250880 0 0 $X=-232710 $Y=250235
X61309 1 2 3254 3199 3334 3153 CAG_5VX1 $T=-222200 71680 1 180 $X=-229350 $Y=71035
X61310 1 2 3262 3186 8536 3213 CAG_5VX1 $T=-219400 277760 1 180 $X=-226550 $Y=277115
X61311 1 2 3167 3243 3250 3254 CAG_5VX1 $T=-224440 89600 1 0 $X=-224870 $Y=84480
X61312 1 2 3398 3234 3171 3029 CAG_5VX1 $T=-217720 367360 1 180 $X=-224870 $Y=366715
X61313 1 2 3270 199 2803 3304 CAG_5VX1 $T=-214360 62720 0 180 $X=-221510 $Y=57600
X61314 1 2 8551 200 720 3270 CAG_5VX1 $T=-214360 98560 1 180 $X=-221510 $Y=97915
X61315 1 2 3304 202 181 196 CAG_5VX1 $T=-212680 17920 1 180 $X=-219830 $Y=17275
X61316 1 2 3329 3309 8553 3262 CAG_5VX1 $T=-210440 295680 0 180 $X=-217590 $Y=290560
X61317 1 2 3292 3311 2849 8551 CAG_5VX1 $T=-209880 107520 1 180 $X=-217030 $Y=106875
X61318 1 2 3358 3286 2605 3292 CAG_5VX1 $T=-204280 116480 1 180 $X=-211430 $Y=115835
X61319 1 2 3438 3405 3387 3329 CAG_5VX1 $T=-198680 304640 1 180 $X=-205830 $Y=303995
X61320 1 2 3506 8588 3388 3398 CAG_5VX1 $T=-197560 376320 0 180 $X=-204710 $Y=371200
X61321 1 2 9841 156 3415 3366 CAG_5VX1 $T=-203720 170240 1 0 $X=-204150 $Y=165120
X61322 1 2 3460 74 8589 3306 CAG_5VX1 $T=-194760 89600 1 180 $X=-201910 $Y=88955
X61323 1 2 3478 2632 3402 3468 CAG_5VX1 $T=-190280 161280 1 180 $X=-197430 $Y=160635
X61324 1 2 3446 74 77 47 CAG_5VX1 $T=-194200 107520 1 0 $X=-194630 $Y=102400
X61325 1 2 3468 3497 3419 8613 CAG_5VX1 $T=-193080 152320 0 0 $X=-193510 $Y=151675
X61326 1 2 3546 43 224 1661 CAG_5VX1 $T=-185240 17920 1 180 $X=-192390 $Y=17275
X61327 1 2 3564 3546 3512 8621 CAG_5VX1 $T=-183000 26880 0 180 $X=-190150 $Y=21760
X61328 1 2 8613 3503 3426 8620 CAG_5VX1 $T=-189720 143360 1 0 $X=-190150 $Y=138240
X61329 1 2 735 3206 3685 3015 CAG_5VX1 $T=-182440 349440 1 180 $X=-189590 $Y=348795
X61330 1 2 8620 3453 3520 3547 CAG_5VX1 $T=-186920 134400 1 0 $X=-187350 $Y=129280
X61331 1 2 3606 8627 3485 3507 CAG_5VX1 $T=-179640 224000 0 180 $X=-186790 $Y=218880
X61332 1 2 3547 3540 3496 3581 CAG_5VX1 $T=-185240 116480 0 0 $X=-185670 $Y=115835
X61333 1 2 3602 3670 3587 3601 CAG_5VX1 $T=-176840 71680 0 180 $X=-183990 $Y=66560
X61334 1 2 3619 3609 3529 3438 CAG_5VX1 $T=-176840 322560 0 180 $X=-183990 $Y=317440
X61335 1 2 3622 3708 3566 3602 CAG_5VX1 $T=-176280 80640 1 180 $X=-183430 $Y=79995
X61336 1 2 3601 3637 8639 3600 CAG_5VX1 $T=-174040 62720 0 180 $X=-181190 $Y=57600
X61337 1 2 3581 3535 3595 8644 CAG_5VX1 $T=-180200 98560 0 0 $X=-180630 $Y=97915
X61338 1 2 3675 3660 3492 3606 CAG_5VX1 $T=-172360 224000 1 180 $X=-179510 $Y=223355
X61339 1 2 3663 231 226 232 CAG_5VX1 $T=-170680 17920 0 180 $X=-177830 $Y=12800
X61340 1 2 3600 3519 3564 3663 CAG_5VX1 $T=-177400 35840 0 0 $X=-177830 $Y=35195
X61341 1 2 8639 3611 3476 3599 CAG_5VX1 $T=-177400 53760 1 0 $X=-177830 $Y=48640
X61342 1 2 3705 3330 3656 3668 CAG_5VX1 $T=-170680 385280 0 180 $X=-177830 $Y=380160
X61343 1 2 8644 3607 3679 3622 CAG_5VX1 $T=-176840 98560 1 0 $X=-177270 $Y=93440
X61344 1 2 3683 3712 3583 3675 CAG_5VX1 $T=-167880 241920 0 180 $X=-175030 $Y=236800
X61345 1 2 3755 3645 2771 3358 CAG_5VX1 $T=-166200 134400 0 180 $X=-173350 $Y=129280
X61346 1 2 3587 3524 3565 3621 CAG_5VX1 $T=-170680 53760 1 0 $X=-171110 $Y=48640
X61347 1 2 3928 3760 3739 3683 CAG_5VX1 $T=-162280 250880 1 180 $X=-169430 $Y=250235
X61348 1 2 8661 3746 3766 2259 CAG_5VX1 $T=-168440 313600 1 0 $X=-168870 $Y=308480
X61349 1 2 3841 3763 3762 3619 CAG_5VX1 $T=-156680 322560 1 180 $X=-163830 $Y=321915
X61350 1 2 3795 3789 3790 3755 CAG_5VX1 $T=-156120 134400 1 180 $X=-163270 $Y=133755
X61351 1 2 3821 3807 2836 3795 CAG_5VX1 $T=-156120 143360 1 180 $X=-163270 $Y=142715
X61352 1 2 3837 3206 3716 3787 CAG_5VX1 $T=-156120 358400 1 180 $X=-163270 $Y=357755
X61353 1 2 8697 3808 2766 3821 CAG_5VX1 $T=-155560 152320 1 180 $X=-162710 $Y=151675
X61354 1 2 3809 3768 2907 8697 CAG_5VX1 $T=-152200 170240 0 180 $X=-159350 $Y=165120
X61355 1 2 3894 3810 1907 3809 CAG_5VX1 $T=-150520 179200 0 180 $X=-157670 $Y=174080
X61356 1 2 739 3908 2566 3894 CAG_5VX1 $T=-146600 170240 1 180 $X=-153750 $Y=169595
X61357 1 2 8715 3914 3780 3928 CAG_5VX1 $T=-143240 250880 1 180 $X=-150390 $Y=250235
X61358 1 2 3981 3856 3927 3947 CAG_5VX1 $T=-139880 53760 0 180 $X=-147030 $Y=48640
X61359 1 2 3992 3922 3953 3965 CAG_5VX1 $T=-139880 125440 1 180 $X=-147030 $Y=124795
X61360 1 2 3929 3973 3835 8715 CAG_5VX1 $T=-139880 268800 0 180 $X=-147030 $Y=263680
X61361 1 2 8723 3746 3839 8716 CAG_5VX1 $T=-139880 313600 0 180 $X=-147030 $Y=308480
X61362 1 2 3886 3971 3990 3981 CAG_5VX1 $T=-144360 71680 0 0 $X=-144790 $Y=71035
X61363 1 2 8746 3996 3253 4012 CAG_5VX1 $T=-134280 376320 0 180 $X=-141430 $Y=371200
X61364 1 2 8742 3999 3959 3929 CAG_5VX1 $T=-133160 268800 0 180 $X=-140310 $Y=263680
X61365 1 2 3947 3757 4024 265 CAG_5VX1 $T=-138200 44800 1 0 $X=-138630 $Y=39680
X61366 1 2 3965 3939 3997 4007 CAG_5VX1 $T=-135960 116480 1 0 $X=-136390 $Y=111360
X61367 1 2 8740 3957 4008 3992 CAG_5VX1 $T=-134280 143360 1 0 $X=-134710 $Y=138240
X61368 1 2 8738 3942 4021 8740 CAG_5VX1 $T=-133720 152320 0 0 $X=-134150 $Y=151675
X61369 1 2 4028 3979 4109 4106 CAG_5VX1 $T=-130920 331520 1 0 $X=-131350 $Y=326400
X61370 1 2 4134 8771 4080 4057 CAG_5VX1 $T=-121960 286720 1 180 $X=-129110 $Y=286075
X61371 1 2 4169 4070 3716 4001 CAG_5VX1 $T=-118600 349440 1 180 $X=-125750 $Y=348795
X61372 1 2 4166 4160 4207 4197 CAG_5VX1 $T=-118600 89600 0 0 $X=-119030 $Y=88955
X61373 1 2 4223 4166 4098 4148 CAG_5VX1 $T=-111880 116480 1 180 $X=-119030 $Y=115835
X61374 1 2 4114 4200 4208 4199 CAG_5VX1 $T=-118600 161280 0 0 $X=-119030 $Y=160635
X61375 1 2 4302 309 311 4183 CAG_5VX1 $T=-95640 35840 1 0 $X=-96070 $Y=30720
X61376 1 2 8831 4232 4210 4376 CAG_5VX1 $T=-85560 340480 0 180 $X=-92710 $Y=335360
X61377 1 2 8851 4383 3839 4419 CAG_5VX1 $T=-74360 313600 0 180 $X=-81510 $Y=308480
X61378 1 2 4476 4470 4449 4087 CAG_5VX1 $T=-73800 197120 1 180 $X=-80950 $Y=196475
X61379 1 2 4488 4326 4295 4369 CAG_5VX1 $T=-72120 152320 1 180 $X=-79270 $Y=151675
X61380 1 2 4504 4479 4458 4416 CAG_5VX1 $T=-72120 170240 1 180 $X=-79270 $Y=169595
X61381 1 2 8853 4447 4269 4465 CAG_5VX1 $T=-69880 295680 0 180 $X=-77030 $Y=290560
X61382 1 2 4533 4469 4483 4400 CAG_5VX1 $T=-69320 125440 0 180 $X=-76470 $Y=120320
X61383 1 2 8856 4508 4422 4380 CAG_5VX1 $T=-65960 268800 0 180 $X=-73110 $Y=263680
X61384 1 2 327 332 4567 4531 CAG_5VX1 $T=-71000 17920 0 0 $X=-71430 $Y=17275
X61385 1 2 4369 4540 337 4507 CAG_5VX1 $T=-68760 116480 0 0 $X=-69190 $Y=115835
X61386 1 2 4551 4564 4518 4502 CAG_5VX1 $T=-62040 170240 0 180 $X=-69190 $Y=165120
X61387 1 2 4666 4519 4494 4551 CAG_5VX1 $T=-62040 188160 0 180 $X=-69190 $Y=183040
X61388 1 2 4584 4476 4505 4480 CAG_5VX1 $T=-61480 206080 1 180 $X=-68630 $Y=205435
X61389 1 2 4546 4523 336 4474 CAG_5VX1 $T=-66520 53760 0 0 $X=-66950 $Y=53115
X61390 1 2 4477 4575 341 4687 CAG_5VX1 $T=-64840 44800 0 0 $X=-65270 $Y=44155
X61391 1 2 4616 330 4640 4550 CAG_5VX1 $T=-58120 71680 1 180 $X=-65270 $Y=71035
X61392 1 2 4552 4605 4693 4504 CAG_5VX1 $T=-57560 179200 1 180 $X=-64710 $Y=178555
X61393 1 2 4633 4583 4636 4606 CAG_5VX1 $T=-56440 206080 0 180 $X=-63590 $Y=200960
X61394 1 2 751 8867 339 4556 CAG_5VX1 $T=-61480 71680 1 0 $X=-61910 $Y=66560
X61395 1 2 4606 4638 4612 4401 CAG_5VX1 $T=-54760 197120 1 180 $X=-61910 $Y=196475
X61396 1 2 4700 4584 4613 4578 CAG_5VX1 $T=-54760 215040 0 180 $X=-61910 $Y=209920
X61397 1 2 4652 350 320 351 CAG_5VX1 $T=-53080 26880 1 180 $X=-60230 $Y=26235
X61398 1 2 4638 4623 4644 4666 CAG_5VX1 $T=-55880 188160 0 0 $X=-56310 $Y=187515
X61399 1 2 752 4633 4572 4673 CAG_5VX1 $T=-48040 215040 0 180 $X=-55190 $Y=209920
X61400 1 2 4564 4533 4377 4549 CAG_5VX1 $T=-53640 152320 0 0 $X=-54070 $Y=151675
X61401 1 2 8888 8880 339 4631 CAG_5VX1 $T=-44680 80640 1 180 $X=-51830 $Y=79995
X61402 1 2 8875 4662 4616 4622 CAG_5VX1 $T=-50840 89600 0 0 $X=-51270 $Y=88955
X61403 1 2 4416 4488 4428 4451 CAG_5VX1 $T=-50840 161280 1 0 $X=-51270 $Y=156160
X61404 1 2 8881 353 351 359 CAG_5VX1 $T=-46920 62720 1 0 $X=-47350 $Y=57600
X61405 1 2 4796 4731 4738 4798 CAG_5VX1 $T=-36840 80640 0 180 $X=-43990 $Y=75520
X61406 1 2 8893 366 359 362 CAG_5VX1 $T=-42440 62720 0 0 $X=-42870 $Y=62075
X61407 1 2 4807 4780 4764 4772 CAG_5VX1 $T=-34600 44800 0 180 $X=-41750 $Y=39680
X61408 1 2 8905 8901 4758 4781 CAG_5VX1 $T=-34600 107520 0 180 $X=-41750 $Y=102400
X61409 1 2 4781 4790 4803 4796 CAG_5VX1 $T=-39080 89600 1 0 $X=-39510 $Y=84480
X61410 1 2 4798 4808 8911 4821 CAG_5VX1 $T=-35720 62720 0 0 $X=-36150 $Y=62075
X61411 1 2 4855 348 4792 4825 CAG_5VX1 $T=-28440 224000 0 180 $X=-35590 $Y=218880
X61412 1 2 8920 4726 4746 8905 CAG_5VX1 $T=-26200 116480 1 180 $X=-33350 $Y=115835
X61413 1 2 4821 4742 4802 4807 CAG_5VX1 $T=-32360 53760 1 0 $X=-32790 $Y=48640
X61414 1 2 4895 4863 4809 348 CAG_5VX1 $T=-24520 206080 1 180 $X=-31670 $Y=205435
X61415 1 2 8928 4890 4895 4876 CAG_5VX1 $T=-22840 215040 0 180 $X=-29990 $Y=209920
X61416 1 2 4772 4789 373 375 CAG_5VX1 $T=-27880 26880 1 0 $X=-28310 $Y=21760
X61417 1 2 4875 4894 4806 4889 CAG_5VX1 $T=-25640 197120 0 0 $X=-26070 $Y=196475
X61418 1 2 4940 4855 4825 8928 CAG_5VX1 $T=-18360 224000 1 180 $X=-25510 $Y=223355
X61419 1 2 4876 4800 4906 4875 CAG_5VX1 $T=-24520 206080 0 0 $X=-24950 $Y=205435
X61420 1 2 8933 4880 4847 4814 CAG_5VX1 $T=-23960 143360 1 0 $X=-24390 $Y=138240
X61421 1 2 4862 8939 4900 4925 CAG_5VX1 $T=-16680 179200 0 180 $X=-23830 $Y=174080
X61422 1 2 4889 4901 4939 4862 CAG_5VX1 $T=-23400 188160 0 0 $X=-23830 $Y=187515
X61423 1 2 4958 4943 339 8938 CAG_5VX1 $T=-16120 107520 1 180 $X=-23270 $Y=106875
X61424 1 2 4925 4936 4953 4944 CAG_5VX1 $T=-21720 161280 1 0 $X=-22150 $Y=156160
X61425 1 2 5005 4985 4967 5010 CAG_5VX1 $T=-9400 322560 0 180 $X=-16550 $Y=317440
X61426 1 2 4934 4977 4860 346 CAG_5VX1 $T=-15000 71680 1 0 $X=-15430 $Y=66560
X61427 1 2 5010 4908 4915 4984 CAG_5VX1 $T=-7720 313600 0 180 $X=-14870 $Y=308480
X61428 1 2 4983 348 5024 5008 CAG_5VX1 $T=-12200 170240 0 0 $X=-12630 $Y=169595
X61429 1 2 4984 4844 8960 4999 CAG_5VX1 $T=-12200 295680 0 0 $X=-12630 $Y=295035
X61430 1 2 4944 5013 5033 5023 CAG_5VX1 $T=-10520 143360 1 0 $X=-10950 $Y=138240
X61431 1 2 4990 5020 359 362 CAG_5VX1 $T=-9400 62720 1 0 $X=-9830 $Y=57600
X61432 1 2 5078 5068 5046 8976 CAG_5VX1 $T=120 349440 1 180 $X=-7030 $Y=348795
X61433 1 2 8976 4986 5014 5005 CAG_5VX1 $T=-4360 331520 0 0 $X=-4790 $Y=330875
X61434 1 2 5023 5117 8984 5082 CAG_5VX1 $T=-3240 116480 1 0 $X=-3670 $Y=111360
X61435 1 2 8980 5085 5108 5119 CAG_5VX1 $T=-1000 197120 0 0 $X=-1430 $Y=196475
X61436 1 2 5113 5145 5124 5091 CAG_5VX1 $T=10200 116480 0 180 $X=3050 $Y=111360
X61437 1 2 5082 5127 9001 759 CAG_5VX1 $T=4040 98560 1 0 $X=3610 $Y=93440
X61438 1 2 9016 5075 5103 5078 CAG_5VX1 $T=11880 367360 0 180 $X=4730 $Y=362240
X61439 1 2 759 5101 5179 5161 CAG_5VX1 $T=5720 53760 1 0 $X=5290 $Y=48640
X61440 1 2 9006 364 5190 4973 CAG_5VX1 $T=8520 134400 1 0 $X=8090 $Y=129280
X61441 1 2 9005 353 383 366 CAG_5VX1 $T=9080 62720 0 0 $X=8650 $Y=62075
X61442 1 2 9028 5167 5136 9016 CAG_5VX1 $T=16920 385280 0 180 $X=9770 $Y=380160
X61443 1 2 9021 5168 5185 5138 CAG_5VX1 $T=13560 188160 1 0 $X=13130 $Y=183040
X61444 1 2 5218 5206 5183 5216 CAG_5VX1 $T=22520 62720 1 180 $X=15370 $Y=62075
X61445 1 2 5138 5259 5281 5325 CAG_5VX1 $T=20840 188160 1 0 $X=20410 $Y=183040
X61446 1 2 5329 405 402 5211 CAG_5VX1 $T=34280 53760 0 180 $X=27130 $Y=48640
X61447 1 2 5325 5311 5352 5271 CAG_5VX1 $T=29240 179200 1 0 $X=28810 $Y=174080
X61448 1 2 5271 5357 5348 5366 CAG_5VX1 $T=32040 161280 0 0 $X=31610 $Y=160635
X61449 1 2 5315 5131 5266 5362 CAG_5VX1 $T=32040 394240 0 0 $X=31610 $Y=393595
X61450 1 2 5366 5346 5347 5324 CAG_5VX1 $T=39880 143360 1 180 $X=32730 $Y=142715
X61451 1 2 5382 5393 5322 5302 CAG_5VX1 $T=41560 89600 1 180 $X=34410 $Y=88955
X61452 1 2 5324 5394 5303 5344 CAG_5VX1 $T=35400 125440 1 0 $X=34970 $Y=120320
X61453 1 2 5416 5308 5248 5224 CAG_5VX1 $T=42680 62720 0 180 $X=35530 $Y=57600
X61454 1 2 5302 5404 5424 5416 CAG_5VX1 $T=37640 71680 0 0 $X=37210 $Y=71035
X61455 1 2 5344 5212 5338 5382 CAG_5VX1 $T=40440 116480 0 0 $X=40010 $Y=115835
X61456 1 2 5161 5240 412 413 CAG_5VX1 $T=41000 26880 1 0 $X=40570 $Y=21760
X61457 1 2 5224 5415 411 410 CAG_5VX1 $T=42120 44800 1 0 $X=41690 $Y=39680
X61458 1 2 9136 5235 5601 5555 CAG_5VX1 $T=66760 358400 0 180 $X=59610 $Y=353280
X61459 1 2 5698 5235 5565 5602 CAG_5VX1 $T=71800 376320 1 180 $X=64650 $Y=375675
X61460 1 2 9151 5673 5656 5618 CAG_5VX1 $T=72920 98560 1 180 $X=65770 $Y=97915
X61461 1 2 9161 5712 763 5705 CAG_5VX1 $T=76280 394240 0 180 $X=69130 $Y=389120
X61462 1 2 5618 5707 430 9154 CAG_5VX1 $T=71240 80640 1 0 $X=70810 $Y=75520
X61463 1 2 9154 434 436 435 CAG_5VX1 $T=75720 44800 0 0 $X=75290 $Y=44155
X61464 1 2 771 5669 5724 5741 CAG_5VX1 $T=84680 286720 0 180 $X=77530 $Y=281600
X61465 1 2 5882 5725 9163 5794 CAG_5VX1 $T=87480 313600 0 180 $X=80330 $Y=308480
X61466 1 2 9173 5822 5803 9170 CAG_5VX1 $T=89720 62720 0 180 $X=82570 $Y=57600
X61467 1 2 5854 5799 5812 5882 CAG_5VX1 $T=90280 331520 0 180 $X=83130 $Y=326400
X61468 1 2 5810 5782 5843 9173 CAG_5VX1 $T=85240 71680 1 0 $X=84810 $Y=66560
X61469 1 2 5741 5819 5863 5770 CAG_5VX1 $T=86920 277760 1 0 $X=86490 $Y=272640
X61470 1 2 9186 5780 5565 5851 CAG_5VX1 $T=93640 394240 0 180 $X=86490 $Y=389120
X61471 1 2 5794 5715 5807 771 CAG_5VX1 $T=87480 295680 1 0 $X=87050 $Y=290560
X61472 1 2 5844 5878 5835 5810 CAG_5VX1 $T=95320 89600 0 180 $X=88170 $Y=84480
X61473 1 2 5917 5887 5883 5854 CAG_5VX1 $T=96440 349440 1 180 $X=89290 $Y=348795
X61474 1 2 9170 5743 5834 5888 CAG_5VX1 $T=91960 44800 1 0 $X=91530 $Y=39680
X61475 1 2 5994 5905 5884 5844 CAG_5VX1 $T=98680 98560 1 180 $X=91530 $Y=97915
X61476 1 2 5888 5940 5964 9200 CAG_5VX1 $T=98680 26880 0 0 $X=98250 $Y=26235
X61477 1 2 9198 5877 6011 348 CAG_5VX1 $T=99240 71680 1 0 $X=98810 $Y=66560
X61478 1 2 5961 5969 5959 5994 CAG_5VX1 $T=106520 98560 1 180 $X=99370 $Y=97915
X61479 1 2 9215 5972 5932 5917 CAG_5VX1 $T=108760 367360 1 180 $X=101610 $Y=366715
X61480 1 2 6052 5936 5981 5961 CAG_5VX1 $T=113800 134400 0 180 $X=106650 $Y=129280
X61481 1 2 9228 6009 6032 5923 CAG_5VX1 $T=114360 331520 0 180 $X=107210 $Y=326400
X61482 1 2 9200 9229 456 453 CAG_5VX1 $T=108760 17920 1 0 $X=108330 $Y=12800
X61483 1 2 5968 459 350 359 CAG_5VX1 $T=112680 35840 0 0 $X=112250 $Y=35195
X61484 1 2 6105 6009 6048 9231 CAG_5VX1 $T=120520 358400 0 180 $X=113370 $Y=353280
X61485 1 2 9254 6102 6086 6052 CAG_5VX1 $T=121640 125440 0 180 $X=114490 $Y=120320
X61486 1 2 779 5955 5985 6025 CAG_5VX1 $T=121640 394240 0 180 $X=114490 $Y=389120
X61487 1 2 6164 346 5956 6038 CAG_5VX1 $T=126680 71680 0 180 $X=119530 $Y=66560
X61488 1 2 6203 6216 9255 6148 CAG_5VX1 $T=133960 143360 1 180 $X=126810 $Y=142715
X61489 1 2 6255 6228 6210 6173 CAG_5VX1 $T=136760 286720 0 180 $X=129610 $Y=281600
X61490 1 2 6172 6226 6234 6230 CAG_5VX1 $T=131160 107520 0 0 $X=130730 $Y=106875
X61491 1 2 6148 782 6189 6172 CAG_5VX1 $T=131160 134400 0 0 $X=130730 $Y=133755
X61492 1 2 6173 6122 6196 6232 CAG_5VX1 $T=131160 250880 0 0 $X=130730 $Y=250235
X61493 1 2 6230 6239 6225 6238 CAG_5VX1 $T=138440 89600 0 180 $X=131290 $Y=84480
X61494 1 2 6188 4739 6164 6201 CAG_5VX1 $T=131720 116480 1 0 $X=131290 $Y=111360
X61495 1 2 6276 481 476 484 CAG_5VX1 $T=158600 17920 1 180 $X=151450 $Y=17275
X61496 1 2 9285 6169 6287 6276 CAG_5VX1 $T=151880 26880 0 0 $X=151450 $Y=26235
X61497 1 2 6313 6288 6177 9285 CAG_5VX1 $T=158600 44800 0 180 $X=151450 $Y=39680
X61498 1 2 6278 9276 6184 6313 CAG_5VX1 $T=158600 44800 1 180 $X=151450 $Y=44155
X61499 1 2 6279 6248 6170 6278 CAG_5VX1 $T=158600 62720 0 180 $X=151450 $Y=57600
X61500 1 2 6238 6106 6178 6279 CAG_5VX1 $T=151880 80640 1 0 $X=151450 $Y=75520
X61501 1 2 6334 6326 6215 6255 CAG_5VX1 $T=161400 286720 1 180 $X=154250 $Y=286075
X61502 1 2 9309 776 6258 6329 CAG_5VX1 $T=163080 385280 1 180 $X=155930 $Y=384635
X61503 1 2 6444 6460 6341 6334 CAG_5VX1 $T=174280 304640 0 180 $X=167130 $Y=299520
X61504 1 2 9336 6403 6048 6342 CAG_5VX1 $T=177080 358400 0 180 $X=169930 $Y=353280
X61505 1 2 6524 9342 6479 6444 CAG_5VX1 $T=183240 313600 0 180 $X=176090 $Y=308480
X61506 1 2 6510 6575 6552 6524 CAG_5VX1 $T=191640 313600 1 180 $X=184490 $Y=312955
X61507 1 2 9356 6582 6496 6510 CAG_5VX1 $T=188840 331520 1 0 $X=188410 $Y=326400
X61508 1 2 6707 6655 6563 6596 CAG_5VX1 $T=207320 349440 0 180 $X=200170 $Y=344320
X61509 1 2 9416 9420 6561 6808 CAG_5VX1 $T=220200 259840 0 0 $X=219770 $Y=259195
X61510 1 2 9417 6507 6737 6778 CAG_5VX1 $T=220200 313600 1 0 $X=219770 $Y=308480
X61511 1 2 6856 6849 6871 531 CAG_5VX1 $T=234200 26880 0 180 $X=227050 $Y=21760
X61512 1 2 6868 6802 6899 6856 CAG_5VX1 $T=234760 26880 1 180 $X=227610 $Y=26235
X61513 1 2 9454 792 6861 6868 CAG_5VX1 $T=237000 44800 1 180 $X=229850 $Y=44155
X61514 1 2 6971 6888 6867 9454 CAG_5VX1 $T=242600 53760 1 180 $X=235450 $Y=53115
X61515 1 2 9888 6906 6955 6962 CAG_5VX1 $T=253240 80640 1 0 $X=252810 $Y=75520
X61516 1 2 9889 555 6981 550 CAG_5VX1 $T=254920 26880 1 0 $X=254490 $Y=21760
X61517 1 2 7038 6966 6914 6971 CAG_5VX1 $T=261640 62720 1 180 $X=254490 $Y=62075
X61518 1 2 6962 6956 6926 6972 CAG_5VX1 $T=259400 71680 0 0 $X=258970 $Y=71035
X61519 1 2 6970 548 544 545 CAG_5VX1 $T=263320 53760 1 0 $X=262890 $Y=48640
X61520 1 2 6972 7002 9479 7038 CAG_5VX1 $T=266120 71680 0 0 $X=265690 $Y=71035
X61521 1 2 7147 7137 7126 7130 CAG_5VX1 $T=289640 26880 0 180 $X=282490 $Y=21760
X61522 1 2 7155 7152 7136 7143 CAG_5VX1 $T=291320 143360 1 180 $X=284170 $Y=142715
X61523 1 2 7131 7151 7158 7147 CAG_5VX1 $T=285160 35840 0 0 $X=284730 $Y=35195
X61524 1 2 7172 7091 7150 7155 CAG_5VX1 $T=293000 170240 0 180 $X=285850 $Y=165120
X61525 1 2 7130 573 578 582 CAG_5VX1 $T=294120 17920 0 180 $X=286970 $Y=12800
X61526 1 2 9514 7120 7124 7131 CAG_5VX1 $T=296920 44800 0 180 $X=289770 $Y=39680
X61527 1 2 7187 7175 7200 7178 CAG_5VX1 $T=299160 134400 1 180 $X=292010 $Y=133755
X61528 1 2 7143 7179 9518 7187 CAG_5VX1 $T=292440 143360 0 0 $X=292010 $Y=142715
X61529 1 2 7199 7166 7186 7191 CAG_5VX1 $T=300280 116480 0 180 $X=293130 $Y=111360
X61530 1 2 7227 7128 7139 7172 CAG_5VX1 $T=300840 179200 1 180 $X=293690 $Y=178555
X61531 1 2 7178 7181 7208 7199 CAG_5VX1 $T=295240 125440 1 0 $X=294810 $Y=120320
X61532 1 2 7191 7193 9524 7212 CAG_5VX1 $T=298040 98560 0 0 $X=297610 $Y=97915
X61533 1 2 9891 7217 7188 7227 CAG_5VX1 $T=307560 179200 1 180 $X=300410 $Y=178555
X61534 1 2 7222 9528 9535 7240 CAG_5VX1 $T=304200 53760 0 0 $X=303770 $Y=53115
X61535 1 2 7212 7198 7253 7222 CAG_5VX1 $T=307000 80640 0 0 $X=306570 $Y=79995
X61536 1 2 9541 545 7216 7255 CAG_5VX1 $T=312040 161280 0 0 $X=311610 $Y=160635
X61537 1 2 7255 548 544 550 CAG_5VX1 $T=313160 170240 1 0 $X=312730 $Y=165120
X61538 1 2 7384 606 604 605 CAG_5VX1 $T=338920 17920 0 180 $X=331770 $Y=12800
X61539 1 2 7240 7203 7326 7384 CAG_5VX1 $T=332200 35840 1 0 $X=331770 $Y=30720
X61540 1 2 7429 7409 799 7390 CAG_5VX1 $T=349000 107520 0 180 $X=341850 $Y=102400
X61541 1 2 7390 7416 7434 7421 CAG_5VX1 $T=345640 89600 0 0 $X=345210 $Y=88955
X61542 1 2 7421 7428 7408 9584 CAG_5VX1 $T=352920 89600 0 180 $X=345770 $Y=84480
X61543 1 2 7446 9590 7457 7429 CAG_5VX1 $T=354040 107520 1 180 $X=346890 $Y=106875
X61544 1 2 9584 7427 7444 7404 CAG_5VX1 $T=348440 71680 0 0 $X=348010 $Y=71035
X61545 1 2 7449 7430 7458 7446 CAG_5VX1 $T=355160 116480 1 180 $X=348010 $Y=115835
X61546 1 2 9591 7471 7451 7426 CAG_5VX1 $T=349560 161280 1 0 $X=349130 $Y=156160
X61547 1 2 7404 7438 7453 7445 CAG_5VX1 $T=350120 53760 1 0 $X=349690 $Y=48640
X61548 1 2 7466 7455 7441 7449 CAG_5VX1 $T=356840 125440 1 180 $X=349690 $Y=124795
X61549 1 2 7426 7447 7431 7442 CAG_5VX1 $T=351240 170240 1 0 $X=350810 $Y=165120
X61550 1 2 9617 542 547 548 CAG_5VX1 $T=364120 152320 0 180 $X=356970 $Y=147200
X61551 1 2 7445 7480 7486 9608 CAG_5VX1 $T=359080 35840 0 0 $X=358650 $Y=35195
X61552 1 2 9602 545 7504 7492 CAG_5VX1 $T=359080 170240 1 0 $X=358650 $Y=165120
X61553 1 2 9605 7490 7489 7494 CAG_5VX1 $T=359640 125440 1 0 $X=359210 $Y=120320
X61554 1 2 9615 545 7495 7500 CAG_5VX1 $T=368040 98560 1 180 $X=360890 $Y=97915
X61555 1 2 7494 7469 7496 7466 CAG_5VX1 $T=368040 134400 0 180 $X=360890 $Y=129280
X61556 1 2 9608 7493 9621 622 CAG_5VX1 $T=364120 35840 1 0 $X=363690 $Y=30720
X61557 1 2 7442 7423 7520 7548 CAG_5VX1 $T=365240 170240 0 0 $X=364810 $Y=169595
X61558 1 2 7548 7570 7518 7546 CAG_5VX1 $T=380920 170240 1 180 $X=373770 $Y=169595
X61559 1 2 9639 7554 548 550 CAG_5VX1 $T=382600 161280 1 180 $X=375450 $Y=160635
X61560 1 2 9632 548 7522 545 CAG_5VX1 $T=381480 107520 0 0 $X=381050 $Y=106875
X61561 1 2 9633 7568 550 9628 CAG_5VX1 $T=381480 116480 0 0 $X=381050 $Y=115835
X61562 1 2 7563 547 7635 544 CAG_5VX1 $T=401640 71680 0 0 $X=401210 $Y=71035
X61563 1 2 7552 7624 7606 7600 CAG_5VX1 $T=401640 188160 1 0 $X=401210 $Y=183040
X61564 1 2 7600 7670 7652 7645 CAG_5VX1 $T=415640 188160 0 0 $X=415210 $Y=187515
X61565 1 2 7609 547 7655 542 CAG_5VX1 $T=416200 116480 1 0 $X=415770 $Y=111360
X61566 1 2 7546 9672 7648 7660 CAG_5VX1 $T=418440 161280 0 0 $X=418010 $Y=160635
X61567 1 2 9684 7630 648 7672 CAG_5VX1 $T=430760 53760 1 180 $X=423610 $Y=53115
X61568 1 2 7598 528 532 546 CAG_5VX1 $T=426280 80640 0 0 $X=425850 $Y=79995
X61569 1 2 7660 7620 7679 7691 CAG_5VX1 $T=426840 143360 1 0 $X=426410 $Y=138240
X61570 1 2 7607 649 652 9685 CAG_5VX1 $T=427960 35840 1 0 $X=427530 $Y=30720
X61571 1 2 801 651 654 9894 CAG_5VX1 $T=429080 17920 0 0 $X=428650 $Y=17275
X61572 1 2 7645 7697 7676 7685 CAG_5VX1 $T=430200 197120 1 0 $X=429770 $Y=192000
X61573 1 2 7718 7690 9694 7725 CAG_5VX1 $T=436360 89600 0 0 $X=435930 $Y=88955
X61574 1 2 7691 7711 7720 7718 CAG_5VX1 $T=436360 125440 1 0 $X=435930 $Y=120320
X61575 1 2 7767 7761 7762 9716 CAG_5VX1 $T=455960 62720 1 180 $X=448810 $Y=62075
X61576 1 2 7725 7752 7739 7767 CAG_5VX1 $T=453160 71680 1 0 $X=452730 $Y=66560
X61577 1 2 9718 7759 9725 7769 CAG_5VX1 $T=454280 170240 1 0 $X=453850 $Y=165120
X61578 1 2 7764 7768 7807 7774 CAG_5VX1 $T=455400 134400 1 0 $X=454970 $Y=129280
X61579 1 2 7769 7758 7771 7764 CAG_5VX1 $T=457080 152320 1 0 $X=456650 $Y=147200
X61580 1 2 9716 7765 7793 7783 CAG_5VX1 $T=459320 53760 1 0 $X=458890 $Y=48640
X61581 1 2 7783 7799 9738 7802 CAG_5VX1 $T=463240 35840 1 0 $X=462810 $Y=30720
X61582 1 2 7774 7801 7809 7805 CAG_5VX1 $T=464360 125440 1 0 $X=463930 $Y=120320
X61583 1 2 7811 7838 7823 7825 CAG_5VX1 $T=478920 80640 0 180 $X=471770 $Y=75520
X61584 1 2 7805 7829 7819 7811 CAG_5VX1 $T=473320 98560 1 0 $X=472890 $Y=93440
X61585 1 2 7802 7830 678 677 CAG_5VX1 $T=475560 26880 1 0 $X=475130 $Y=21760
X61586 1 2 7825 7846 7851 9757 CAG_5VX1 $T=481160 62720 1 0 $X=480730 $Y=57600
X61587 1 2 7857 683 682 685 CAG_5VX1 $T=495720 17920 0 180 $X=488570 $Y=12800
X61588 1 2 9757 7874 7854 7857 CAG_5VX1 $T=490680 35840 0 0 $X=490250 $Y=35195
X61589 1 2 5885 5890 9188 778 5859 AN22_5VX1 $T=93080 116480 1 0 $X=92650 $Y=111360
X61590 1 2 4517 5890 5941 778 5909 AN22_5VX1 $T=97000 116480 0 0 $X=96570 $Y=115840
X61591 1 2 774 5890 5949 778 5945 AN22_5VX1 $T=97000 125440 0 0 $X=96570 $Y=124800
X61592 1 2 5925 5890 5948 778 775 AN22_5VX1 $T=97560 116480 1 0 $X=97130 $Y=111360
X61593 1 2 5987 5890 6145 778 9249 AN22_5VX1 $T=118840 143360 1 0 $X=118410 $Y=138240
X61594 1 2 6097 5890 6142 778 9252 AN22_5VX1 $T=119960 143360 0 0 $X=119530 $Y=142720
X61595 1 2 5892 5890 6151 778 6132 AN22_5VX1 $T=121640 170240 1 0 $X=121210 $Y=165120
X61596 1 2 9235 5890 6180 778 6121 AN22_5VX1 $T=121640 188160 0 0 $X=121210 $Y=187520
X61597 1 2 6003 5890 6204 778 6150 AN22_5VX1 $T=125560 161280 0 0 $X=125130 $Y=160640
X61598 1 2 6053 5890 6218 778 6221 AN22_5VX1 $T=128920 188160 1 0 $X=128490 $Y=183040
X61599 1 2 6084 5890 6309 778 6254 AN22_5VX1 $T=153000 197120 0 0 $X=152570 $Y=196480
X61600 1 2 1173 1174 1187 1224 OA21_5VX1 $T=-513960 241920 0 0 $X=-514390 $Y=241280
X61601 1 2 1264 1224 1252 8075 OA21_5VX1 $T=-496040 250880 0 0 $X=-496470 $Y=250240
X61602 1 2 1903 1902 1886 713 OA21_5VX1 $T=-401400 143360 1 0 $X=-401830 $Y=138240
X61603 1 2 1993 713 1976 2081 OA21_5VX1 $T=-391880 143360 0 0 $X=-392310 $Y=142720
X61604 1 2 2910 2878 8433 3040 OA21_5VX1 $T=-264760 340480 1 0 $X=-265190 $Y=335360
X61605 1 2 8472 3040 3046 8487 OA21_5VX1 $T=-250760 349440 1 0 $X=-251190 $Y=344320
X61606 1 2 3977 3910 3958 4039 OA21_5VX1 $T=-142120 224000 1 0 $X=-142550 $Y=218880
X61607 1 2 4014 4039 4016 8751 OA21_5VX1 $T=-135960 224000 1 0 $X=-136390 $Y=218880
X61608 1 2 4067 4005 8758 4097 OA21_5VX1 $T=-132040 80640 0 0 $X=-132470 $Y=80000
X61609 1 2 355 354 344 4589 OA21_5VX1 $T=-53080 17920 1 180 $X=-58550 $Y=17280
X61610 1 2 355 354 343 4640 OA21_5VX1 $T=-49720 26880 0 180 $X=-55190 $Y=21760
X61611 1 2 5156 5142 9010 9014 OA21_5VX1 $T=6280 340480 1 0 $X=5850 $Y=335360
X61612 1 2 5151 5130 760 5142 OA21_5VX1 $T=15240 322560 0 180 $X=9770 $Y=317440
X61613 1 2 790 6500 6514 6603 OA21_5VX1 $T=184920 259840 0 0 $X=184490 $Y=259200
X61614 1 2 6560 6603 6541 9373 OA21_5VX1 $T=191080 259840 0 0 $X=190650 $Y=259200
X61615 1 2 6946 6945 6940 9467 OA21_5VX1 $T=252120 53760 1 0 $X=251690 $Y=48640
X61616 1 2 975 993 972 1037 EN3_5VX1 $T=-552600 206080 1 0 $X=-553030 $Y=200960
X61617 1 2 7966 7967 978 7981 EN3_5VX1 $T=-548120 224000 1 0 $X=-548550 $Y=218880
X61618 1 2 1006 1017 1149 8024 EN3_5VX1 $T=-526280 232960 0 0 $X=-526710 $Y=232320
X61619 1 2 8022 1146 1188 1249 EN3_5VX1 $T=-512280 250880 1 0 $X=-512710 $Y=245760
X61620 1 2 1308 1205 1256 1195 EN3_5VX1 $T=-498280 152320 1 180 $X=-511030 $Y=151680
X61621 1 2 1283 8055 1245 1227 EN3_5VX1 $T=-492120 179200 0 180 $X=-504870 $Y=174080
X61622 1 2 1206 1228 1300 8070 EN3_5VX1 $T=-500520 259840 0 0 $X=-500950 $Y=259200
X61623 1 2 1299 1347 1380 1331 EN3_5VX1 $T=-488760 188160 0 0 $X=-489190 $Y=187520
X61624 1 2 1316 1276 8093 1463 EN3_5VX1 $T=-480920 268800 0 0 $X=-481350 $Y=268160
X61625 1 2 1403 1462 1421 8088 EN3_5VX1 $T=-464120 197120 1 180 $X=-476870 $Y=196480
X61626 1 2 31 29 8108 1437 EN3_5VX1 $T=-453480 17920 1 180 $X=-466230 $Y=17280
X61627 1 2 32 30 1499 1415 EN3_5VX1 $T=-452360 35840 0 180 $X=-465110 $Y=30720
X61628 1 2 1516 1562 1540 8107 EN3_5VX1 $T=-451800 26880 1 180 $X=-464550 $Y=26240
X61629 1 2 1497 1515 1531 1532 EN3_5VX1 $T=-461880 215040 0 0 $X=-462310 $Y=214400
X61630 1 2 1517 1570 1527 9925 EN3_5VX1 $T=-446760 44800 1 180 $X=-459510 $Y=44160
X61631 1 2 1555 1530 1452 1488 EN3_5VX1 $T=-445640 116480 1 180 $X=-458390 $Y=115840
X61632 1 2 1400 1504 1521 1597 EN3_5VX1 $T=-456280 286720 1 0 $X=-456710 $Y=281600
X61633 1 2 1592 1584 1551 8121 EN3_5VX1 $T=-443400 35840 1 180 $X=-456150 $Y=35200
X61634 1 2 1606 1602 1575 9926 EN3_5VX1 $T=-440600 62720 0 180 $X=-453350 $Y=57600
X61635 1 2 1625 1613 1576 1546 EN3_5VX1 $T=-440040 71680 0 180 $X=-452790 $Y=66560
X61636 1 2 1615 1630 1673 1663 EN3_5VX1 $T=-443960 125440 0 0 $X=-444390 $Y=124800
X61637 1 2 8139 1595 1585 8169 EN3_5VX1 $T=-442280 44800 1 0 $X=-442710 $Y=39680
X61638 1 2 1560 1635 1685 1665 EN3_5VX1 $T=-442280 224000 0 0 $X=-442710 $Y=223360
X61639 1 2 1688 1676 1683 1593 EN3_5VX1 $T=-427160 80640 1 180 $X=-439910 $Y=80000
X61640 1 2 1579 1674 1802 8170 EN3_5VX1 $T=-439480 295680 0 0 $X=-439910 $Y=295040
X61641 1 2 1743 1721 1737 8152 EN3_5VX1 $T=-425480 89600 1 180 $X=-438230 $Y=88960
X61642 1 2 1670 1678 1718 1689 EN3_5VX1 $T=-437240 143360 1 0 $X=-437670 $Y=138240
X61643 1 2 49 43 1661 1650 EN3_5VX1 $T=-422680 17920 1 180 $X=-435430 $Y=17280
X61644 1 2 1612 1786 1714 1819 EN3_5VX1 $T=-427160 53760 1 0 $X=-427590 $Y=48640
X61645 1 2 1710 1797 1783 8176 EN3_5VX1 $T=-412600 241920 1 180 $X=-425350 $Y=241280
X61646 1 2 1762 1782 1800 8209 EN3_5VX1 $T=-423800 62720 0 0 $X=-424230 $Y=62080
X61647 1 2 1777 8167 1723 1759 EN3_5VX1 $T=-422120 152320 1 0 $X=-422550 $Y=147200
X61648 1 2 1810 1872 1894 8200 EN3_5VX1 $T=-405320 161280 0 180 $X=-418070 $Y=156160
X61649 1 2 1816 1820 1908 8224 EN3_5VX1 $T=-412040 71680 0 0 $X=-412470 $Y=71040
X61650 1 2 1887 1879 1900 2009 EN3_5VX1 $T=-404200 170240 1 0 $X=-404630 $Y=165120
X61651 1 2 1859 2069 2052 8231 EN3_5VX1 $T=-382360 232960 1 180 $X=-395110 $Y=232320
X61652 1 2 2026 2056 8252 2136 EN3_5VX1 $T=-391320 80640 1 0 $X=-391750 $Y=75520
X61653 1 2 1926 2095 1995 1994 EN3_5VX1 $T=-379000 179200 0 180 $X=-391750 $Y=174080
X61654 1 2 2060 2012 2137 2179 EN3_5VX1 $T=-386840 89600 1 0 $X=-387270 $Y=84480
X61655 1 2 2193 2025 2183 2202 EN3_5VX1 $T=-382920 44800 0 0 $X=-383350 $Y=44160
X61656 1 2 2066 2123 1998 2206 EN3_5VX1 $T=-382920 71680 1 0 $X=-383350 $Y=66560
X61657 1 2 2201 2011 1932 2128 EN3_5VX1 $T=-369480 35840 1 180 $X=-382230 $Y=35200
X61658 1 2 8255 8259 2100 2130 EN3_5VX1 $T=-381800 62720 1 0 $X=-382230 $Y=57600
X61659 1 2 80 2049 2099 8281 EN3_5VX1 $T=-379000 17920 0 0 $X=-379430 $Y=17280
X61660 1 2 81 83 68 2249 EN3_5VX1 $T=-377880 17920 1 0 $X=-378310 $Y=12800
X61661 1 2 2186 2118 2213 2160 EN3_5VX1 $T=-375080 197120 1 0 $X=-375510 $Y=192000
X61662 1 2 2418 2433 2349 2329 EN3_5VX1 $T=-331400 35840 1 180 $X=-344150 $Y=35200
X61663 1 2 2471 2518 2461 2424 EN3_5VX1 $T=-318520 53760 1 180 $X=-331270 $Y=53120
X61664 1 2 2533 2519 2472 2431 EN3_5VX1 $T=-317400 71680 1 180 $X=-330150 $Y=71040
X61665 1 2 2550 2539 2489 2478 EN3_5VX1 $T=-315160 62720 1 180 $X=-327910 $Y=62080
X61666 1 2 2479 2490 2534 8351 EN3_5VX1 $T=-326920 98560 1 0 $X=-327350 $Y=93440
X61667 1 2 113 2411 2506 8334 EN3_5VX1 $T=-312920 26880 1 180 $X=-325670 $Y=26240
X61668 1 2 2597 2629 2556 2535 EN3_5VX1 $T=-306200 116480 1 180 $X=-318950 $Y=115840
X61669 1 2 2551 61 2639 2617 EN3_5VX1 $T=-311240 107520 1 0 $X=-311670 $Y=102400
X61670 1 2 124 2687 1661 117 EN3_5VX1 $T=-295560 17920 1 180 $X=-308310 $Y=17280
X61671 1 2 2718 2702 2724 2623 EN3_5VX1 $T=-293880 116480 1 180 $X=-306630 $Y=115840
X61672 1 2 2695 2684 2679 2585 EN3_5VX1 $T=-288840 134400 0 180 $X=-301590 $Y=129280
X61673 1 2 2655 2680 2727 8408 EN3_5VX1 $T=-301160 286720 1 0 $X=-301590 $Y=281600
X61674 1 2 2656 2711 2672 8401 EN3_5VX1 $T=-297800 304640 0 0 $X=-298230 $Y=304000
X61675 1 2 2811 2719 2739 2696 EN3_5VX1 $T=-281000 134400 1 180 $X=-293750 $Y=133760
X61676 1 2 47 40 43 2788 EN3_5VX1 $T=-277080 107520 1 180 $X=-289830 $Y=106880
X61677 1 2 2682 2759 2745 8429 EN3_5VX1 $T=-282120 322560 0 0 $X=-282550 $Y=321920
X61678 1 2 2832 47 41 2886 EN3_5VX1 $T=-279880 44800 1 0 $X=-280310 $Y=39680
X61679 1 2 40 39 1661 8405 EN3_5VX1 $T=-266440 125440 1 180 $X=-279190 $Y=124800
X61680 1 2 2800 2815 2895 8441 EN3_5VX1 $T=-277080 340480 1 0 $X=-277510 $Y=335360
X61681 1 2 2882 41 40 2966 EN3_5VX1 $T=-270920 44800 0 0 $X=-271350 $Y=44160
X61682 1 2 2941 2935 2946 8484 EN3_5VX1 $T=-259720 170240 0 0 $X=-260150 $Y=169600
X61683 1 2 2955 3023 3008 9927 EN3_5VX1 $T=-254120 179200 1 0 $X=-254550 $Y=174080
X61684 1 2 3022 8434 2884 8499 EN3_5VX1 $T=-251880 152320 1 0 $X=-252310 $Y=147200
X61685 1 2 3017 3047 3122 3111 EN3_5VX1 $T=-251320 44800 0 0 $X=-251750 $Y=44160
X61686 1 2 3028 2992 3021 9928 EN3_5VX1 $T=-250200 134400 1 0 $X=-250630 $Y=129280
X61687 1 2 3056 2962 2823 8501 EN3_5VX1 $T=-249640 143360 1 0 $X=-250070 $Y=138240
X61688 1 2 2970 2891 3095 3130 EN3_5VX1 $T=-249080 349440 0 0 $X=-249510 $Y=348800
X61689 1 2 3076 3020 3077 8518 EN3_5VX1 $T=-245720 116480 0 0 $X=-246150 $Y=115840
X61690 1 2 3167 3136 3101 163 EN3_5VX1 $T=-232280 107520 0 180 $X=-245030 $Y=102400
X61691 1 2 3180 3102 3103 3052 EN3_5VX1 $T=-232280 250880 1 180 $X=-245030 $Y=250240
X61692 1 2 8522 8517 3114 3090 EN3_5VX1 $T=-230600 259840 1 180 $X=-243350 $Y=259200
X61693 1 2 3029 3171 3234 8537 EN3_5VX1 $T=-235080 367360 1 0 $X=-235510 $Y=362240
X61694 1 2 3151 172 3166 3296 EN3_5VX1 $T=-234520 35840 1 0 $X=-234950 $Y=30720
X61695 1 2 3213 8536 3186 3127 EN3_5VX1 $T=-222200 277760 0 180 $X=-234950 $Y=272640
X61696 1 2 3153 3334 3199 2361 EN3_5VX1 $T=-205400 80640 0 180 $X=-218150 $Y=75520
X61697 1 2 3254 3250 3243 3132 EN3_5VX1 $T=-217720 89600 1 0 $X=-218150 $Y=84480
X61698 1 2 3262 8553 3309 3256 EN3_5VX1 $T=-217720 295680 0 0 $X=-218150 $Y=295040
X61699 1 2 3329 3387 3405 8584 EN3_5VX1 $T=-191960 304640 0 180 $X=-204710 $Y=299520
X61700 1 2 3398 3388 8588 8581 EN3_5VX1 $T=-191400 367360 1 180 $X=-204150 $Y=366720
X61701 1 2 40 1986 4238 3401 EN3_5VX1 $T=-188600 143360 1 180 $X=-201350 $Y=142720
X61702 1 2 222 39 17 3580 EN3_5VX1 $T=-193640 26880 0 0 $X=-194070 $Y=26240
X61703 1 2 3485 8627 3507 3515 EN3_5VX1 $T=-180200 215040 0 180 $X=-192950 $Y=209920
X61704 1 2 8613 3419 3497 8635 EN3_5VX1 $T=-191960 161280 1 0 $X=-192390 $Y=156160
X61705 1 2 3581 3496 3540 3603 EN3_5VX1 $T=-191400 125440 1 0 $X=-191830 $Y=120320
X61706 1 2 3468 3402 2632 3514 EN3_5VX1 $T=-191400 170240 1 0 $X=-191830 $Y=165120
X61707 1 2 3611 3599 61 3519 EN3_5VX1 $T=-177960 44800 0 180 $X=-190710 $Y=39680
X61708 1 2 8620 3426 3503 3624 EN3_5VX1 $T=-188600 143360 0 0 $X=-189030 $Y=142720
X61709 1 2 3547 3520 3453 3608 EN3_5VX1 $T=-186360 134400 0 0 $X=-186790 $Y=133760
X61710 1 2 3330 3656 3668 3631 EN3_5VX1 $T=-186360 385280 0 0 $X=-186790 $Y=384640
X61711 1 2 3512 3546 3580 231 EN3_5VX1 $T=-185240 17920 0 0 $X=-185670 $Y=17280
X61712 1 2 8644 3595 3535 3561 EN3_5VX1 $T=-172920 107520 0 180 $X=-185670 $Y=102400
X61713 1 2 3438 3529 3609 3578 EN3_5VX1 $T=-183000 313600 0 0 $X=-183430 $Y=312960
X61714 1 2 3600 8639 3637 8651 EN3_5VX1 $T=-180760 53760 0 0 $X=-181190 $Y=53120
X61715 1 2 3663 3564 3519 3736 EN3_5VX1 $T=-179640 35840 1 0 $X=-180070 $Y=30720
X61716 1 2 3606 3492 3660 3734 EN3_5VX1 $T=-179640 215040 0 0 $X=-180070 $Y=214400
X61717 1 2 3622 3679 3607 3737 EN3_5VX1 $T=-177960 89600 0 0 $X=-178390 $Y=88960
X61718 1 2 3601 3587 3670 3701 EN3_5VX1 $T=-176840 71680 1 0 $X=-177270 $Y=66560
X61719 1 2 3602 3566 3708 8669 EN3_5VX1 $T=-176280 89600 1 0 $X=-176710 $Y=84480
X61720 1 2 3675 3583 3712 3703 EN3_5VX1 $T=-173480 232960 0 0 $X=-173910 $Y=232320
X61721 1 2 3683 3739 3760 8682 EN3_5VX1 $T=-173480 241920 0 0 $X=-173910 $Y=241280
X61722 1 2 3619 3762 3763 8662 EN3_5VX1 $T=-156120 331520 0 180 $X=-168870 $Y=326400
X61723 1 2 3928 3780 3914 3854 EN3_5VX1 $T=-162280 250880 0 0 $X=-162710 $Y=250240
X61724 1 2 3929 3959 3999 4022 EN3_5VX1 $T=-147720 259840 0 0 $X=-148150 $Y=259200
X61725 1 2 8715 3835 3973 8745 EN3_5VX1 $T=-143240 259840 1 0 $X=-143670 $Y=254720
X61726 1 2 3979 4109 4106 8737 EN3_5VX1 $T=-123080 322560 1 180 $X=-135830 $Y=321920
X61727 1 2 4097 4197 4207 4048 EN3_5VX1 $T=-121400 98560 0 180 $X=-134150 $Y=93440
X61728 1 2 4057 4080 8771 4105 EN3_5VX1 $T=-132040 286720 1 0 $X=-132470 $Y=281600
X61729 1 2 4183 311 309 4457 EN3_5VX1 $T=-88920 26880 0 0 $X=-89350 $Y=26240
X61730 1 2 336 4523 4474 9943 EN3_5VX1 $T=-66520 53760 1 180 $X=-79270 $Y=53120
X61731 1 2 4567 4531 332 331 EN3_5VX1 $T=-58120 17920 0 180 $X=-70870 $Y=12800
X61732 1 2 339 8867 4556 8854 EN3_5VX1 $T=-51400 62720 1 180 $X=-64150 $Y=62080
X61733 1 2 4640 330 4550 8864 EN3_5VX1 $T=-49720 80640 0 180 $X=-62470 $Y=75520
X61734 1 2 341 4687 4575 4490 EN3_5VX1 $T=-45240 44800 0 180 $X=-57990 $Y=39680
X61735 1 2 8905 4746 4726 8884 EN3_5VX1 $T=-34600 116480 1 180 $X=-47350 $Y=115840
X61736 1 2 4807 4802 4742 4367 EN3_5VX1 $T=-32360 53760 0 180 $X=-45110 $Y=48640
X61737 1 2 4772 4764 4780 8819 EN3_5VX1 $T=-30120 35840 1 180 $X=-42870 $Y=35200
X61738 1 2 4781 4758 8901 4707 EN3_5VX1 $T=-29560 98560 1 180 $X=-42310 $Y=97920
X61739 1 2 375 373 4789 312 EN3_5VX1 $T=-27880 26880 0 180 $X=-40630 $Y=21760
X61740 1 2 4821 8911 4808 4394 EN3_5VX1 $T=-27880 62720 0 180 $X=-40630 $Y=57600
X61741 1 2 4798 4738 4731 4743 EN3_5VX1 $T=-27880 71680 1 180 $X=-40630 $Y=71040
X61742 1 2 4796 4803 4790 4599 EN3_5VX1 $T=-25640 89600 1 180 $X=-38390 $Y=88960
X61743 1 2 4814 4847 4880 8925 EN3_5VX1 $T=-34040 143360 0 0 $X=-34470 $Y=142720
X61744 1 2 4889 4806 4894 9931 EN3_5VX1 $T=-32920 197120 1 0 $X=-33350 $Y=192000
X61745 1 2 4862 4939 4901 8943 EN3_5VX1 $T=-28440 188160 1 0 $X=-28870 $Y=183040
X61746 1 2 4875 4906 4800 4965 EN3_5VX1 $T=-27320 206080 1 0 $X=-27750 $Y=200960
X61747 1 2 4925 4900 8939 8950 EN3_5VX1 $T=-26200 170240 0 0 $X=-26630 $Y=169600
X61748 1 2 4876 4895 4890 5056 EN3_5VX1 $T=-22280 215040 0 0 $X=-22710 $Y=214400
X61749 1 2 339 5024 4854 4992 EN3_5VX1 $T=-4360 179200 1 180 $X=-17110 $Y=178560
X61750 1 2 4944 4953 4936 5054 EN3_5VX1 $T=-16120 161280 0 0 $X=-16550 $Y=160640
X61751 1 2 5023 5033 5013 5092 EN3_5VX1 $T=-10520 134400 0 0 $X=-10950 $Y=133760
X61752 1 2 5010 4967 4985 5089 EN3_5VX1 $T=-9400 322560 1 0 $X=-9830 $Y=317440
X61753 1 2 5119 5108 5085 5035 EN3_5VX1 $T=5160 188160 1 180 $X=-7590 $Y=187520
X61754 1 2 4984 4915 4908 5122 EN3_5VX1 $T=-6600 304640 0 0 $X=-7030 $Y=304000
X61755 1 2 8960 4844 4999 5125 EN3_5VX1 $T=-5480 295680 0 0 $X=-5910 $Y=295040
X61756 1 2 5005 5014 4986 5135 EN3_5VX1 $T=-4920 331520 1 0 $X=-5350 $Y=326400
X61757 1 2 5082 8984 5117 5144 EN3_5VX1 $T=-3800 107520 0 0 $X=-4230 $Y=106880
X61758 1 2 353 359 383 5137 EN3_5VX1 $T=-3240 62720 0 0 $X=-3670 $Y=62080
X61759 1 2 8976 5046 5068 5157 EN3_5VX1 $T=-3240 340480 0 0 $X=-3670 $Y=339840
X61760 1 2 5078 5103 5075 5171 EN3_5VX1 $T=-1560 358400 0 0 $X=-1990 $Y=357760
X61761 1 2 353 5091 362 5083 EN3_5VX1 $T=11880 143360 1 180 $X=-870 $Y=142720
X61762 1 2 5113 362 326 5184 EN3_5VX1 $T=2920 125440 0 0 $X=2490 $Y=124800
X61763 1 2 759 9001 5127 5200 EN3_5VX1 $T=5160 89600 0 0 $X=4730 $Y=88960
X61764 1 2 5124 5091 5145 5208 EN3_5VX1 $T=6280 107520 1 0 $X=5850 $Y=102400
X61765 1 2 5138 5168 5185 5219 EN3_5VX1 $T=6840 188160 0 0 $X=6410 $Y=187520
X61766 1 2 9006 346 339 5243 EN3_5VX1 $T=10200 152320 1 0 $X=9770 $Y=147200
X61767 1 2 9016 5136 5167 9039 EN3_5VX1 $T=10760 376320 1 0 $X=10330 $Y=371200
X61768 1 2 5161 5179 5101 5268 EN3_5VX1 $T=11880 44800 0 0 $X=11450 $Y=44160
X61769 1 2 5183 5206 5216 5286 EN3_5VX1 $T=13560 71680 1 0 $X=13130 $Y=66560
X61770 1 2 402 5211 405 9047 EN3_5VX1 $T=15240 53760 1 0 $X=14810 $Y=48640
X61771 1 2 5190 4973 364 5297 EN3_5VX1 $T=15240 125440 0 0 $X=14810 $Y=124800
X61772 1 2 5218 366 346 5334 EN3_5VX1 $T=18040 116480 1 0 $X=17610 $Y=111360
X61773 1 2 5224 5248 5308 5337 EN3_5VX1 $T=18600 53760 0 0 $X=18170 $Y=53120
X61774 1 2 5325 5281 5259 9034 EN3_5VX1 $T=31480 188160 1 180 $X=18730 $Y=187520
X61775 1 2 5131 5266 5362 5320 EN3_5VX1 $T=19720 394240 0 0 $X=19290 $Y=393600
X61776 1 2 404 351 359 5365 EN3_5VX1 $T=23640 62720 1 0 $X=23210 $Y=57600
X61777 1 2 5271 5311 5352 9074 EN3_5VX1 $T=24200 179200 0 0 $X=23770 $Y=178560
X61778 1 2 353 5329 366 5257 EN3_5VX1 $T=38200 80640 1 180 $X=25450 $Y=80000
X61779 1 2 5302 5322 5393 5406 EN3_5VX1 $T=27000 98560 1 0 $X=26570 $Y=93440
X61780 1 2 5324 5347 5346 5417 EN3_5VX1 $T=28680 143360 1 0 $X=28250 $Y=138240
X61781 1 2 5344 5303 5394 5467 EN3_5VX1 $T=30360 125440 0 0 $X=29930 $Y=124800
X61782 1 2 5382 5338 5212 9092 EN3_5VX1 $T=35960 116480 1 0 $X=35530 $Y=111360
X61783 1 2 5416 5424 5404 5466 EN3_5VX1 $T=39320 62720 0 0 $X=38890 $Y=62080
X61784 1 2 5366 5348 5357 5472 EN3_5VX1 $T=39320 170240 0 0 $X=38890 $Y=169600
X61785 1 2 410 411 5415 5522 EN3_5VX1 $T=41000 35840 0 0 $X=40570 $Y=35200
X61786 1 2 413 412 5240 5364 EN3_5VX1 $T=47720 26880 1 0 $X=47290 $Y=21760
X61787 1 2 5741 5724 5669 5696 EN3_5VX1 $T=77960 286720 0 180 $X=65210 $Y=281600
X61788 1 2 5794 9163 5725 5679 EN3_5VX1 $T=84120 313600 1 180 $X=71370 $Y=312960
X61789 1 2 771 5807 5715 5686 EN3_5VX1 $T=87480 295680 1 180 $X=74730 $Y=295040
X61790 1 2 5863 5819 5770 5695 EN3_5VX1 $T=89160 268800 1 180 $X=76410 $Y=268160
X61791 1 2 9173 5843 5782 5748 EN3_5VX1 $T=90840 80640 0 180 $X=78090 $Y=75520
X61792 1 2 5882 5812 5799 9166 EN3_5VX1 $T=94200 322560 1 180 $X=81450 $Y=321920
X61793 1 2 5810 5835 5878 5924 EN3_5VX1 $T=87480 89600 0 0 $X=87050 $Y=88960
X61794 1 2 5917 5932 5972 9176 EN3_5VX1 $T=101480 367360 1 180 $X=88730 $Y=366720
X61795 1 2 5844 5884 5905 6314 EN3_5VX1 $T=89720 98560 1 0 $X=89290 $Y=93440
X61796 1 2 9170 5803 5822 5957 EN3_5VX1 $T=90840 62720 1 0 $X=90410 $Y=57600
X61797 1 2 5888 5834 5743 5980 EN3_5VX1 $T=93640 35840 0 0 $X=93210 $Y=35200
X61798 1 2 5854 5883 5887 5773 EN3_5VX1 $T=93640 349440 1 0 $X=93210 $Y=344320
X61799 1 2 5961 5981 5936 6039 EN3_5VX1 $T=101480 125440 0 0 $X=101050 $Y=124800
X61800 1 2 5955 5985 6025 9870 EN3_5VX1 $T=102040 394240 1 0 $X=101610 $Y=389120
X61801 1 2 453 456 9229 6337 EN3_5VX1 $T=107080 17920 0 0 $X=106650 $Y=17280
X61802 1 2 5994 5959 5969 6107 EN3_5VX1 $T=107080 98560 0 0 $X=106650 $Y=97920
X61803 1 2 9200 5964 5940 9320 EN3_5VX1 $T=107640 26880 0 0 $X=107210 $Y=26240
X61804 1 2 339 326 362 9220 EN3_5VX1 $T=122200 116480 1 180 $X=109450 $Y=115840
X61805 1 2 6052 6086 6102 6156 EN3_5VX1 $T=113800 125440 0 0 $X=113370 $Y=124800
X61806 1 2 6201 6164 4739 6108 EN3_5VX1 $T=130600 107520 1 180 $X=117850 $Y=106880
X61807 1 2 339 4739 6171 6155 EN3_5VX1 $T=118840 116480 1 0 $X=118410 $Y=111360
X61808 1 2 6148 9255 6216 9270 EN3_5VX1 $T=125000 143360 1 0 $X=124570 $Y=138240
X61809 1 2 6172 6189 782 9273 EN3_5VX1 $T=126120 125440 0 0 $X=125690 $Y=124800
X61810 1 2 6196 6122 6232 6242 EN3_5VX1 $T=126120 259840 1 0 $X=125690 $Y=254720
X61811 1 2 6173 6210 6228 6243 EN3_5VX1 $T=126120 268800 1 0 $X=125690 $Y=263680
X61812 1 2 6313 6184 9276 9283 EN3_5VX1 $T=164200 53760 0 180 $X=151450 $Y=48640
X61813 1 2 6278 6170 6248 9279 EN3_5VX1 $T=164200 71680 0 180 $X=151450 $Y=66560
X61814 1 2 6238 6225 6239 6364 EN3_5VX1 $T=151880 98560 1 0 $X=151450 $Y=93440
X61815 1 2 6230 6234 6226 9305 EN3_5VX1 $T=151880 107520 0 0 $X=151450 $Y=106880
X61816 1 2 6276 6287 6169 9282 EN3_5VX1 $T=164760 26880 0 180 $X=152010 $Y=21760
X61817 1 2 9285 6177 6288 6370 EN3_5VX1 $T=152440 35840 0 0 $X=152010 $Y=35200
X61818 1 2 6255 6215 6326 6273 EN3_5VX1 $T=152440 286720 1 0 $X=152010 $Y=281600
X61819 1 2 6279 6178 6106 6425 EN3_5VX1 $T=158600 80640 1 0 $X=158170 $Y=75520
X61820 1 2 6334 6341 6460 6456 EN3_5VX1 $T=167560 295680 0 0 $X=167130 $Y=295040
X61821 1 2 6444 6479 9342 6488 EN3_5VX1 $T=173720 304640 0 0 $X=173290 $Y=304000
X61822 1 2 6510 6496 6582 9362 EN3_5VX1 $T=181560 322560 1 0 $X=181130 $Y=317440
X61823 1 2 6524 6552 6575 6562 EN3_5VX1 $T=183240 313600 1 0 $X=182810 $Y=308480
X61824 1 2 6596 6563 6655 9378 EN3_5VX1 $T=192200 340480 0 0 $X=191770 $Y=339840
X61825 1 2 9454 6867 6888 6823 EN3_5VX1 $T=235880 53760 1 180 $X=223130 $Y=53120
X61826 1 2 531 6871 6849 6786 EN3_5VX1 $T=238680 17920 1 180 $X=225930 $Y=17280
X61827 1 2 6856 6899 6802 6803 EN3_5VX1 $T=246520 35840 0 180 $X=233770 $Y=30720
X61828 1 2 6868 792 6861 6913 EN3_5VX1 $T=239800 53760 1 0 $X=239370 $Y=48640
X61829 1 2 6971 6914 6966 9464 EN3_5VX1 $T=242600 62720 0 0 $X=242170 $Y=62080
X61830 1 2 6972 6956 6926 6893 EN3_5VX1 $T=258280 89600 1 180 $X=245530 $Y=88960
X61831 1 2 6962 6955 6906 6915 EN3_5VX1 $T=258280 98560 0 180 $X=245530 $Y=93440
X61832 1 2 7038 9479 7002 6951 EN3_5VX1 $T=272280 80640 0 180 $X=259530 $Y=75520
X61833 1 2 7131 7124 7120 7051 EN3_5VX1 $T=286840 44800 1 180 $X=274090 $Y=44160
X61834 1 2 582 578 573 9486 EN3_5VX1 $T=288520 17920 1 180 $X=275770 $Y=17280
X61835 1 2 7172 7139 7128 7113 EN3_5VX1 $T=294120 179200 1 180 $X=281370 $Y=178560
X61836 1 2 7143 7136 7152 7075 EN3_5VX1 $T=294680 152320 0 180 $X=281930 $Y=147200
X61837 1 2 7155 7150 7091 9498 EN3_5VX1 $T=295800 179200 0 180 $X=283050 $Y=174080
X61838 1 2 7130 7126 7137 7088 EN3_5VX1 $T=296360 26880 1 180 $X=283610 $Y=26240
X61839 1 2 7147 7158 7151 7065 EN3_5VX1 $T=298600 35840 0 180 $X=285850 $Y=30720
X61840 1 2 7191 7186 7166 9504 EN3_5VX1 $T=300840 107520 1 180 $X=288090 $Y=106880
X61841 1 2 7187 9518 7179 7086 EN3_5VX1 $T=301960 143360 0 180 $X=289210 $Y=138240
X61842 1 2 7178 7200 7175 7118 EN3_5VX1 $T=302520 134400 0 180 $X=289770 $Y=129280
X61843 1 2 7199 7208 7181 7117 EN3_5VX1 $T=303640 125440 1 180 $X=290890 $Y=124800
X61844 1 2 7227 7217 7188 9513 EN3_5VX1 $T=304760 188160 0 180 $X=292010 $Y=183040
X61845 1 2 7212 9524 7193 7149 EN3_5VX1 $T=305880 98560 0 180 $X=293130 $Y=93440
X61846 1 2 7222 7253 7198 9519 EN3_5VX1 $T=307000 80640 1 180 $X=294250 $Y=80000
X61847 1 2 7240 9535 9528 9521 EN3_5VX1 $T=313160 53760 0 180 $X=300410 $Y=48640
X61848 1 2 532 528 7293 9561 EN3_5VX1 $T=315960 89600 1 0 $X=315530 $Y=84480
X61849 1 2 7384 7326 7203 9566 EN3_5VX1 $T=342840 26880 1 180 $X=330090 $Y=26240
X61850 1 2 9584 7408 7428 9575 EN3_5VX1 $T=348440 80640 1 180 $X=335690 $Y=80000
X61851 1 2 7390 799 7409 7405 EN3_5VX1 $T=342280 98560 0 0 $X=341850 $Y=97920
X61852 1 2 7421 7434 7416 9581 EN3_5VX1 $T=355720 98560 0 180 $X=342970 $Y=93440
X61853 1 2 7404 7444 7427 9600 EN3_5VX1 $T=345080 71680 1 0 $X=344650 $Y=66560
X61854 1 2 7429 7457 9590 9583 EN3_5VX1 $T=359080 116480 0 180 $X=346330 $Y=111360
X61855 1 2 7446 7458 7430 7391 EN3_5VX1 $T=359640 125440 0 180 $X=346890 $Y=120320
X61856 1 2 7449 7441 7455 7386 EN3_5VX1 $T=360760 134400 1 180 $X=348010 $Y=133760
X61857 1 2 7445 7453 7438 7396 EN3_5VX1 $T=361320 44800 1 180 $X=348570 $Y=44160
X61858 1 2 7426 7451 7471 7485 EN3_5VX1 $T=349560 161280 0 0 $X=349130 $Y=160640
X61859 1 2 9608 7486 7480 9587 EN3_5VX1 $T=364120 35840 0 180 $X=351370 $Y=30720
X61860 1 2 7470 545 540 7439 EN3_5VX1 $T=364120 62720 1 180 $X=351370 $Y=62080
X61861 1 2 7442 7431 7447 9609 EN3_5VX1 $T=351800 170240 0 0 $X=351370 $Y=169600
X61862 1 2 7466 7496 7469 7450 EN3_5VX1 $T=365800 143360 0 180 $X=353050 $Y=138240
X61863 1 2 7494 7489 7490 9599 EN3_5VX1 $T=369720 125440 1 180 $X=356970 $Y=124800
X61864 1 2 622 9621 7493 9604 EN3_5VX1 $T=371400 17920 1 180 $X=358650 $Y=17280
X61865 1 2 7548 7520 7423 7514 EN3_5VX1 $T=378680 179200 1 180 $X=365930 $Y=178560
X61866 1 2 7546 7518 7570 9641 EN3_5VX1 $T=375880 179200 1 0 $X=375450 $Y=174080
X61867 1 2 7625 533 547 9960 EN3_5VX1 $T=413960 53760 1 180 $X=401210 $Y=53120
X61868 1 2 640 535 528 632 EN3_5VX1 $T=418440 17920 0 180 $X=405690 $Y=12800
X61869 1 2 7660 7648 9672 7633 EN3_5VX1 $T=427960 170240 0 180 $X=415210 $Y=165120
X61870 1 2 7645 7652 7670 9682 EN3_5VX1 $T=415640 197120 1 0 $X=415210 $Y=192000
X61871 1 2 647 536 535 7585 EN3_5VX1 $T=430200 26880 0 180 $X=417450 $Y=21760
X61872 1 2 546 528 7630 803 EN3_5VX1 $T=435240 71680 1 180 $X=422490 $Y=71040
X61873 1 2 7691 7679 7620 7702 EN3_5VX1 $T=438040 143360 1 180 $X=425290 $Y=142720
X61874 1 2 7718 7720 7711 7682 EN3_5VX1 $T=438600 116480 1 180 $X=425850 $Y=115840
X61875 1 2 7685 7676 7697 9691 EN3_5VX1 $T=427960 197120 0 0 $X=427530 $Y=196480
X61876 1 2 7725 9694 7690 7708 EN3_5VX1 $T=447000 89600 0 180 $X=434250 $Y=84480
X61877 1 2 7764 7771 7758 9706 EN3_5VX1 $T=460440 143360 1 180 $X=447690 $Y=142720
X61878 1 2 7769 9725 7759 9708 EN3_5VX1 $T=461000 161280 1 180 $X=448250 $Y=160640
X61879 1 2 7767 7739 7752 9717 EN3_5VX1 $T=464360 71680 1 180 $X=451610 $Y=71040
X61880 1 2 7774 7807 7768 9722 EN3_5VX1 $T=464360 125440 0 180 $X=451610 $Y=120320
X61881 1 2 9716 7762 7761 7789 EN3_5VX1 $T=456520 62720 0 0 $X=456090 $Y=62080
X61882 1 2 7783 7765 7793 9745 EN3_5VX1 $T=462680 44800 0 0 $X=462250 $Y=44160
X61883 1 2 7805 7809 7801 9746 EN3_5VX1 $T=463800 116480 0 0 $X=463370 $Y=115840
X61884 1 2 7802 9738 7799 9750 EN3_5VX1 $T=466600 26880 0 0 $X=466170 $Y=26240
X61885 1 2 7811 7819 7829 7826 EN3_5VX1 $T=469400 89600 0 0 $X=468970 $Y=88960
X61886 1 2 7825 7823 7838 9770 EN3_5VX1 $T=475000 71680 0 0 $X=474570 $Y=71040
X61887 1 2 677 678 7830 9768 EN3_5VX1 $T=477800 17920 0 0 $X=477370 $Y=17280
X61888 1 2 9757 7851 7846 9773 EN3_5VX1 $T=486200 53760 0 0 $X=485770 $Y=53120
X61889 1 2 7857 7854 7874 9775 EN3_5VX1 $T=486760 35840 1 0 $X=486330 $Y=30720
X61890 1 2 1131 1046 1074 AND2_5VX1 $T=-522360 232960 0 180 $X=-526710 $Y=227840
X61891 1 2 8202 1528 1796 AND2_5VX1 $T=-414840 134400 0 180 $X=-419190 $Y=129280
X61892 1 2 2831 2825 2863 AND2_5VX1 $T=-270920 313600 1 180 $X=-275270 $Y=312960
X61893 1 2 3801 2498 3896 AND2_5VX1 $T=-153880 224000 1 0 $X=-154310 $Y=218880
X61894 1 2 4946 4910 9027 AND2_5VX1 $T=21400 304640 1 180 $X=17050 $Y=304000
X61895 1 2 6443 6418 6477 AND2_5VX1 $T=173160 259840 0 0 $X=172730 $Y=259200
X61896 1 2 3 4 842 NO2I1_5VX1 $T=-578920 125440 1 180 $X=-583270 $Y=124800
X61897 1 2 884 899 9810 NO2I1_5VX1 $T=-577800 241920 1 180 $X=-582150 $Y=241280
X61898 1 2 9 4 861 NO2I1_5VX1 $T=-576120 62720 0 180 $X=-580470 $Y=57600
X61899 1 2 5 899 7937 NO2I1_5VX1 $T=-580040 206080 1 0 $X=-580470 $Y=200960
X61900 1 2 11 4 7935 NO2I1_5VX1 $T=-573320 17920 0 180 $X=-577670 $Y=12800
X61901 1 2 10 899 898 NO2I1_5VX1 $T=-576120 241920 0 0 $X=-576550 $Y=241280
X61902 1 2 903 4 866 NO2I1_5VX1 $T=-571640 152320 0 180 $X=-575990 $Y=147200
X61903 1 2 911 899 873 NO2I1_5VX1 $T=-569960 206080 0 180 $X=-574310 $Y=200960
X61904 1 2 914 4 865 NO2I1_5VX1 $T=-568840 143360 1 180 $X=-573190 $Y=142720
X61905 1 2 916 899 881 NO2I1_5VX1 $T=-568840 250880 1 180 $X=-573190 $Y=250240
X61906 1 2 876 899 867 NO2I1_5VX1 $T=-566600 179200 1 180 $X=-570950 $Y=178560
X61907 1 2 857 899 880 NO2I1_5VX1 $T=-566600 224000 0 180 $X=-570950 $Y=218880
X61908 1 2 891 899 943 NO2I1_5VX1 $T=-568840 170240 0 0 $X=-569270 $Y=169600
X61909 1 2 941 899 850 NO2I1_5VX1 $T=-562680 188160 0 180 $X=-567030 $Y=183040
X61910 1 2 950 4 7939 NO2I1_5VX1 $T=-562120 107520 1 180 $X=-566470 $Y=106880
X61911 1 2 706 4 7944 NO2I1_5VX1 $T=-566040 143360 1 0 $X=-566470 $Y=138240
X61912 1 2 7951 4 897 NO2I1_5VX1 $T=-561560 116480 1 180 $X=-565910 $Y=115840
X61913 1 2 904 899 7954 NO2I1_5VX1 $T=-565480 170240 1 0 $X=-565910 $Y=165120
X61914 1 2 906 899 7948 NO2I1_5VX1 $T=-559880 197120 0 180 $X=-564230 $Y=192000
X61915 1 2 900 899 7950 NO2I1_5VX1 $T=-559320 215040 0 180 $X=-563670 $Y=209920
X61916 1 2 915 899 7953 NO2I1_5VX1 $T=-563240 232960 0 0 $X=-563670 $Y=232320
X61917 1 2 942 4 7956 NO2I1_5VX1 $T=-561000 107520 1 0 $X=-561430 $Y=102400
X61918 1 2 941 899 951 NO2I1_5VX1 $T=-561000 188160 1 0 $X=-561430 $Y=183040
X61919 1 2 940 899 815 NO2I1_5VX1 $T=-560440 170240 0 0 $X=-560870 $Y=169600
X61920 1 2 938 899 939 NO2I1_5VX1 $T=-553160 224000 0 180 $X=-557510 $Y=218880
X61921 1 2 990 899 945 NO2I1_5VX1 $T=-553160 286720 0 180 $X=-557510 $Y=281600
X61922 1 2 944 899 7960 NO2I1_5VX1 $T=-555960 259840 1 0 $X=-556390 $Y=254720
X61923 1 2 962 899 981 NO2I1_5VX1 $T=-555960 277760 1 0 $X=-556390 $Y=272640
X61924 1 2 932 899 7962 NO2I1_5VX1 $T=-554840 250880 1 0 $X=-555270 $Y=245760
X61925 1 2 929 974 961 NO2I1_5VX1 $T=-549800 161280 0 180 $X=-554150 $Y=156160
X61926 1 2 957 899 1042 NO2I1_5VX1 $T=-552040 241920 1 0 $X=-552470 $Y=236800
X61927 1 2 985 4 7965 NO2I1_5VX1 $T=-551480 116480 0 0 $X=-551910 $Y=115840
X61928 1 2 996 899 967 NO2I1_5VX1 $T=-547560 295680 1 180 $X=-551910 $Y=295040
X61929 1 2 13 899 997 NO2I1_5VX1 $T=-551480 340480 0 0 $X=-551910 $Y=339840
X61930 1 2 956 974 7964 NO2I1_5VX1 $T=-550920 143360 0 0 $X=-551350 $Y=142720
X61931 1 2 14 899 1033 NO2I1_5VX1 $T=-548680 313600 1 0 $X=-549110 $Y=308480
X61932 1 2 12 899 1390 NO2I1_5VX1 $T=-548680 349440 1 0 $X=-549110 $Y=344320
X61933 1 2 1004 974 822 NO2I1_5VX1 $T=-544200 161280 0 180 $X=-548550 $Y=156160
X61934 1 2 887 899 1011 NO2I1_5VX1 $T=-546440 206080 0 0 $X=-546870 $Y=205440
X61935 1 2 911 899 1018 NO2I1_5VX1 $T=-546440 241920 0 0 $X=-546870 $Y=241280
X61936 1 2 1098 4 976 NO2I1_5VX1 $T=-541960 98560 0 0 $X=-542390 $Y=97920
X61937 1 2 980 4 7975 NO2I1_5VX1 $T=-541960 116480 0 0 $X=-542390 $Y=115840
X61938 1 2 1028 15 811 NO2I1_5VX1 $T=-541960 241920 0 0 $X=-542390 $Y=241280
X61939 1 2 994 899 1094 NO2I1_5VX1 $T=-541960 277760 1 0 $X=-542390 $Y=272640
X61940 1 2 1016 974 829 NO2I1_5VX1 $T=-540280 188160 1 0 $X=-540710 $Y=183040
X61941 1 2 977 974 963 NO2I1_5VX1 $T=-535800 134400 1 180 $X=-540150 $Y=133760
X61942 1 2 1036 7978 7984 NO2I1_5VX1 $T=-539720 188160 0 0 $X=-540150 $Y=187520
X61943 1 2 1027 1058 7985 NO2I1_5VX1 $T=-539160 206080 1 0 $X=-539590 $Y=200960
X61944 1 2 9792 899 1032 NO2I1_5VX1 $T=-535240 295680 0 180 $X=-539590 $Y=290560
X61945 1 2 1056 4 7986 NO2I1_5VX1 $T=-536360 98560 0 0 $X=-536790 $Y=97920
X61946 1 2 9962 974 1005 NO2I1_5VX1 $T=-535240 134400 1 0 $X=-535670 $Y=129280
X61947 1 2 7992 974 807 NO2I1_5VX1 $T=-531320 152320 1 180 $X=-535670 $Y=151680
X61948 1 2 1023 15 7988 NO2I1_5VX1 $T=-534680 259840 1 0 $X=-535110 $Y=254720
X61949 1 2 1081 899 1055 NO2I1_5VX1 $T=-530760 304640 0 180 $X=-535110 $Y=299520
X61950 1 2 1051 974 1050 NO2I1_5VX1 $T=-534120 125440 1 0 $X=-534550 $Y=120320
X61951 1 2 1010 974 812 NO2I1_5VX1 $T=-530200 134400 1 180 $X=-534550 $Y=133760
X61952 1 2 1108 15 7989 NO2I1_5VX1 $T=-526840 268800 0 180 $X=-531190 $Y=263680
X61953 1 2 1274 974 830 NO2I1_5VX1 $T=-528520 179200 0 0 $X=-528950 $Y=178560
X61954 1 2 1046 974 1045 NO2I1_5VX1 $T=-528520 188160 0 0 $X=-528950 $Y=187520
X61955 1 2 8000 974 8003 NO2I1_5VX1 $T=-527400 125440 1 0 $X=-527830 $Y=120320
X61956 1 2 1106 15 979 NO2I1_5VX1 $T=-525160 268800 1 0 $X=-525590 $Y=263680
X61957 1 2 1048 899 1130 NO2I1_5VX1 $T=-524600 206080 0 0 $X=-525030 $Y=205440
X61958 1 2 1111 899 8009 NO2I1_5VX1 $T=-523480 295680 1 0 $X=-523910 $Y=290560
X61959 1 2 973 15 834 NO2I1_5VX1 $T=-521800 215040 0 0 $X=-522230 $Y=214400
X61960 1 2 1131 15 817 NO2I1_5VX1 $T=-521240 232960 1 0 $X=-521670 $Y=227840
X61961 1 2 9812 974 909 NO2I1_5VX1 $T=-520680 107520 0 0 $X=-521110 $Y=106880
X61962 1 2 1090 15 1143 NO2I1_5VX1 $T=-520120 286720 1 0 $X=-520550 $Y=281600
X61963 1 2 1157 4 1148 NO2I1_5VX1 $T=-513400 98560 0 180 $X=-517750 $Y=93440
X61964 1 2 1168 974 1142 NO2I1_5VX1 $T=-512280 125440 0 180 $X=-516630 $Y=120320
X61965 1 2 1128 974 1144 NO2I1_5VX1 $T=-511160 107520 0 180 $X=-515510 $Y=102400
X61966 1 2 1191 899 1153 NO2I1_5VX1 $T=-510040 304640 0 180 $X=-514390 $Y=299520
X61967 1 2 8031 15 882 NO2I1_5VX1 $T=-509480 277760 0 180 $X=-513830 $Y=272640
X61968 1 2 901 15 841 NO2I1_5VX1 $T=-508360 224000 1 180 $X=-512710 $Y=223360
X61969 1 2 1003 4 1198 NO2I1_5VX1 $T=-511720 80640 0 0 $X=-512150 $Y=80000
X61970 1 2 1164 4 955 NO2I1_5VX1 $T=-510600 98560 1 0 $X=-511030 $Y=93440
X61971 1 2 1202 15 1215 NO2I1_5VX1 $T=-510040 286720 1 0 $X=-510470 $Y=281600
X61972 1 2 8032 974 1009 NO2I1_5VX1 $T=-509480 107520 1 0 $X=-509910 $Y=102400
X61973 1 2 8045 4 970 NO2I1_5VX1 $T=-502200 89600 0 180 $X=-506550 $Y=84480
X61974 1 2 1237 899 8037 NO2I1_5VX1 $T=-502200 313600 0 180 $X=-506550 $Y=308480
X61975 1 2 1204 974 8042 NO2I1_5VX1 $T=-498840 116480 0 180 $X=-503190 $Y=111360
X61976 1 2 930 15 1251 NO2I1_5VX1 $T=-502200 241920 1 0 $X=-502630 $Y=236800
X61977 1 2 1216 15 8043 NO2I1_5VX1 $T=-496600 295680 0 180 $X=-500950 $Y=290560
X61978 1 2 1248 899 1279 NO2I1_5VX1 $T=-499960 206080 0 0 $X=-500390 $Y=205440
X61979 1 2 1238 899 8050 NO2I1_5VX1 $T=-495480 313600 0 180 $X=-499830 $Y=308480
X61980 1 2 1243 899 8062 NO2I1_5VX1 $T=-498280 197120 0 0 $X=-498710 $Y=196480
X61981 1 2 1225 4 8053 NO2I1_5VX1 $T=-491560 89600 0 180 $X=-495910 $Y=84480
X61982 1 2 1217 974 937 NO2I1_5VX1 $T=-495480 116480 1 0 $X=-495910 $Y=111360
X61983 1 2 8063 15 1230 NO2I1_5VX1 $T=-491560 286720 0 180 $X=-495910 $Y=281600
X61984 1 2 8066 899 8054 NO2I1_5VX1 $T=-491000 188160 1 180 $X=-495350 $Y=187520
X61985 1 2 9794 899 816 NO2I1_5VX1 $T=-494920 215040 1 0 $X=-495350 $Y=209920
X61986 1 2 1270 974 1327 NO2I1_5VX1 $T=-491000 107520 0 0 $X=-491430 $Y=106880
X61987 1 2 8069 4 1133 NO2I1_5VX1 $T=-490440 89600 1 0 $X=-490870 $Y=84480
X61988 1 2 1340 4 1031 NO2I1_5VX1 $T=-485400 71680 0 180 $X=-489750 $Y=66560
X61989 1 2 1145 974 1330 NO2I1_5VX1 $T=-484280 161280 0 180 $X=-488630 $Y=156160
X61990 1 2 921 15 1341 NO2I1_5VX1 $T=-488200 232960 1 0 $X=-488630 $Y=227840
X61991 1 2 1301 15 8073 NO2I1_5VX1 $T=-483720 295680 0 180 $X=-488070 $Y=290560
X61992 1 2 9796 4 22 NO2I1_5VX1 $T=-480920 17920 0 180 $X=-485270 $Y=12800
X61993 1 2 9963 4 913 NO2I1_5VX1 $T=-484280 80640 0 0 $X=-484710 $Y=80000
X61994 1 2 1362 4 1177 NO2I1_5VX1 $T=-483160 26880 1 0 $X=-483590 $Y=21760
X61995 1 2 958 899 1352 NO2I1_5VX1 $T=-483160 215040 1 0 $X=-483590 $Y=209920
X61996 1 2 1332 15 840 NO2I1_5VX1 $T=-483160 232960 1 0 $X=-483590 $Y=227840
X61997 1 2 1339 15 1383 NO2I1_5VX1 $T=-482600 295680 0 0 $X=-483030 $Y=295040
X61998 1 2 1291 4 1139 NO2I1_5VX1 $T=-479800 71680 0 0 $X=-480230 $Y=71040
X61999 1 2 1391 4 1192 NO2I1_5VX1 $T=-478120 35840 0 0 $X=-478550 $Y=35200
X62000 1 2 1350 4 8091 NO2I1_5VX1 $T=-477560 44800 0 0 $X=-477990 $Y=44160
X62001 1 2 8087 15 1405 NO2I1_5VX1 $T=-477560 295680 0 0 $X=-477990 $Y=295040
X62002 1 2 1398 1408 1361 NO2I1_5VX1 $T=-473640 304640 1 180 $X=-477990 $Y=304000
X62003 1 2 1368 1408 1406 NO2I1_5VX1 $T=-477560 331520 0 0 $X=-477990 $Y=330880
X62004 1 2 1439 4 1141 NO2I1_5VX1 $T=-473080 53760 1 180 $X=-477430 $Y=53120
X62005 1 2 1411 1408 8099 NO2I1_5VX1 $T=-472520 304640 0 0 $X=-472950 $Y=304000
X62006 1 2 1219 899 1447 NO2I1_5VX1 $T=-471400 241920 1 0 $X=-471830 $Y=236800
X62007 1 2 1167 15 1422 NO2I1_5VX1 $T=-467480 259840 0 180 $X=-471830 $Y=254720
X62008 1 2 8100 4 1176 NO2I1_5VX1 $T=-466920 98560 1 180 $X=-471270 $Y=97920
X62009 1 2 1296 4 1416 NO2I1_5VX1 $T=-464680 53760 1 180 $X=-469030 $Y=53120
X62010 1 2 1489 899 809 NO2I1_5VX1 $T=-463000 215040 1 180 $X=-467350 $Y=214400
X62011 1 2 1454 1408 8112 NO2I1_5VX1 $T=-465240 304640 0 0 $X=-465670 $Y=304000
X62012 1 2 8105 1408 9790 NO2I1_5VX1 $T=-464680 232960 0 0 $X=-465110 $Y=232320
X62013 1 2 1465 4 832 NO2I1_5VX1 $T=-464120 152320 0 0 $X=-464550 $Y=151680
X62014 1 2 1138 899 1085 NO2I1_5VX1 $T=-461320 179200 0 0 $X=-461750 $Y=178560
X62015 1 2 8124 4 875 NO2I1_5VX1 $T=-456840 143360 0 180 $X=-461190 $Y=138240
X62016 1 2 1511 4 1114 NO2I1_5VX1 $T=-456280 80640 0 180 $X=-460630 $Y=75520
X62017 1 2 1302 4 1482 NO2I1_5VX1 $T=-455160 152320 0 180 $X=-459510 $Y=147200
X62018 1 2 1507 899 1557 NO2I1_5VX1 $T=-459080 232960 0 0 $X=-459510 $Y=232320
X62019 1 2 1229 1408 1502 NO2I1_5VX1 $T=-455160 259840 1 180 $X=-459510 $Y=259200
X62020 1 2 1379 899 8117 NO2I1_5VX1 $T=-454600 170240 0 180 $X=-458950 $Y=165120
X62021 1 2 1510 1408 8115 NO2I1_5VX1 $T=-454600 304640 1 180 $X=-458950 $Y=304000
X62022 1 2 1601 1408 8120 NO2I1_5VX1 $T=-454600 340480 1 180 $X=-458950 $Y=339840
X62023 1 2 1548 1408 1476 NO2I1_5VX1 $T=-454040 322560 1 180 $X=-458390 $Y=321920
X62024 1 2 1376 1408 1553 NO2I1_5VX1 $T=-455160 268800 0 0 $X=-455590 $Y=268160
X62025 1 2 1250 4 1538 NO2I1_5VX1 $T=-450120 80640 1 180 $X=-454470 $Y=80000
X62026 1 2 1374 1408 1568 NO2I1_5VX1 $T=-453480 250880 1 0 $X=-453910 $Y=245760
X62027 1 2 8140 899 1015 NO2I1_5VX1 $T=-449000 170240 0 180 $X=-453350 $Y=165120
X62028 1 2 8136 1408 8130 NO2I1_5VX1 $T=-447320 241920 1 180 $X=-451670 $Y=241280
X62029 1 2 1556 1408 8135 NO2I1_5VX1 $T=-451240 331520 1 0 $X=-451670 $Y=326400
X62030 1 2 1564 974 954 NO2I1_5VX1 $T=-450680 107520 1 0 $X=-451110 $Y=102400
X62031 1 2 1433 1408 1604 NO2I1_5VX1 $T=-448440 349440 1 0 $X=-448870 $Y=344320
X62032 1 2 9821 1408 1590 NO2I1_5VX1 $T=-442280 241920 1 180 $X=-446630 $Y=241280
X62033 1 2 709 1614 8142 NO2I1_5VX1 $T=-441160 116480 1 180 $X=-445510 $Y=115840
X62034 1 2 8141 974 828 NO2I1_5VX1 $T=-441160 161280 0 180 $X=-445510 $Y=156160
X62035 1 2 1677 4 1210 NO2I1_5VX1 $T=-440040 98560 0 180 $X=-444390 $Y=93440
X62036 1 2 1433 1408 1660 NO2I1_5VX1 $T=-441720 349440 0 0 $X=-442150 $Y=348800
X62037 1 2 1431 899 8153 NO2I1_5VX1 $T=-441160 179200 1 0 $X=-441590 $Y=174080
X62038 1 2 1601 1408 1654 NO2I1_5VX1 $T=-441160 349440 1 0 $X=-441590 $Y=344320
X62039 1 2 8143 974 1619 NO2I1_5VX1 $T=-440040 161280 0 0 $X=-440470 $Y=160640
X62040 1 2 1212 899 1645 NO2I1_5VX1 $T=-433880 188160 1 180 $X=-438230 $Y=187520
X62041 1 2 1160 899 1692 NO2I1_5VX1 $T=-437240 206080 0 0 $X=-437670 $Y=205440
X62042 1 2 1694 899 1672 NO2I1_5VX1 $T=-432200 179200 0 180 $X=-436550 $Y=174080
X62043 1 2 1599 1408 1712 NO2I1_5VX1 $T=-436120 313600 1 0 $X=-436550 $Y=308480
X62044 1 2 1594 1408 8156 NO2I1_5VX1 $T=-431080 304640 1 180 $X=-435430 $Y=304000
X62045 1 2 1623 1408 1690 NO2I1_5VX1 $T=-429960 331520 0 180 $X=-434310 $Y=326400
X62046 1 2 1716 1408 1640 NO2I1_5VX1 $T=-428840 250880 0 180 $X=-433190 $Y=245760
X62047 1 2 8157 1697 1729 NO2I1_5VX1 $T=-430520 125440 1 0 $X=-430950 $Y=120320
X62048 1 2 1747 899 1727 NO2I1_5VX1 $T=-424920 188160 1 180 $X=-429270 $Y=187520
X62049 1 2 1289 899 1755 NO2I1_5VX1 $T=-428280 224000 0 0 $X=-428710 $Y=223360
X62050 1 2 1756 1408 1740 NO2I1_5VX1 $T=-423240 313600 0 180 $X=-427590 $Y=308480
X62051 1 2 1426 899 1744 NO2I1_5VX1 $T=-419320 188160 0 180 $X=-423670 $Y=183040
X62052 1 2 8185 974 1155 NO2I1_5VX1 $T=-422120 107520 1 0 $X=-422550 $Y=102400
X62053 1 2 1802 8189 1761 NO2I1_5VX1 $T=-418200 286720 1 180 $X=-422550 $Y=286080
X62054 1 2 1674 1598 8189 NO2I1_5VX1 $T=-422120 304640 1 0 $X=-422550 $Y=299520
X62055 1 2 1768 1408 8194 NO2I1_5VX1 $T=-419880 322560 0 0 $X=-420310 $Y=321920
X62056 1 2 1368 1408 1824 NO2I1_5VX1 $T=-419320 331520 0 0 $X=-419750 $Y=330880
X62057 1 2 1272 974 1851 NO2I1_5VX1 $T=-417080 107520 1 0 $X=-417510 $Y=102400
X62058 1 2 914 974 1826 NO2I1_5VX1 $T=-417080 188160 1 0 $X=-417510 $Y=183040
X62059 1 2 1674 1408 1841 NO2I1_5VX1 $T=-417080 304640 1 0 $X=-417510 $Y=299520
X62060 1 2 1858 974 8195 NO2I1_5VX1 $T=-412040 179200 0 180 $X=-416390 $Y=174080
X62061 1 2 8210 974 1845 NO2I1_5VX1 $T=-409800 197120 0 180 $X=-414150 $Y=192000
X62062 1 2 1598 1408 1881 NO2I1_5VX1 $T=-410360 304640 1 0 $X=-410790 $Y=299520
X62063 1 2 1680 1491 1901 NO2I1_5VX1 $T=-409800 277760 1 0 $X=-410230 $Y=272640
X62064 1 2 1865 1408 9824 NO2I1_5VX1 $T=-408120 295680 1 0 $X=-408550 $Y=290560
X62065 1 2 8213 974 1062 NO2I1_5VX1 $T=-407560 107520 0 0 $X=-407990 $Y=106880
X62066 1 2 1628 974 1904 NO2I1_5VX1 $T=-407560 197120 1 0 $X=-407990 $Y=192000
X62067 1 2 1925 1408 8215 NO2I1_5VX1 $T=-403080 322560 0 180 $X=-407430 $Y=317440
X62068 1 2 1699 1408 1924 NO2I1_5VX1 $T=-406440 286720 1 0 $X=-406870 $Y=281600
X62069 1 2 1648 974 1927 NO2I1_5VX1 $T=-405880 197120 0 0 $X=-406310 $Y=196480
X62070 1 2 8227 974 999 NO2I1_5VX1 $T=-400840 116480 1 180 $X=-405190 $Y=115840
X62071 1 2 1899 974 1944 NO2I1_5VX1 $T=-400280 188160 0 180 $X=-404630 $Y=183040
X62072 1 2 1680 1408 2001 NO2I1_5VX1 $T=-400280 268800 0 0 $X=-400710 $Y=268160
X62073 1 2 1848 1514 1956 NO2I1_5VX1 $T=-399720 224000 0 0 $X=-400150 $Y=223360
X62074 1 2 8228 974 1969 NO2I1_5VX1 $T=-399160 188160 1 0 $X=-399590 $Y=183040
X62075 1 2 1436 1408 1959 NO2I1_5VX1 $T=-396920 295680 1 0 $X=-397350 $Y=290560
X62076 1 2 1191 1408 2010 NO2I1_5VX1 $T=-395800 313600 1 0 $X=-396230 $Y=308480
X62077 1 2 1491 1408 2015 NO2I1_5VX1 $T=-395240 250880 1 0 $X=-395670 $Y=245760
X62078 1 2 2002 1408 2016 NO2I1_5VX1 $T=-395240 304640 1 0 $X=-395670 $Y=299520
X62079 1 2 8232 1408 1840 NO2I1_5VX1 $T=-394680 224000 0 0 $X=-395110 $Y=223360
X62080 1 2 1870 974 2043 NO2I1_5VX1 $T=-393560 107520 0 0 $X=-393990 $Y=106880
X62081 1 2 9964 974 1101 NO2I1_5VX1 $T=-393000 125440 1 0 $X=-393430 $Y=120320
X62082 1 2 1524 974 2086 NO2I1_5VX1 $T=-387960 107520 0 0 $X=-388390 $Y=106880
X62083 1 2 2097 1408 1991 NO2I1_5VX1 $T=-384040 277760 1 180 $X=-388390 $Y=277120
X62084 1 2 1365 974 2116 NO2I1_5VX1 $T=-384600 125440 1 0 $X=-385030 $Y=120320
X62085 1 2 1929 1408 2140 NO2I1_5VX1 $T=-382920 232960 1 0 $X=-383350 $Y=227840
X62086 1 2 8254 1408 1866 NO2I1_5VX1 $T=-382920 259840 1 0 $X=-383350 $Y=254720
X62087 1 2 1949 78 2129 NO2I1_5VX1 $T=-382360 71680 0 0 $X=-382790 $Y=71040
X62088 1 2 959 1408 2327 NO2I1_5VX1 $T=-381800 304640 1 0 $X=-382230 $Y=299520
X62089 1 2 9965 1408 2148 NO2I1_5VX1 $T=-380680 286720 0 0 $X=-381110 $Y=286080
X62090 1 2 1353 974 82 NO2I1_5VX1 $T=-380120 107520 1 0 $X=-380550 $Y=102400
X62091 1 2 1643 974 2156 NO2I1_5VX1 $T=-379560 125440 1 0 $X=-379990 $Y=120320
X62092 1 2 2069 1929 2196 NO2I1_5VX1 $T=-377320 232960 0 0 $X=-377750 $Y=232320
X62093 1 2 1064 1408 2204 NO2I1_5VX1 $T=-374520 295680 1 0 $X=-374950 $Y=290560
X62094 1 2 1790 1408 2064 NO2I1_5VX1 $T=-369480 277760 0 180 $X=-373830 $Y=272640
X62095 1 2 2052 2196 1935 NO2I1_5VX1 $T=-367800 232960 1 180 $X=-372150 $Y=232320
X62096 1 2 1370 78 2229 NO2I1_5VX1 $T=-369480 26880 0 0 $X=-369910 $Y=26240
X62097 1 2 1386 78 2230 NO2I1_5VX1 $T=-369480 35840 0 0 $X=-369910 $Y=35200
X62098 1 2 2219 78 1043 NO2I1_5VX1 $T=-369480 62720 1 0 $X=-369910 $Y=57600
X62099 1 2 8287 974 1933 NO2I1_5VX1 $T=-363880 143360 0 180 $X=-368230 $Y=138240
X62100 1 2 2240 78 2102 NO2I1_5VX1 $T=-363320 215040 0 180 $X=-367670 $Y=209920
X62101 1 2 8286 1408 2082 NO2I1_5VX1 $T=-363320 268800 1 180 $X=-367670 $Y=268160
X62102 1 2 1363 78 2365 NO2I1_5VX1 $T=-366680 44800 1 0 $X=-367110 $Y=39680
X62103 1 2 2178 78 2241 NO2I1_5VX1 $T=-366680 116480 0 0 $X=-367110 $Y=115840
X62104 1 2 1349 78 2250 NO2I1_5VX1 $T=-366120 17920 0 0 $X=-366550 $Y=17280
X62105 1 2 1313 974 8288 NO2I1_5VX1 $T=-366120 125440 1 0 $X=-366550 $Y=120320
X62106 1 2 2235 974 2242 NO2I1_5VX1 $T=-366120 134400 1 0 $X=-366550 $Y=129280
X62107 1 2 2117 974 8289 NO2I1_5VX1 $T=-366120 134400 0 0 $X=-366550 $Y=133760
X62108 1 2 2069 1408 8262 NO2I1_5VX1 $T=-362200 232960 1 180 $X=-366550 $Y=232320
X62109 1 2 8284 78 1159 NO2I1_5VX1 $T=-365560 26880 0 0 $X=-365990 $Y=26240
X62110 1 2 8285 78 1178 NO2I1_5VX1 $T=-365560 35840 0 0 $X=-365990 $Y=35200
X62111 1 2 1388 78 2366 NO2I1_5VX1 $T=-365560 53760 1 0 $X=-365990 $Y=48640
X62112 1 2 1769 78 2268 NO2I1_5VX1 $T=-365560 62720 1 0 $X=-365990 $Y=57600
X62113 1 2 8051 78 2367 NO2I1_5VX1 $T=-365560 62720 0 0 $X=-365990 $Y=62080
X62114 1 2 1222 78 2276 NO2I1_5VX1 $T=-365560 89600 1 0 $X=-365990 $Y=84480
X62115 1 2 1392 78 2337 NO2I1_5VX1 $T=-365560 107520 1 0 $X=-365990 $Y=102400
X62116 1 2 2018 78 1121 NO2I1_5VX1 $T=-348200 80640 0 0 $X=-348630 $Y=80000
X62117 1 2 2281 78 88 NO2I1_5VX1 $T=-348200 107520 1 0 $X=-348630 $Y=102400
X62118 1 2 1975 974 1323 NO2I1_5VX1 $T=-347640 125440 1 0 $X=-348070 $Y=120320
X62119 1 2 2278 974 2319 NO2I1_5VX1 $T=-347640 134400 1 0 $X=-348070 $Y=129280
X62120 1 2 8290 974 1122 NO2I1_5VX1 $T=-347640 134400 0 0 $X=-348070 $Y=133760
X62121 1 2 2279 974 2312 NO2I1_5VX1 $T=-347640 143360 1 0 $X=-348070 $Y=138240
X62122 1 2 8292 78 2318 NO2I1_5VX1 $T=-347640 215040 0 0 $X=-348070 $Y=214400
X62123 1 2 884 1408 8301 NO2I1_5VX1 $T=-347640 259840 0 0 $X=-348070 $Y=259200
X62124 1 2 2290 974 86 NO2I1_5VX1 $T=-346520 116480 1 0 $X=-346950 $Y=111360
X62125 1 2 1461 78 2343 NO2I1_5VX1 $T=-344280 80640 0 0 $X=-344710 $Y=80000
X62126 1 2 2335 78 9800 NO2I1_5VX1 $T=-342600 116480 1 0 $X=-343030 $Y=111360
X62127 1 2 2270 78 2371 NO2I1_5VX1 $T=-340360 107520 1 0 $X=-340790 $Y=102400
X62128 1 2 2355 78 2406 NO2I1_5VX1 $T=-338680 161280 1 0 $X=-339110 $Y=156160
X62129 1 2 8315 78 1068 NO2I1_5VX1 $T=-336440 107520 1 0 $X=-336870 $Y=102400
X62130 1 2 2434 1408 2383 NO2I1_5VX1 $T=-331960 250880 0 180 $X=-336310 $Y=245760
X62131 1 2 1541 974 2446 NO2I1_5VX1 $T=-334760 134400 1 0 $X=-335190 $Y=129280
X62132 1 2 9966 78 1220 NO2I1_5VX1 $T=-333640 26880 1 0 $X=-334070 $Y=21760
X62133 1 2 8318 78 99 NO2I1_5VX1 $T=-333640 71680 0 0 $X=-334070 $Y=71040
X62134 1 2 2400 1408 8323 NO2I1_5VX1 $T=-333640 241920 1 0 $X=-334070 $Y=236800
X62135 1 2 8316 78 2150 NO2I1_5VX1 $T=-333080 161280 1 0 $X=-333510 $Y=156160
X62136 1 2 2293 1408 8327 NO2I1_5VX1 $T=-332520 268800 1 0 $X=-332950 $Y=263680
X62137 1 2 2443 2435 2416 NO2I1_5VX1 $T=-328600 295680 1 180 $X=-332950 $Y=295040
X62138 1 2 2419 78 2447 NO2I1_5VX1 $T=-331960 152320 0 0 $X=-332390 $Y=151680
X62139 1 2 2449 2435 2351 NO2I1_5VX1 $T=-328040 277760 1 180 $X=-332390 $Y=277120
X62140 1 2 1795 78 2453 NO2I1_5VX1 $T=-331400 35840 0 0 $X=-331830 $Y=35200
X62141 1 2 8325 78 2454 NO2I1_5VX1 $T=-331400 170240 0 0 $X=-331830 $Y=169600
X62142 1 2 9967 974 1779 NO2I1_5VX1 $T=-330840 143360 0 0 $X=-331270 $Y=142720
X62143 1 2 2376 1408 8303 NO2I1_5VX1 $T=-326360 259840 0 180 $X=-330710 $Y=254720
X62144 1 2 2445 974 102 NO2I1_5VX1 $T=-329160 125440 1 0 $X=-329590 $Y=120320
X62145 1 2 2440 78 2844 NO2I1_5VX1 $T=-329160 170240 1 0 $X=-329590 $Y=165120
X62146 1 2 2358 2435 2421 NO2I1_5VX1 $T=-325240 304640 1 180 $X=-329590 $Y=304000
X62147 1 2 2374 2435 2407 NO2I1_5VX1 $T=-325240 313600 1 180 $X=-329590 $Y=312960
X62148 1 2 2438 974 2861 NO2I1_5VX1 $T=-328600 116480 0 0 $X=-329030 $Y=115840
X62149 1 2 1758 974 2521 NO2I1_5VX1 $T=-328600 134400 1 0 $X=-329030 $Y=129280
X62150 1 2 2292 78 8330 NO2I1_5VX1 $T=-324680 224000 0 180 $X=-329030 $Y=218880
X62151 1 2 2252 2435 2357 NO2I1_5VX1 $T=-324120 286720 1 180 $X=-328470 $Y=286080
X62152 1 2 2387 2435 2394 NO2I1_5VX1 $T=-323560 331520 0 180 $X=-327910 $Y=326400
X62153 1 2 2501 2435 2430 NO2I1_5VX1 $T=-323000 331520 1 180 $X=-327350 $Y=330880
X62154 1 2 8333 78 2172 NO2I1_5VX1 $T=-326360 179200 0 0 $X=-326790 $Y=178560
X62155 1 2 950 78 2496 NO2I1_5VX1 $T=-326360 188160 1 0 $X=-326790 $Y=183040
X62156 1 2 8332 974 1072 NO2I1_5VX1 $T=-325240 134400 0 0 $X=-325670 $Y=133760
X62157 1 2 2247 974 2522 NO2I1_5VX1 $T=-325240 143360 0 0 $X=-325670 $Y=142720
X62158 1 2 2488 2499 2509 NO2I1_5VX1 $T=-325240 349440 0 0 $X=-325670 $Y=348800
X62159 1 2 2233 974 2520 NO2I1_5VX1 $T=-323000 116480 0 0 $X=-323430 $Y=115840
X62160 1 2 8331 78 2531 NO2I1_5VX1 $T=-320760 179200 0 0 $X=-321190 $Y=178560
X62161 1 2 2413 974 2548 NO2I1_5VX1 $T=-319640 134400 0 0 $X=-320070 $Y=133760
X62162 1 2 2514 1408 8354 NO2I1_5VX1 $T=-316280 259840 1 0 $X=-316710 $Y=254720
X62163 1 2 2602 1408 8353 NO2I1_5VX1 $T=-315160 232960 1 0 $X=-315590 $Y=227840
X62164 1 2 2560 1408 8359 NO2I1_5VX1 $T=-312920 241920 0 0 $X=-313350 $Y=241280
X62165 1 2 2608 2499 8355 NO2I1_5VX1 $T=-309000 367360 0 180 $X=-313350 $Y=362240
X62166 1 2 2467 78 2035 NO2I1_5VX1 $T=-312360 179200 0 0 $X=-312790 $Y=178560
X62167 1 2 2525 1408 8360 NO2I1_5VX1 $T=-312360 259840 0 0 $X=-312790 $Y=259200
X62168 1 2 8356 78 2182 NO2I1_5VX1 $T=-311240 152320 0 0 $X=-311670 $Y=151680
X62169 1 2 2515 2435 8365 NO2I1_5VX1 $T=-310120 286720 1 0 $X=-310550 $Y=281600
X62170 1 2 2524 1408 8370 NO2I1_5VX1 $T=-309560 232960 1 0 $X=-309990 $Y=227840
X62171 1 2 2561 2435 8357 NO2I1_5VX1 $T=-305640 268800 1 180 $X=-309990 $Y=268160
X62172 1 2 2563 2435 8366 NO2I1_5VX1 $T=-309560 295680 1 0 $X=-309990 $Y=290560
X62173 1 2 2587 2435 8371 NO2I1_5VX1 $T=-309560 322560 0 0 $X=-309990 $Y=321920
X62174 1 2 2592 78 3368 NO2I1_5VX1 $T=-309000 170240 0 0 $X=-309430 $Y=169600
X62175 1 2 2593 2435 8369 NO2I1_5VX1 $T=-308440 304640 0 0 $X=-308870 $Y=304000
X62176 1 2 2579 1408 2631 NO2I1_5VX1 $T=-307880 259840 1 0 $X=-308310 $Y=254720
X62177 1 2 2606 2435 2675 NO2I1_5VX1 $T=-307880 313600 0 0 $X=-308310 $Y=312960
X62178 1 2 2564 2435 2707 NO2I1_5VX1 $T=-307880 331520 0 0 $X=-308310 $Y=330880
X62179 1 2 2554 2499 8361 NO2I1_5VX1 $T=-303400 367360 0 180 $X=-307750 $Y=362240
X62180 1 2 2604 78 8178 NO2I1_5VX1 $T=-306200 152320 0 0 $X=-306630 $Y=151680
X62181 1 2 8358 78 1920 NO2I1_5VX1 $T=-306200 179200 0 0 $X=-306630 $Y=178560
X62182 1 2 2573 2435 2735 NO2I1_5VX1 $T=-305640 224000 1 0 $X=-306070 $Y=218880
X62183 1 2 2663 78 8368 NO2I1_5VX1 $T=-300600 215040 0 180 $X=-304950 $Y=209920
X62184 1 2 723 78 1882 NO2I1_5VX1 $T=-303960 170240 0 0 $X=-304390 $Y=169600
X62185 1 2 2627 2435 8379 NO2I1_5VX1 $T=-302280 331520 1 0 $X=-302710 $Y=326400
X62186 1 2 2612 78 1798 NO2I1_5VX1 $T=-301160 152320 0 0 $X=-301590 $Y=151680
X62187 1 2 2670 78 2689 NO2I1_5VX1 $T=-300600 179200 1 0 $X=-301030 $Y=174080
X62188 1 2 2686 2435 2653 NO2I1_5VX1 $T=-296120 232960 1 180 $X=-300470 $Y=232320
X62189 1 2 2463 2435 3215 NO2I1_5VX1 $T=-297240 331520 1 0 $X=-297670 $Y=326400
X62190 1 2 2712 2499 2720 NO2I1_5VX1 $T=-296680 385280 1 0 $X=-297110 $Y=380160
X62191 1 2 2654 2435 2690 NO2I1_5VX1 $T=-289400 250880 0 180 $X=-293750 $Y=245760
X62192 1 2 2541 2435 2751 NO2I1_5VX1 $T=-292200 268800 0 0 $X=-292630 $Y=268160
X62193 1 2 8382 2499 8400 NO2I1_5VX1 $T=-292200 340480 0 0 $X=-292630 $Y=339840
X62194 1 2 2651 2499 8398 NO2I1_5VX1 $T=-292200 349440 0 0 $X=-292630 $Y=348800
X62195 1 2 2773 2435 2722 NO2I1_5VX1 $T=-287160 215040 1 180 $X=-291510 $Y=214400
X62196 1 2 2671 2435 2731 NO2I1_5VX1 $T=-286600 241920 0 180 $X=-290950 $Y=236800
X62197 1 2 726 2435 2625 NO2I1_5VX1 $T=-286040 206080 1 180 $X=-290390 $Y=205440
X62198 1 2 2749 2435 2288 NO2I1_5VX1 $T=-289400 232960 1 0 $X=-289830 $Y=227840
X62199 1 2 2752 2499 8402 NO2I1_5VX1 $T=-288840 358400 1 0 $X=-289270 $Y=353280
X62200 1 2 2750 2435 2505 NO2I1_5VX1 $T=-287720 250880 1 0 $X=-288150 $Y=245760
X62201 1 2 2778 2841 2790 NO2I1_5VX1 $T=-286040 268800 0 0 $X=-286470 $Y=268160
X62202 1 2 2716 2435 8406 NO2I1_5VX1 $T=-285480 197120 0 0 $X=-285910 $Y=196480
X62203 1 2 2742 2435 2034 NO2I1_5VX1 $T=-284920 188160 1 0 $X=-285350 $Y=183040
X62204 1 2 2676 2499 2806 NO2I1_5VX1 $T=-284920 358400 1 0 $X=-285350 $Y=353280
X62205 1 2 2764 2499 2807 NO2I1_5VX1 $T=-284920 376320 0 0 $X=-285350 $Y=375680
X62206 1 2 2792 2810 2816 NO2I1_5VX1 $T=-283800 44800 1 0 $X=-284230 $Y=39680
X62207 1 2 2774 2814 2829 NO2I1_5VX1 $T=-282680 286720 0 0 $X=-283110 $Y=286080
X62208 1 2 8397 2499 2820 NO2I1_5VX1 $T=-277080 367360 1 180 $X=-281430 $Y=366720
X62209 1 2 8414 2435 8418 NO2I1_5VX1 $T=-280440 197120 0 0 $X=-280870 $Y=196480
X62210 1 2 2743 2435 2777 NO2I1_5VX1 $T=-275960 224000 0 180 $X=-280310 $Y=218880
X62211 1 2 2721 2435 3404 NO2I1_5VX1 $T=-279320 188160 1 0 $X=-279750 $Y=183040
X62212 1 2 8343 2810 140 NO2I1_5VX1 $T=-276520 80640 1 0 $X=-276950 $Y=75520
X62213 1 2 8412 2435 2304 NO2I1_5VX1 $T=-275960 224000 1 0 $X=-276390 $Y=218880
X62214 1 2 2767 2435 2851 NO2I1_5VX1 $T=-272040 241920 0 180 $X=-276390 $Y=236800
X62215 1 2 2661 2435 2868 NO2I1_5VX1 $T=-275400 179200 1 0 $X=-275830 $Y=174080
X62216 1 2 2542 2810 141 NO2I1_5VX1 $T=-274840 44800 0 0 $X=-275270 $Y=44160
X62217 1 2 2726 2435 2876 NO2I1_5VX1 $T=-274840 188160 0 0 $X=-275270 $Y=187520
X62218 1 2 2476 2499 8423 NO2I1_5VX1 $T=-270920 367360 1 180 $X=-275270 $Y=366720
X62219 1 2 2821 2499 2847 NO2I1_5VX1 $T=-270360 394240 1 180 $X=-274710 $Y=393600
X62220 1 2 2817 2435 2173 NO2I1_5VX1 $T=-273720 188160 1 0 $X=-274150 $Y=183040
X62221 1 2 2594 2435 2890 NO2I1_5VX1 $T=-273720 295680 1 0 $X=-274150 $Y=290560
X62222 1 2 8427 2435 2729 NO2I1_5VX1 $T=-273160 304640 0 0 $X=-273590 $Y=304000
X62223 1 2 2888 2940 2872 NO2I1_5VX1 $T=-268680 80640 0 180 $X=-273030 $Y=75520
X62224 1 2 135 143 8435 NO2I1_5VX1 $T=-272040 35840 1 0 $X=-272470 $Y=30720
X62225 1 2 2877 2435 2309 NO2I1_5VX1 $T=-272040 241920 1 0 $X=-272470 $Y=236800
X62226 1 2 2825 2435 3053 NO2I1_5VX1 $T=-270920 277760 1 0 $X=-271350 $Y=272640
X62227 1 2 2885 2499 8438 NO2I1_5VX1 $T=-269240 367360 0 0 $X=-269670 $Y=366720
X62228 1 2 2919 2499 2864 NO2I1_5VX1 $T=-265320 403200 1 180 $X=-269670 $Y=402560
X62229 1 2 9968 2435 2029 NO2I1_5VX1 $T=-268680 206080 1 0 $X=-269110 $Y=200960
X62230 1 2 3037 2435 2360 NO2I1_5VX1 $T=-268680 215040 0 0 $X=-269110 $Y=214400
X62231 1 2 2831 2435 2858 NO2I1_5VX1 $T=-268680 313600 0 0 $X=-269110 $Y=312960
X62232 1 2 2897 2810 2923 NO2I1_5VX1 $T=-268120 71680 0 0 $X=-268550 $Y=71040
X62233 1 2 2756 2435 2036 NO2I1_5VX1 $T=-268120 179200 0 0 $X=-268550 $Y=178560
X62234 1 2 2657 2435 8447 NO2I1_5VX1 $T=-268120 304640 0 0 $X=-268550 $Y=304000
X62235 1 2 2828 2435 3080 NO2I1_5VX1 $T=-261960 286720 0 180 $X=-266310 $Y=281600
X62236 1 2 2944 2499 2865 NO2I1_5VX1 $T=-263640 358400 1 0 $X=-264070 $Y=353280
X62237 1 2 2938 2499 8463 NO2I1_5VX1 $T=-262520 385280 1 0 $X=-262950 $Y=380160
X62238 1 2 2951 2499 2795 NO2I1_5VX1 $T=-261400 358400 0 0 $X=-261830 $Y=357760
X62239 1 2 8458 2499 2976 NO2I1_5VX1 $T=-260280 367360 0 0 $X=-260710 $Y=366720
X62240 1 2 2959 2499 2958 NO2I1_5VX1 $T=-253560 385280 1 180 $X=-257910 $Y=384640
X62241 1 2 2977 3042 3002 NO2I1_5VX1 $T=-250760 206080 1 180 $X=-255110 $Y=205440
X62242 1 2 2685 3042 8471 NO2I1_5VX1 $T=-250200 188160 0 0 $X=-250630 $Y=187520
X62243 1 2 2900 2435 3060 NO2I1_5VX1 $T=-249080 250880 1 0 $X=-249510 $Y=245760
X62244 1 2 2893 3042 8490 NO2I1_5VX1 $T=-248520 215040 1 0 $X=-248950 $Y=209920
X62245 1 2 3044 2435 3294 NO2I1_5VX1 $T=-248520 259840 0 0 $X=-248950 $Y=259200
X62246 1 2 2487 2435 3065 NO2I1_5VX1 $T=-248520 277760 0 0 $X=-248950 $Y=277120
X62247 1 2 3006 2499 8497 NO2I1_5VX1 $T=-247960 376320 1 0 $X=-248390 $Y=371200
X62248 1 2 9969 3042 3078 NO2I1_5VX1 $T=-246280 206080 1 0 $X=-246710 $Y=200960
X62249 1 2 3093 3042 3071 NO2I1_5VX1 $T=-241240 197120 0 180 $X=-245590 $Y=192000
X62250 1 2 2415 2435 3115 NO2I1_5VX1 $T=-242920 268800 1 0 $X=-243350 $Y=263680
X62251 1 2 2738 2435 9801 NO2I1_5VX1 $T=-242920 277760 1 0 $X=-243350 $Y=272640
X62252 1 2 3016 2499 3058 NO2I1_5VX1 $T=-239000 394240 0 180 $X=-243350 $Y=389120
X62253 1 2 2574 2435 8502 NO2I1_5VX1 $T=-242360 304640 0 0 $X=-242790 $Y=304000
X62254 1 2 3098 2499 8500 NO2I1_5VX1 $T=-242360 376320 1 0 $X=-242790 $Y=371200
X62255 1 2 3145 2499 3082 NO2I1_5VX1 $T=-237320 403200 0 180 $X=-241670 $Y=398080
X62256 1 2 3064 3042 8506 NO2I1_5VX1 $T=-240120 188160 0 0 $X=-240550 $Y=187520
X62257 1 2 3125 3042 3173 NO2I1_5VX1 $T=-237320 179200 0 0 $X=-237750 $Y=178560
X62258 1 2 2909 3042 3174 NO2I1_5VX1 $T=-237320 197120 0 0 $X=-237750 $Y=196480
X62259 1 2 3128 2435 8519 NO2I1_5VX1 $T=-237320 286720 0 0 $X=-237750 $Y=286080
X62260 1 2 3121 2499 8504 NO2I1_5VX1 $T=-232280 394240 0 180 $X=-236630 $Y=389120
X62261 1 2 8512 2435 3170 NO2I1_5VX1 $T=-235640 295680 1 0 $X=-236070 $Y=290560
X62262 1 2 8513 2435 2423 NO2I1_5VX1 $T=-235640 304640 0 0 $X=-236070 $Y=304000
X62263 1 2 3160 2499 8520 NO2I1_5VX1 $T=-235080 412160 1 0 $X=-235510 $Y=407040
X62264 1 2 2794 2435 8523 NO2I1_5VX1 $T=-234520 322560 1 0 $X=-234950 $Y=317440
X62265 1 2 170 2810 3183 NO2I1_5VX1 $T=-233960 26880 0 0 $X=-234390 $Y=26240
X62266 1 2 3150 2499 2555 NO2I1_5VX1 $T=-229480 376320 0 180 $X=-233830 $Y=371200
X62267 1 2 9970 3042 2396 NO2I1_5VX1 $T=-232280 206080 0 0 $X=-232710 $Y=205440
X62268 1 2 2665 3042 8514 NO2I1_5VX1 $T=-228360 215040 1 180 $X=-232710 $Y=214400
X62269 1 2 3194 3042 8530 NO2I1_5VX1 $T=-230600 152320 0 0 $X=-231030 $Y=151680
X62270 1 2 8483 2435 2892 NO2I1_5VX1 $T=-230600 313600 0 0 $X=-231030 $Y=312960
X62271 1 2 175 2810 3211 NO2I1_5VX1 $T=-230040 26880 0 0 $X=-230470 $Y=26240
X62272 1 2 176 2810 8528 NO2I1_5VX1 $T=-230040 116480 1 0 $X=-230470 $Y=111360
X62273 1 2 3106 2810 1960 NO2I1_5VX1 $T=-226120 125440 0 180 $X=-230470 $Y=120320
X62274 1 2 3086 2810 1946 NO2I1_5VX1 $T=-230040 143360 0 0 $X=-230470 $Y=142720
X62275 1 2 3195 3042 8532 NO2I1_5VX1 $T=-230040 179200 1 0 $X=-230470 $Y=174080
X62276 1 2 184 2810 8525 NO2I1_5VX1 $T=-225000 134400 0 180 $X=-229350 $Y=129280
X62277 1 2 3165 2499 8531 NO2I1_5VX1 $T=-228920 394240 1 0 $X=-229350 $Y=389120
X62278 1 2 3248 2435 2846 NO2I1_5VX1 $T=-227800 304640 0 0 $X=-228230 $Y=304000
X62279 1 2 8507 3042 2310 NO2I1_5VX1 $T=-227240 215040 0 0 $X=-227670 $Y=214400
X62280 1 2 3220 185 3238 NO2I1_5VX1 $T=-226120 143360 0 0 $X=-226550 $Y=142720
X62281 1 2 189 2810 3203 NO2I1_5VX1 $T=-221080 98560 1 180 $X=-225430 $Y=97920
X62282 1 2 8534 2810 188 NO2I1_5VX1 $T=-225000 134400 1 0 $X=-225430 $Y=129280
X62283 1 2 8529 3042 2003 NO2I1_5VX1 $T=-225000 179200 1 0 $X=-225430 $Y=174080
X62284 1 2 3201 2435 2527 NO2I1_5VX1 $T=-225000 313600 0 0 $X=-225430 $Y=312960
X62285 1 2 2785 2435 3252 NO2I1_5VX1 $T=-225000 340480 1 0 $X=-225430 $Y=335360
X62286 1 2 3230 2810 1987 NO2I1_5VX1 $T=-224440 125440 1 0 $X=-224870 $Y=120320
X62287 1 2 2474 3042 3251 NO2I1_5VX1 $T=-224440 215040 1 0 $X=-224870 $Y=209920
X62288 1 2 2936 2435 3249 NO2I1_5VX1 $T=-224440 331520 1 0 $X=-224870 $Y=326400
X62289 1 2 3207 2499 9836 NO2I1_5VX1 $T=-219400 394240 0 180 $X=-223750 $Y=389120
X62290 1 2 8540 2499 8545 NO2I1_5VX1 $T=-222760 412160 0 0 $X=-223190 $Y=411520
X62291 1 2 197 2810 8541 NO2I1_5VX1 $T=-218280 26880 0 180 $X=-222630 $Y=21760
X62292 1 2 9837 2810 195 NO2I1_5VX1 $T=-222200 143360 0 0 $X=-222630 $Y=142720
X62293 1 2 2902 3042 3284 NO2I1_5VX1 $T=-222200 152320 0 0 $X=-222630 $Y=151680
X62294 1 2 192 2810 9839 NO2I1_5VX1 $T=-221080 53760 0 0 $X=-221510 $Y=53120
X62295 1 2 198 2810 3192 NO2I1_5VX1 $T=-217160 80640 1 180 $X=-221510 $Y=80000
X62296 1 2 2442 3042 8552 NO2I1_5VX1 $T=-218280 188160 0 0 $X=-218710 $Y=187520
X62297 1 2 2628 2499 8547 NO2I1_5VX1 $T=-213800 394240 1 180 $X=-218150 $Y=393600
X62298 1 2 2428 3042 3317 NO2I1_5VX1 $T=-215480 197120 1 0 $X=-215910 $Y=192000
X62299 1 2 8548 3042 207 NO2I1_5VX1 $T=-211000 161280 0 180 $X=-215350 $Y=156160
X62300 1 2 9971 185 1799 NO2I1_5VX1 $T=-213240 152320 1 0 $X=-213670 $Y=147200
X62301 1 2 8556 185 1842 NO2I1_5VX1 $T=-209320 170240 1 180 $X=-213670 $Y=169600
X62302 1 2 8543 3042 2083 NO2I1_5VX1 $T=-213240 188160 1 0 $X=-213670 $Y=183040
X62303 1 2 3371 2499 8565 NO2I1_5VX1 $T=-208200 403200 1 180 $X=-212550 $Y=402560
X62304 1 2 8576 3042 2422 NO2I1_5VX1 $T=-206520 322560 1 180 $X=-210870 $Y=321920
X62305 1 2 2708 185 3362 NO2I1_5VX1 $T=-209880 98560 1 0 $X=-210310 $Y=93440
X62306 1 2 3324 2499 8566 NO2I1_5VX1 $T=-205400 367360 1 180 $X=-209750 $Y=366720
X62307 1 2 8559 3042 2134 NO2I1_5VX1 $T=-208760 179200 0 0 $X=-209190 $Y=178560
X62308 1 2 732 3042 3416 NO2I1_5VX1 $T=-207080 340480 0 0 $X=-207510 $Y=339840
X62309 1 2 3354 3042 3410 NO2I1_5VX1 $T=-205400 322560 0 0 $X=-205830 $Y=321920
X62310 1 2 3271 185 215 NO2I1_5VX1 $T=-203720 107520 0 0 $X=-204150 $Y=106880
X62311 1 2 3394 2499 3431 NO2I1_5VX1 $T=-202600 349440 1 0 $X=-203030 $Y=344320
X62312 1 2 3338 2499 3424 NO2I1_5VX1 $T=-202600 385280 1 0 $X=-203030 $Y=380160
X62313 1 2 3399 2499 8597 NO2I1_5VX1 $T=-202600 394240 1 0 $X=-203030 $Y=389120
X62314 1 2 2984 3042 3440 NO2I1_5VX1 $T=-202040 340480 0 0 $X=-202470 $Y=339840
X62315 1 2 3451 2499 3291 NO2I1_5VX1 $T=-198120 412160 0 180 $X=-202470 $Y=407040
X62316 1 2 3339 2499 3372 NO2I1_5VX1 $T=-197560 421120 0 180 $X=-201910 $Y=416000
X62317 1 2 3411 3042 3430 NO2I1_5VX1 $T=-200360 331520 1 0 $X=-200790 $Y=326400
X62318 1 2 3212 217 8598 NO2I1_5VX1 $T=-199800 241920 0 0 $X=-200230 $Y=241280
X62319 1 2 41 3375 218 NO2I1_5VX1 $T=-193640 71680 0 180 $X=-197990 $Y=66560
X62320 1 2 3255 217 3549 NO2I1_5VX1 $T=-194200 241920 0 0 $X=-194630 $Y=241280
X62321 1 2 17 3489 3463 NO2I1_5VX1 $T=-193640 71680 1 0 $X=-194070 $Y=66560
X62322 1 2 8491 217 3486 NO2I1_5VX1 $T=-188600 268800 0 180 $X=-192950 $Y=263680
X62323 1 2 3505 217 3516 NO2I1_5VX1 $T=-190840 250880 0 0 $X=-191270 $Y=250240
X62324 1 2 3261 217 3577 NO2I1_5VX1 $T=-187480 268800 1 0 $X=-187910 $Y=263680
X62325 1 2 3523 2499 8623 NO2I1_5VX1 $T=-181880 412160 0 180 $X=-186230 $Y=407040
X62326 1 2 3275 217 3618 NO2I1_5VX1 $T=-181880 268800 1 0 $X=-182310 $Y=263680
X62327 1 2 3015 217 3526 NO2I1_5VX1 $T=-176280 277760 0 180 $X=-180630 $Y=272640
X62328 1 2 3315 185 228 NO2I1_5VX1 $T=-179640 26880 0 0 $X=-180070 $Y=26240
X62329 1 2 132 185 3878 NO2I1_5VX1 $T=-179640 80640 1 0 $X=-180070 $Y=75520
X62330 1 2 8638 217 3641 NO2I1_5VX1 $T=-179640 232960 0 0 $X=-180070 $Y=232320
X62331 1 2 3038 3042 3648 NO2I1_5VX1 $T=-179640 313600 1 0 $X=-180070 $Y=308480
X62332 1 2 3228 3042 4273 NO2I1_5VX1 $T=-175720 331520 0 180 $X=-180070 $Y=326400
X62333 1 2 47 185 3644 NO2I1_5VX1 $T=-179080 125440 0 0 $X=-179510 $Y=124800
X62334 1 2 3657 2499 3652 NO2I1_5VX1 $T=-179080 412160 0 0 $X=-179510 $Y=411520
X62335 1 2 206 185 230 NO2I1_5VX1 $T=-177960 44800 1 0 $X=-178390 $Y=39680
X62336 1 2 74 185 3623 NO2I1_5VX1 $T=-177400 116480 1 0 $X=-177830 $Y=111360
X62337 1 2 3494 2499 9844 NO2I1_5VX1 $T=-176280 412160 1 0 $X=-176710 $Y=407040
X62338 1 2 3096 185 236 NO2I1_5VX1 $T=-175720 80640 1 0 $X=-176150 $Y=75520
X62339 1 2 3664 185 234 NO2I1_5VX1 $T=-174040 44800 1 0 $X=-174470 $Y=39680
X62340 1 2 3654 217 3693 NO2I1_5VX1 $T=-169000 277760 0 180 $X=-173350 $Y=272640
X62341 1 2 3039 3042 3715 NO2I1_5VX1 $T=-172920 331520 1 0 $X=-173350 $Y=326400
X62342 1 2 8665 2499 3688 NO2I1_5VX1 $T=-169000 394240 1 180 $X=-173350 $Y=393600
X62343 1 2 3351 185 239 NO2I1_5VX1 $T=-170680 62720 0 0 $X=-171110 $Y=62080
X62344 1 2 3728 217 3745 NO2I1_5VX1 $T=-163400 241920 0 180 $X=-167750 $Y=236800
X62345 1 2 3656 2499 4018 NO2I1_5VX1 $T=-167320 394240 0 0 $X=-167750 $Y=393600
X62346 1 2 3741 2499 3772 NO2I1_5VX1 $T=-166760 412160 1 0 $X=-167190 $Y=407040
X62347 1 2 3668 8680 3509 NO2I1_5VX1 $T=-161720 376320 1 180 $X=-166070 $Y=375680
X62348 1 2 3656 3389 8680 NO2I1_5VX1 $T=-165640 385280 0 0 $X=-166070 $Y=384640
X62349 1 2 3386 3042 3661 NO2I1_5VX1 $T=-160040 286720 0 180 $X=-164390 $Y=281600
X62350 1 2 3247 185 245 NO2I1_5VX1 $T=-162840 80640 1 0 $X=-163270 $Y=75520
X62351 1 2 3685 3206 3824 NO2I1_5VX1 $T=-162280 367360 1 0 $X=-162710 $Y=362240
X62352 1 2 3389 2499 8693 NO2I1_5VX1 $T=-162280 394240 1 0 $X=-162710 $Y=389120
X62353 1 2 737 3752 8695 NO2I1_5VX1 $T=-161720 197120 0 0 $X=-162150 $Y=196480
X62354 1 2 77 185 250 NO2I1_5VX1 $T=-161160 107520 0 0 $X=-161590 $Y=106880
X62355 1 2 3206 3042 3817 NO2I1_5VX1 $T=-161160 340480 0 0 $X=-161590 $Y=339840
X62356 1 2 8685 185 251 NO2I1_5VX1 $T=-160600 35840 0 0 $X=-161030 $Y=35200
X62357 1 2 8690 3811 8707 NO2I1_5VX1 $T=-160600 206080 1 0 $X=-161030 $Y=200960
X62358 1 2 3610 2499 9898 NO2I1_5VX1 $T=-160600 385280 1 0 $X=-161030 $Y=380160
X62359 1 2 4229 217 3860 NO2I1_5VX1 $T=-158360 232960 0 0 $X=-158790 $Y=232320
X62360 1 2 3855 3042 3814 NO2I1_5VX1 $T=-154440 286720 0 180 $X=-158790 $Y=281600
X62361 1 2 3272 185 3049 NO2I1_5VX1 $T=-156680 125440 1 0 $X=-157110 $Y=120320
X62362 1 2 3842 217 3873 NO2I1_5VX1 $T=-156120 241920 0 0 $X=-156550 $Y=241280
X62363 1 2 3269 185 256 NO2I1_5VX1 $T=-155000 53760 1 0 $X=-155430 $Y=48640
X62364 1 2 3850 2499 4301 NO2I1_5VX1 $T=-155000 394240 0 0 $X=-155430 $Y=393600
X62365 1 2 1986 185 3893 NO2I1_5VX1 $T=-153320 161280 0 0 $X=-153750 $Y=160640
X62366 1 2 2839 3042 3895 NO2I1_5VX1 $T=-152760 179200 0 0 $X=-153190 $Y=178560
X62367 1 2 3584 3042 8706 NO2I1_5VX1 $T=-152200 286720 0 0 $X=-152630 $Y=286080
X62368 1 2 3766 3746 3925 NO2I1_5VX1 $T=-152200 313600 1 0 $X=-152630 $Y=308480
X62369 1 2 3685 2499 3936 NO2I1_5VX1 $T=-151080 367360 1 0 $X=-151510 $Y=362240
X62370 1 2 40 185 3923 NO2I1_5VX1 $T=-149960 152320 1 0 $X=-150390 $Y=147200
X62371 1 2 3952 2499 3867 NO2I1_5VX1 $T=-146040 376320 1 180 $X=-150390 $Y=375680
X62372 1 2 3913 217 3955 NO2I1_5VX1 $T=-149400 241920 0 0 $X=-149830 $Y=241280
X62373 1 2 262 2810 3938 NO2I1_5VX1 $T=-148840 89600 0 0 $X=-149270 $Y=88960
X62374 1 2 267 2810 3937 NO2I1_5VX1 $T=-148280 71680 0 0 $X=-148710 $Y=71040
X62375 1 2 1679 185 3972 NO2I1_5VX1 $T=-146040 170240 1 0 $X=-146470 $Y=165120
X62376 1 2 3948 3042 3409 NO2I1_5VX1 $T=-146040 179200 0 0 $X=-146470 $Y=178560
X62377 1 2 3949 3042 3986 NO2I1_5VX1 $T=-144920 188160 0 0 $X=-145350 $Y=187520
X62378 1 2 3522 3042 3970 NO2I1_5VX1 $T=-139880 295680 0 180 $X=-144230 $Y=290560
X62379 1 2 3974 2499 3988 NO2I1_5VX1 $T=-143240 394240 1 0 $X=-143670 $Y=389120
X62380 1 2 3975 185 4718 NO2I1_5VX1 $T=-142120 170240 1 0 $X=-142550 $Y=165120
X62381 1 2 2091 3042 5926 NO2I1_5VX1 $T=-139880 188160 0 0 $X=-140310 $Y=187520
X62382 1 2 1884 185 4421 NO2I1_5VX1 $T=-137640 170240 1 0 $X=-138070 $Y=165120
X62383 1 2 4013 185 5034 NO2I1_5VX1 $T=-137640 170240 0 0 $X=-138070 $Y=169600
X62384 1 2 3141 2810 4053 NO2I1_5VX1 $T=-137080 71680 1 0 $X=-137510 $Y=66560
X62385 1 2 2883 2810 4037 NO2I1_5VX1 $T=-137080 107520 0 0 $X=-137510 $Y=106880
X62386 1 2 3689 3042 740 NO2I1_5VX1 $T=-133160 188160 0 180 $X=-137510 $Y=183040
X62387 1 2 4268 217 4034 NO2I1_5VX1 $T=-137080 250880 1 0 $X=-137510 $Y=245760
X62388 1 2 3253 2499 4060 NO2I1_5VX1 $T=-137080 385280 1 0 $X=-137510 $Y=380160
X62389 1 2 3550 185 4054 NO2I1_5VX1 $T=-136520 125440 1 0 $X=-136950 $Y=120320
X62390 1 2 4064 2499 4031 NO2I1_5VX1 $T=-132040 358400 1 180 $X=-136390 $Y=357760
X62391 1 2 3782 3042 3847 NO2I1_5VX1 $T=-134840 197120 1 0 $X=-135270 $Y=192000
X62392 1 2 3769 185 4094 NO2I1_5VX1 $T=-133720 170240 1 0 $X=-134150 $Y=165120
X62393 1 2 4055 3042 4078 NO2I1_5VX1 $T=-133160 170240 0 0 $X=-133590 $Y=169600
X62394 1 2 8739 3042 4073 NO2I1_5VX1 $T=-133160 313600 0 0 $X=-133590 $Y=312960
X62395 1 2 4062 3042 4100 NO2I1_5VX1 $T=-131480 188160 1 0 $X=-131910 $Y=183040
X62396 1 2 41 185 4099 NO2I1_5VX1 $T=-130920 125440 0 0 $X=-131350 $Y=124800
X62397 1 2 2799 3042 4245 NO2I1_5VX1 $T=-130360 197120 0 0 $X=-130790 $Y=196480
X62398 1 2 4084 3042 4108 NO2I1_5VX1 $T=-129240 197120 1 0 $X=-129670 $Y=192000
X62399 1 2 4089 2499 8770 NO2I1_5VX1 $T=-129240 367360 1 0 $X=-129670 $Y=362240
X62400 1 2 3716 2499 4110 NO2I1_5VX1 $T=-129240 376320 1 0 $X=-129670 $Y=371200
X62401 1 2 8761 2499 8768 NO2I1_5VX1 $T=-128680 385280 1 0 $X=-129110 $Y=380160
X62402 1 2 4109 3898 4153 NO2I1_5VX1 $T=-128120 331520 0 0 $X=-128550 $Y=330880
X62403 1 2 3985 2810 3464 NO2I1_5VX1 $T=-127560 116480 1 0 $X=-127990 $Y=111360
X62404 1 2 4398 3042 8774 NO2I1_5VX1 $T=-120840 197120 0 180 $X=-125190 $Y=192000
X62405 1 2 4125 3042 4144 NO2I1_5VX1 $T=-124200 313600 0 0 $X=-124630 $Y=312960
X62406 1 2 4106 4153 4017 NO2I1_5VX1 $T=-122520 331520 0 0 $X=-122950 $Y=330880
X62407 1 2 4124 2810 283 NO2I1_5VX1 $T=-118040 35840 1 180 $X=-122390 $Y=35200
X62408 1 2 156 3042 4182 NO2I1_5VX1 $T=-121960 179200 0 0 $X=-122390 $Y=178560
X62409 1 2 3898 3042 4189 NO2I1_5VX1 $T=-121960 322560 0 0 $X=-122390 $Y=321920
X62410 1 2 4162 3042 4186 NO2I1_5VX1 $T=-120840 197120 1 0 $X=-121270 $Y=192000
X62411 1 2 9851 3042 4157 NO2I1_5VX1 $T=-116920 206080 0 180 $X=-121270 $Y=200960
X62412 1 2 4190 2810 4020 NO2I1_5VX1 $T=-115800 62720 0 180 $X=-120150 $Y=57600
X62413 1 2 4206 2810 290 NO2I1_5VX1 $T=-114120 53760 1 180 $X=-118470 $Y=53120
X62414 1 2 4265 2810 287 NO2I1_5VX1 $T=-113000 35840 1 180 $X=-117350 $Y=35200
X62415 1 2 9899 3042 4225 NO2I1_5VX1 $T=-116360 179200 1 0 $X=-116790 $Y=174080
X62416 1 2 4191 3042 4227 NO2I1_5VX1 $T=-116360 197120 1 0 $X=-116790 $Y=192000
X62417 1 2 2053 3042 8800 NO2I1_5VX1 $T=-116360 206080 0 0 $X=-116790 $Y=205440
X62418 1 2 4109 3042 4231 NO2I1_5VX1 $T=-116360 322560 0 0 $X=-116790 $Y=321920
X62419 1 2 8789 2810 289 NO2I1_5VX1 $T=-111880 62720 0 180 $X=-116230 $Y=57600
X62420 1 2 3225 3042 4218 NO2I1_5VX1 $T=-115800 206080 1 0 $X=-116230 $Y=200960
X62421 1 2 5458 217 4233 NO2I1_5VX1 $T=-115800 241920 1 0 $X=-116230 $Y=236800
X62422 1 2 307 2810 5100 NO2I1_5VX1 $T=-97880 98560 0 0 $X=-98310 $Y=97920
X62423 1 2 4330 2810 4131 NO2I1_5VX1 $T=-93400 62720 1 180 $X=-97750 $Y=62080
X62424 1 2 4298 217 4336 NO2I1_5VX1 $T=-97320 224000 1 0 $X=-97750 $Y=218880
X62425 1 2 4290 2810 4139 NO2I1_5VX1 $T=-96760 80640 1 0 $X=-97190 $Y=75520
X62426 1 2 8810 217 4344 NO2I1_5VX1 $T=-95640 250880 1 0 $X=-96070 $Y=245760
X62427 1 2 4282 3042 4188 NO2I1_5VX1 $T=-95640 322560 1 0 $X=-96070 $Y=317440
X62428 1 2 4325 4343 4337 NO2I1_5VX1 $T=-95080 241920 0 0 $X=-95510 $Y=241280
X62429 1 2 4342 217 4299 NO2I1_5VX1 $T=-92840 224000 1 0 $X=-93270 $Y=218880
X62430 1 2 4354 4343 4379 NO2I1_5VX1 $T=-91160 241920 0 0 $X=-91590 $Y=241280
X62431 1 2 4385 2810 4407 NO2I1_5VX1 $T=-85000 116480 0 180 $X=-89350 $Y=111360
X62432 1 2 314 2810 8821 NO2I1_5VX1 $T=-83880 80640 1 180 $X=-88230 $Y=80000
X62433 1 2 3776 3042 4395 NO2I1_5VX1 $T=-87240 188160 1 0 $X=-87670 $Y=183040
X62434 1 2 3009 3042 4417 NO2I1_5VX1 $T=-86680 197120 0 0 $X=-87110 $Y=196480
X62435 1 2 4427 2810 4475 NO2I1_5VX1 $T=-79400 107520 0 180 $X=-83750 $Y=102400
X62436 1 2 4454 4343 4464 NO2I1_5VX1 $T=-79400 268800 0 0 $X=-79830 $Y=268160
X62437 1 2 4450 4343 4466 NO2I1_5VX1 $T=-78280 250880 0 0 $X=-78710 $Y=250240
X62438 1 2 4461 4343 8850 NO2I1_5VX1 $T=-76040 232960 0 0 $X=-76470 $Y=232320
X62439 1 2 4486 4343 4497 NO2I1_5VX1 $T=-74360 250880 1 0 $X=-74790 $Y=245760
X62440 1 2 2449 4343 4522 NO2I1_5VX1 $T=-72680 286720 1 0 $X=-73110 $Y=281600
X62441 1 2 4492 2810 4524 NO2I1_5VX1 $T=-72120 125440 0 0 $X=-72550 $Y=124800
X62442 1 2 2501 4343 4603 NO2I1_5VX1 $T=-72120 331520 1 0 $X=-72550 $Y=326400
X62443 1 2 4309 4343 4500 NO2I1_5VX1 $T=-65960 331520 1 180 $X=-70310 $Y=330880
X62444 1 2 2434 4343 4553 NO2I1_5VX1 $T=-68200 259840 1 0 $X=-68630 $Y=254720
X62445 1 2 2358 4343 4565 NO2I1_5VX1 $T=-67640 304640 0 0 $X=-68070 $Y=304000
X62446 1 2 4431 4343 8861 NO2I1_5VX1 $T=-62040 367360 1 180 $X=-66390 $Y=366720
X62447 1 2 8863 4343 4420 NO2I1_5VX1 $T=-64840 241920 1 0 $X=-65270 $Y=236800
X62448 1 2 4397 4343 4601 NO2I1_5VX1 $T=-64840 259840 0 0 $X=-65270 $Y=259200
X62449 1 2 4617 2810 4582 NO2I1_5VX1 $T=-58680 143360 0 180 $X=-63030 $Y=138240
X62450 1 2 4173 4343 4628 NO2I1_5VX1 $T=-60920 241920 1 0 $X=-61350 $Y=236800
X62451 1 2 4649 2810 4626 NO2I1_5VX1 $T=-53640 152320 1 180 $X=-57990 $Y=151680
X62452 1 2 4609 2810 4657 NO2I1_5VX1 $T=-49720 125440 1 180 $X=-54070 $Y=124800
X62453 1 2 4515 4343 8868 NO2I1_5VX1 $T=-49720 322560 1 180 $X=-54070 $Y=321920
X62454 1 2 4448 4343 8876 NO2I1_5VX1 $T=-52520 295680 1 0 $X=-52950 $Y=290560
X62455 1 2 4392 4343 8873 NO2I1_5VX1 $T=-48600 313600 0 180 $X=-52950 $Y=308480
X62456 1 2 3098 4716 4625 NO2I1_5VX1 $T=-48040 376320 0 180 $X=-52390 $Y=371200
X62457 1 2 4529 4343 4704 NO2I1_5VX1 $T=-50840 349440 1 0 $X=-51270 $Y=344320
X62458 1 2 2633 4716 8887 NO2I1_5VX1 $T=-49720 412160 1 0 $X=-50150 $Y=407040
X62459 1 2 4708 2810 5644 NO2I1_5VX1 $T=-45240 125440 1 180 $X=-49590 $Y=124800
X62460 1 2 2400 4343 8885 NO2I1_5VX1 $T=-49160 241920 0 0 $X=-49590 $Y=241280
X62461 1 2 4570 2810 4665 NO2I1_5VX1 $T=-44680 134400 1 180 $X=-49030 $Y=133760
X62462 1 2 3838 2810 4713 NO2I1_5VX1 $T=-48040 143360 0 0 $X=-48470 $Y=142720
X62463 1 2 3940 2810 4733 NO2I1_5VX1 $T=-46920 161280 0 0 $X=-47350 $Y=160640
X62464 1 2 5213 2810 4729 NO2I1_5VX1 $T=-46360 188160 1 0 $X=-46790 $Y=183040
X62465 1 2 4029 2810 4750 NO2I1_5VX1 $T=-45800 179200 1 0 $X=-46230 $Y=174080
X62466 1 2 4705 4716 4756 NO2I1_5VX1 $T=-45800 376320 0 0 $X=-46230 $Y=375680
X62467 1 2 4732 2810 4720 NO2I1_5VX1 $T=-41320 152320 1 180 $X=-45670 $Y=151680
X62468 1 2 3903 2810 4747 NO2I1_5VX1 $T=-44120 143360 0 0 $X=-44550 $Y=142720
X62469 1 2 4749 2810 4727 NO2I1_5VX1 $T=-40200 161280 0 180 $X=-44550 $Y=156160
X62470 1 2 367 2810 4656 NO2I1_5VX1 $T=-39640 107520 1 180 $X=-43990 $Y=106880
X62471 1 2 2628 4716 8890 NO2I1_5VX1 $T=-39080 403200 0 180 $X=-43430 $Y=398080
X62472 1 2 368 2810 6944 NO2I1_5VX1 $T=-42440 170240 0 0 $X=-42870 $Y=169600
X62473 1 2 4676 4343 4766 NO2I1_5VX1 $T=-41880 286720 1 0 $X=-42310 $Y=281600
X62474 1 2 4745 2810 4782 NO2I1_5VX1 $T=-40760 116480 1 0 $X=-41190 $Y=111360
X62475 1 2 4753 4716 4786 NO2I1_5VX1 $T=-40760 286720 0 0 $X=-41190 $Y=286080
X62476 1 2 4755 2810 4791 NO2I1_5VX1 $T=-40200 179200 1 0 $X=-40630 $Y=174080
X62477 1 2 2773 4343 4765 NO2I1_5VX1 $T=-35160 224000 0 180 $X=-39510 $Y=218880
X62478 1 2 8907 4716 8902 NO2I1_5VX1 $T=-34040 385280 1 180 $X=-38390 $Y=384640
X62479 1 2 9791 2810 6625 NO2I1_5VX1 $T=-37400 125440 0 0 $X=-37830 $Y=124800
X62480 1 2 4619 4716 4804 NO2I1_5VX1 $T=-37400 295680 0 0 $X=-37830 $Y=295040
X62481 1 2 4773 2810 4787 NO2I1_5VX1 $T=-32920 143360 0 180 $X=-37270 $Y=138240
X62482 1 2 4793 4343 4850 NO2I1_5VX1 $T=-36840 286720 0 0 $X=-37270 $Y=286080
X62483 1 2 4602 4716 4810 NO2I1_5VX1 $T=-36840 313600 1 0 $X=-37270 $Y=308480
X62484 1 2 4777 4716 4833 NO2I1_5VX1 $T=-36280 304640 1 0 $X=-36710 $Y=299520
X62485 1 2 3825 2810 4841 NO2I1_5VX1 $T=-34040 134400 0 0 $X=-34470 $Y=133760
X62486 1 2 4736 4716 4846 NO2I1_5VX1 $T=-32920 313600 0 0 $X=-33350 $Y=312960
X62487 1 2 4933 4716 8917 NO2I1_5VX1 $T=-32920 412160 1 0 $X=-33350 $Y=407040
X62488 1 2 4812 4716 4858 NO2I1_5VX1 $T=-31800 376320 0 0 $X=-32230 $Y=375680
X62489 1 2 4735 4343 4832 NO2I1_5VX1 $T=-26760 224000 1 180 $X=-31110 $Y=223360
X62490 1 2 4835 4343 4868 NO2I1_5VX1 $T=-30680 358400 0 0 $X=-31110 $Y=357760
X62491 1 2 4794 4716 4877 NO2I1_5VX1 $T=-30120 331520 1 0 $X=-30550 $Y=326400
X62492 1 2 4816 4343 8923 NO2I1_5VX1 $T=-30120 349440 0 0 $X=-30550 $Y=348800
X62493 1 2 4723 4716 4878 NO2I1_5VX1 $T=-29560 331520 0 0 $X=-29990 $Y=330880
X62494 1 2 8869 4343 8935 NO2I1_5VX1 $T=-29560 349440 1 0 $X=-29990 $Y=344320
X62495 1 2 4608 4716 8921 NO2I1_5VX1 $T=-29000 313600 0 0 $X=-29430 $Y=312960
X62496 1 2 4874 2810 4888 NO2I1_5VX1 $T=-27880 161280 1 0 $X=-28310 $Y=156160
X62497 1 2 4737 4716 4902 NO2I1_5VX1 $T=-27320 367360 1 0 $X=-27750 $Y=362240
X62498 1 2 4785 4343 4907 NO2I1_5VX1 $T=-26760 232960 1 0 $X=-27190 $Y=227840
X62499 1 2 4848 4716 4950 NO2I1_5VX1 $T=-25640 331520 0 0 $X=-26070 $Y=330880
X62500 1 2 4618 4343 4881 NO2I1_5VX1 $T=-20040 250880 1 180 $X=-24390 $Y=250240
X62501 1 2 4710 4716 4980 NO2I1_5VX1 $T=-23960 358400 0 0 $X=-24390 $Y=357760
X62502 1 2 4659 4343 4932 NO2I1_5VX1 $T=-22840 232960 1 0 $X=-23270 $Y=227840
X62503 1 2 339 4943 4942 NO2I1_5VX1 $T=-21720 107520 1 0 $X=-22150 $Y=102400
X62504 1 2 4668 4343 4960 NO2I1_5VX1 $T=-18920 232960 1 0 $X=-19350 $Y=227840
X62505 1 2 4761 4343 8945 NO2I1_5VX1 $T=-18360 224000 0 0 $X=-18790 $Y=223360
X62506 1 2 8929 4716 4972 NO2I1_5VX1 $T=-17240 394240 1 0 $X=-17670 $Y=389120
X62507 1 2 4536 4343 5040 NO2I1_5VX1 $T=-16120 206080 0 0 $X=-16550 $Y=205440
X62508 1 2 4866 4716 4827 NO2I1_5VX1 $T=-16120 295680 0 0 $X=-16550 $Y=295040
X62509 1 2 4455 4343 9803 NO2I1_5VX1 $T=-15000 206080 1 0 $X=-15430 $Y=200960
X62510 1 2 4969 4716 5002 NO2I1_5VX1 $T=-15000 367360 0 0 $X=-15430 $Y=366720
X62511 1 2 4975 4343 6597 NO2I1_5VX1 $T=-14440 224000 0 0 $X=-14870 $Y=223360
X62512 1 2 4920 4716 4995 NO2I1_5VX1 $T=-13880 394240 0 0 $X=-14310 $Y=393600
X62513 1 2 4971 4716 5560 NO2I1_5VX1 $T=-13320 358400 1 0 $X=-13750 $Y=353280
X62514 1 2 4993 4343 4408 NO2I1_5VX1 $T=-12200 215040 1 0 $X=-12630 $Y=209920
X62515 1 2 8954 4716 4596 NO2I1_5VX1 $T=-11640 385280 1 0 $X=-12070 $Y=380160
X62516 1 2 4691 4716 5015 NO2I1_5VX1 $T=-11640 394240 1 0 $X=-12070 $Y=389120
X62517 1 2 326 4943 8959 NO2I1_5VX1 $T=-7160 98560 1 180 $X=-11510 $Y=97920
X62518 1 2 5001 4343 4989 NO2I1_5VX1 $T=-11080 206080 1 0 $X=-11510 $Y=200960
X62519 1 2 5009 4343 5120 NO2I1_5VX1 $T=-9960 224000 1 0 $X=-10390 $Y=218880
X62520 1 2 5006 4716 5031 NO2I1_5VX1 $T=-9960 367360 0 0 $X=-10390 $Y=366720
X62521 1 2 4896 4343 5037 NO2I1_5VX1 $T=-8840 232960 1 0 $X=-9270 $Y=227840
X62522 1 2 4961 4716 4255 NO2I1_5VX1 $T=-8280 313600 0 0 $X=-8710 $Y=312960
X62523 1 2 4661 4716 5049 NO2I1_5VX1 $T=-7160 349440 1 0 $X=-7590 $Y=344320
X62524 1 2 4684 4716 5070 NO2I1_5VX1 $T=-7160 394240 0 0 $X=-7590 $Y=393600
X62525 1 2 5017 5047 8956 NO2I1_5VX1 $T=-2680 71680 1 180 $X=-7030 $Y=71040
X62526 1 2 5069 4716 5060 NO2I1_5VX1 $T=-6040 367360 1 0 $X=-6470 $Y=362240
X62527 1 2 8968 4343 4706 NO2I1_5VX1 $T=-5480 250880 0 0 $X=-5910 $Y=250240
X62528 1 2 4994 4343 5066 NO2I1_5VX1 $T=-4920 232960 1 0 $X=-5350 $Y=227840
X62529 1 2 5044 4716 5126 NO2I1_5VX1 $T=-4920 412160 1 0 $X=-5350 $Y=407040
X62530 1 2 758 5062 8981 NO2I1_5VX1 $T=-4360 44800 0 0 $X=-4790 $Y=44160
X62531 1 2 5087 4343 5074 NO2I1_5VX1 $T=1800 241920 0 180 $X=-2550 $Y=236800
X62532 1 2 4834 4343 5097 NO2I1_5VX1 $T=-2120 286720 1 0 $X=-2550 $Y=281600
X62533 1 2 757 4716 5098 NO2I1_5VX1 $T=-1560 313600 0 0 $X=-1990 $Y=312960
X62534 1 2 4897 4716 5099 NO2I1_5VX1 $T=-1560 394240 0 0 $X=-1990 $Y=393600
X62535 1 2 3749 2810 5104 NO2I1_5VX1 $T=-1000 98560 1 0 $X=-1430 $Y=93440
X62536 1 2 4903 4716 8994 NO2I1_5VX1 $T=680 412160 0 0 $X=250 $Y=411520
X62537 1 2 394 2810 5116 NO2I1_5VX1 $T=1240 62720 1 0 $X=810 $Y=57600
X62538 1 2 4815 4343 8990 NO2I1_5VX1 $T=5720 241920 0 180 $X=1370 $Y=236800
X62539 1 2 5109 4343 5121 NO2I1_5VX1 $T=2360 250880 0 0 $X=1930 $Y=250240
X62540 1 2 4945 4716 5129 NO2I1_5VX1 $T=2360 313600 1 0 $X=1930 $Y=308480
X62541 1 2 5000 4716 5160 NO2I1_5VX1 $T=5160 421120 1 0 $X=4730 $Y=416000
X62542 1 2 362 5091 5153 NO2I1_5VX1 $T=6280 116480 0 0 $X=5850 $Y=115840
X62543 1 2 4771 4343 5169 NO2I1_5VX1 $T=6280 206080 0 0 $X=5850 $Y=205440
X62544 1 2 9009 5234 8999 NO2I1_5VX1 $T=10760 295680 1 180 $X=6410 $Y=295040
X62545 1 2 5174 4343 4409 NO2I1_5VX1 $T=13560 224000 0 180 $X=9210 $Y=218880
X62546 1 2 9012 4343 5187 NO2I1_5VX1 $T=11320 206080 0 0 $X=10890 $Y=205440
X62547 1 2 5134 4343 5474 NO2I1_5VX1 $T=13000 250880 1 0 $X=12570 $Y=245760
X62548 1 2 5146 4343 5215 NO2I1_5VX1 $T=13560 224000 1 0 $X=13130 $Y=218880
X62549 1 2 765 4343 5233 NO2I1_5VX1 $T=16920 250880 1 0 $X=16490 $Y=245760
X62550 1 2 5026 4716 6256 NO2I1_5VX1 $T=17480 331520 0 0 $X=17050 $Y=330880
X62551 1 2 4557 4343 5241 NO2I1_5VX1 $T=18040 259840 0 0 $X=17610 $Y=259200
X62552 1 2 5150 4716 5274 NO2I1_5VX1 $T=20840 322560 1 0 $X=20410 $Y=317440
X62553 1 2 5191 5228 9048 NO2I1_5VX1 $T=23080 98560 1 0 $X=22650 $Y=93440
X62554 1 2 5059 4343 5293 NO2I1_5VX1 $T=23080 232960 0 0 $X=22650 $Y=232320
X62555 1 2 4779 4716 9046 NO2I1_5VX1 $T=23080 295680 0 0 $X=22650 $Y=295040
X62556 1 2 4946 4716 9045 NO2I1_5VX1 $T=23080 313600 1 0 $X=22650 $Y=308480
X62557 1 2 4857 4716 5296 NO2I1_5VX1 $T=23080 331520 0 0 $X=22650 $Y=330880
X62558 1 2 5278 4716 5307 NO2I1_5VX1 $T=24200 403200 1 0 $X=23770 $Y=398080
X62559 1 2 5182 4716 9042 NO2I1_5VX1 $T=25320 340480 0 0 $X=24890 $Y=339840
X62560 1 2 5132 5312 5317 NO2I1_5VX1 $T=26440 197120 1 0 $X=26010 $Y=192000
X62561 1 2 9049 4343 5335 NO2I1_5VX1 $T=27000 232960 0 0 $X=26570 $Y=232320
X62562 1 2 5188 5141 5331 NO2I1_5VX1 $T=27000 295680 0 0 $X=26570 $Y=295040
X62563 1 2 4987 4716 5336 NO2I1_5VX1 $T=27000 349440 0 0 $X=26570 $Y=348800
X62564 1 2 4910 4716 9105 NO2I1_5VX1 $T=32040 277760 1 180 $X=27690 $Y=277120
X62565 1 2 5328 4716 5355 NO2I1_5VX1 $T=29800 403200 0 0 $X=29370 $Y=402560
X62566 1 2 4951 4716 5284 NO2I1_5VX1 $T=30920 349440 0 0 $X=30490 $Y=348800
X62567 1 2 8964 5312 5360 NO2I1_5VX1 $T=31480 188160 0 0 $X=31050 $Y=187520
X62568 1 2 5372 2810 4632 NO2I1_5VX1 $T=35960 116480 0 180 $X=31610 $Y=111360
X62569 1 2 5361 4716 5400 NO2I1_5VX1 $T=34840 322560 0 0 $X=34410 $Y=321920
X62570 1 2 5383 5312 5395 NO2I1_5VX1 $T=35960 179200 1 0 $X=35530 $Y=174080
X62571 1 2 5379 4716 5402 NO2I1_5VX1 $T=35960 412160 1 0 $X=35530 $Y=407040
X62572 1 2 9068 4343 5409 NO2I1_5VX1 $T=37080 232960 1 0 $X=36650 $Y=227840
X62573 1 2 9066 4343 5426 NO2I1_5VX1 $T=38760 224000 0 0 $X=38330 $Y=223360
X62574 1 2 5422 4716 5438 NO2I1_5VX1 $T=39880 331520 1 0 $X=39450 $Y=326400
X62575 1 2 5413 4343 5443 NO2I1_5VX1 $T=41000 232960 1 0 $X=40570 $Y=227840
X62576 1 2 5266 5172 5440 NO2I1_5VX1 $T=41000 403200 0 0 $X=40570 $Y=402560
X62577 1 2 770 5312 5441 NO2I1_5VX1 $T=41560 89600 0 0 $X=41130 $Y=88960
X62578 1 2 5425 5312 5449 NO2I1_5VX1 $T=41560 179200 0 0 $X=41130 $Y=178560
X62579 1 2 4679 4343 9086 NO2I1_5VX1 $T=43240 224000 1 0 $X=42810 $Y=218880
X62580 1 2 5445 4716 5470 NO2I1_5VX1 $T=43800 331520 0 0 $X=43370 $Y=330880
X62581 1 2 5442 5312 9091 NO2I1_5VX1 $T=44360 134400 1 0 $X=43930 $Y=129280
X62582 1 2 5459 4716 5512 NO2I1_5VX1 $T=44920 340480 0 0 $X=44490 $Y=339840
X62583 1 2 5362 5440 5246 NO2I1_5VX1 $T=44920 403200 1 0 $X=44490 $Y=398080
X62584 1 2 5172 4716 5477 NO2I1_5VX1 $T=46040 403200 0 0 $X=45610 $Y=402560
X62585 1 2 5462 2810 5495 NO2I1_5VX1 $T=46600 80640 1 0 $X=46170 $Y=75520
X62586 1 2 5516 5312 5464 NO2I1_5VX1 $T=50520 152320 1 180 $X=46170 $Y=151680
X62587 1 2 9087 5504 5511 NO2I1_5VX1 $T=48280 304640 1 0 $X=47850 $Y=299520
X62588 1 2 5491 5312 5525 NO2I1_5VX1 $T=49400 116480 1 0 $X=48970 $Y=111360
X62589 1 2 5376 5504 9106 NO2I1_5VX1 $T=49960 250880 0 0 $X=49530 $Y=250240
X62590 1 2 5532 2810 6492 NO2I1_5VX1 $T=55560 62720 1 180 $X=51210 $Y=62080
X62591 1 2 5542 2810 416 NO2I1_5VX1 $T=56120 35840 0 180 $X=51770 $Y=30720
X62592 1 2 5538 2810 4032 NO2I1_5VX1 $T=56120 53760 0 180 $X=51770 $Y=48640
X62593 1 2 9117 5312 5090 NO2I1_5VX1 $T=56120 80640 0 180 $X=51770 $Y=75520
X62594 1 2 5536 5312 9114 NO2I1_5VX1 $T=53320 206080 1 0 $X=52890 $Y=200960
X62595 1 2 5531 4716 5547 NO2I1_5VX1 $T=53320 358400 1 0 $X=52890 $Y=353280
X62596 1 2 5266 4716 5561 NO2I1_5VX1 $T=54440 412160 1 0 $X=54010 $Y=407040
X62597 1 2 5545 5504 5573 NO2I1_5VX1 $T=55000 224000 1 0 $X=54570 $Y=218880
X62598 1 2 5448 2810 9084 NO2I1_5VX1 $T=59480 44800 1 180 $X=55130 $Y=44160
X62599 1 2 9119 2810 5566 NO2I1_5VX1 $T=56120 53760 1 0 $X=55690 $Y=48640
X62600 1 2 9120 5312 5620 NO2I1_5VX1 $T=56120 125440 1 0 $X=55690 $Y=120320
X62601 1 2 5384 5504 5575 NO2I1_5VX1 $T=56120 277760 0 0 $X=55690 $Y=277120
X62602 1 2 5471 5312 5570 NO2I1_5VX1 $T=56680 98560 1 0 $X=56250 $Y=93440
X62603 1 2 9121 5312 5551 NO2I1_5VX1 $T=60600 170240 0 180 $X=56250 $Y=165120
X62604 1 2 9972 5312 5613 NO2I1_5VX1 $T=58360 152320 1 0 $X=57930 $Y=147200
X62605 1 2 9127 2810 5585 NO2I1_5VX1 $T=58920 71680 1 0 $X=58490 $Y=66560
X62606 1 2 335 2810 5617 NO2I1_5VX1 $T=58920 80640 0 0 $X=58490 $Y=80000
X62607 1 2 9973 5504 5600 NO2I1_5VX1 $T=58920 224000 0 0 $X=58490 $Y=223360
X62608 1 2 5578 2810 5609 NO2I1_5VX1 $T=60040 26880 1 0 $X=59610 $Y=21760
X62609 1 2 5572 5312 9138 NO2I1_5VX1 $T=60040 206080 1 0 $X=59610 $Y=200960
X62610 1 2 6950 5312 9865 NO2I1_5VX1 $T=60600 125440 0 0 $X=60170 $Y=124800
X62611 1 2 5598 2810 5629 NO2I1_5VX1 $T=61160 80640 1 0 $X=60730 $Y=75520
X62612 1 2 9974 5504 9275 NO2I1_5VX1 $T=61160 232960 1 0 $X=60730 $Y=227840
X62613 1 2 5591 5504 6257 NO2I1_5VX1 $T=61160 313600 0 0 $X=60730 $Y=312960
X62614 1 2 5606 5312 9134 NO2I1_5VX1 $T=61720 197120 0 0 $X=61290 $Y=196480
X62615 1 2 319 2810 5594 NO2I1_5VX1 $T=66200 62720 0 180 $X=61850 $Y=57600
X62616 1 2 5605 5312 5701 NO2I1_5VX1 $T=62280 170240 0 0 $X=61850 $Y=169600
X62617 1 2 5358 5504 5645 NO2I1_5VX1 $T=62840 241920 0 0 $X=62410 $Y=241280
X62618 1 2 5378 5504 5638 NO2I1_5VX1 $T=62840 295680 1 0 $X=62410 $Y=290560
X62619 1 2 5555 5504 5639 NO2I1_5VX1 $T=62840 322560 1 0 $X=62410 $Y=317440
X62620 1 2 9866 5504 5646 NO2I1_5VX1 $T=63400 304640 0 0 $X=62970 $Y=304000
X62621 1 2 5621 5312 9137 NO2I1_5VX1 $T=63960 152320 1 0 $X=63530 $Y=147200
X62622 1 2 9133 5312 5641 NO2I1_5VX1 $T=63960 161280 0 0 $X=63530 $Y=160640
X62623 1 2 9975 2810 5634 NO2I1_5VX1 $T=69000 53760 1 180 $X=64650 $Y=53120
X62624 1 2 5614 5312 5668 NO2I1_5VX1 $T=65640 197120 0 0 $X=65210 $Y=196480
X62625 1 2 9144 2810 5643 NO2I1_5VX1 $T=70120 80640 0 180 $X=65770 $Y=75520
X62626 1 2 5635 5312 5658 NO2I1_5VX1 $T=66200 125440 0 0 $X=65770 $Y=124800
X62627 1 2 5568 5504 5683 NO2I1_5VX1 $T=66200 232960 1 0 $X=65770 $Y=227840
X62628 1 2 5631 5504 5692 NO2I1_5VX1 $T=66200 313600 0 0 $X=65770 $Y=312960
X62629 1 2 5599 5312 5667 NO2I1_5VX1 $T=66760 179200 1 0 $X=66330 $Y=174080
X62630 1 2 5677 5504 6240 NO2I1_5VX1 $T=70680 268800 0 180 $X=66330 $Y=263680
X62631 1 2 5390 5504 5582 NO2I1_5VX1 $T=70680 295680 0 180 $X=66330 $Y=290560
X62632 1 2 5654 4716 5704 NO2I1_5VX1 $T=67320 403200 1 0 $X=66890 $Y=398080
X62633 1 2 5593 2810 5960 NO2I1_5VX1 $T=69000 53760 1 0 $X=68570 $Y=48640
X62634 1 2 5699 5312 5604 NO2I1_5VX1 $T=72920 107520 1 180 $X=68570 $Y=106880
X62635 1 2 9152 5312 5675 NO2I1_5VX1 $T=72920 161280 0 180 $X=68570 $Y=156160
X62636 1 2 5615 4716 5697 NO2I1_5VX1 $T=69000 349440 1 0 $X=68570 $Y=344320
X62637 1 2 5045 5504 5723 NO2I1_5VX1 $T=69560 250880 1 0 $X=69130 $Y=245760
X62638 1 2 5546 5504 9182 NO2I1_5VX1 $T=71240 295680 0 0 $X=70810 $Y=295040
X62639 1 2 5702 5312 6702 NO2I1_5VX1 $T=71800 197120 1 0 $X=71370 $Y=192000
X62640 1 2 5722 5312 9150 NO2I1_5VX1 $T=76280 188160 0 180 $X=71930 $Y=183040
X62641 1 2 5583 5504 5719 NO2I1_5VX1 $T=72360 322560 0 0 $X=71930 $Y=321920
X62642 1 2 763 4716 5733 NO2I1_5VX1 $T=72920 403200 1 0 $X=72490 $Y=398080
X62643 1 2 378 5312 6736 NO2I1_5VX1 $T=74600 98560 0 0 $X=74170 $Y=97920
X62644 1 2 5763 5312 5737 NO2I1_5VX1 $T=80200 107520 1 180 $X=75850 $Y=106880
X62645 1 2 5714 5312 5759 NO2I1_5VX1 $T=76280 188160 1 0 $X=75850 $Y=183040
X62646 1 2 5601 5235 9160 NO2I1_5VX1 $T=80760 367360 1 180 $X=76410 $Y=366720
X62647 1 2 5734 4716 5736 NO2I1_5VX1 $T=76840 403200 0 0 $X=76410 $Y=402560
X62648 1 2 5771 5312 5756 NO2I1_5VX1 $T=82440 89600 0 180 $X=78090 $Y=84480
X62649 1 2 5761 5504 5778 NO2I1_5VX1 $T=79080 349440 1 0 $X=78650 $Y=344320
X62650 1 2 5746 5504 5784 NO2I1_5VX1 $T=79080 367360 1 0 $X=78650 $Y=362240
X62651 1 2 408 5312 5792 NO2I1_5VX1 $T=80200 107520 0 0 $X=79770 $Y=106880
X62652 1 2 5795 2810 9008 NO2I1_5VX1 $T=84680 71680 0 180 $X=80330 $Y=66560
X62653 1 2 5811 5312 9165 NO2I1_5VX1 $T=85800 215040 1 180 $X=81450 $Y=214400
X62654 1 2 5791 4716 5802 NO2I1_5VX1 $T=81880 412160 1 0 $X=81450 $Y=407040
X62655 1 2 5790 4716 5809 NO2I1_5VX1 $T=82440 403200 0 0 $X=82010 $Y=402560
X62656 1 2 5823 5312 4688 NO2I1_5VX1 $T=86920 89600 0 180 $X=82570 $Y=84480
X62657 1 2 5797 5312 5829 NO2I1_5VX1 $T=83560 125440 0 0 $X=83130 $Y=124800
X62658 1 2 5114 5312 6247 NO2I1_5VX1 $T=83560 143360 1 0 $X=83130 $Y=138240
X62659 1 2 5601 5504 5815 NO2I1_5VX1 $T=83560 367360 0 0 $X=83130 $Y=366720
X62660 1 2 5235 5504 5841 NO2I1_5VX1 $T=84680 349440 0 0 $X=84250 $Y=348800
X62661 1 2 5767 443 5821 NO2I1_5VX1 $T=90280 17920 1 180 $X=85930 $Y=17280
X62662 1 2 9976 5504 5850 NO2I1_5VX1 $T=87480 232960 1 0 $X=87050 $Y=227840
X62663 1 2 5652 5504 5866 NO2I1_5VX1 $T=88040 241920 0 0 $X=87610 $Y=241280
X62664 1 2 5870 5312 4680 NO2I1_5VX1 $T=93080 116480 0 180 $X=88730 $Y=111360
X62665 1 2 4977 5312 7054 NO2I1_5VX1 $T=89720 152320 1 0 $X=89290 $Y=147200
X62666 1 2 5913 5504 5893 NO2I1_5VX1 $T=97560 224000 1 180 $X=93210 $Y=223360
X62667 1 2 5766 5504 5914 NO2I1_5VX1 $T=93640 232960 1 0 $X=93210 $Y=227840
X62668 1 2 772 5504 5942 NO2I1_5VX1 $T=97000 215040 1 0 $X=96570 $Y=209920
X62669 1 2 5921 5312 6965 NO2I1_5VX1 $T=102600 143360 1 180 $X=98250 $Y=142720
X62670 1 2 5204 5312 5853 NO2I1_5VX1 $T=102600 206080 1 180 $X=98250 $Y=205440
X62671 1 2 5847 5504 6079 NO2I1_5VX1 $T=101480 277760 1 0 $X=101050 $Y=272640
X62672 1 2 5954 5504 5979 NO2I1_5VX1 $T=102040 304640 1 0 $X=101610 $Y=299520
X62673 1 2 5469 5504 6033 NO2I1_5VX1 $T=102600 215040 1 0 $X=102170 $Y=209920
X62674 1 2 9179 5504 5998 NO2I1_5VX1 $T=103160 232960 0 0 $X=102730 $Y=232320
X62675 1 2 5975 5312 5995 NO2I1_5VX1 $T=104280 152320 1 0 $X=103850 $Y=147200
X62676 1 2 326 5312 6023 NO2I1_5VX1 $T=105400 197120 1 0 $X=104970 $Y=192000
X62677 1 2 5745 5504 6019 NO2I1_5VX1 $T=105400 277760 1 0 $X=104970 $Y=272640
X62678 1 2 5864 5504 6005 NO2I1_5VX1 $T=105400 286720 1 0 $X=104970 $Y=281600
X62679 1 2 777 5312 5997 NO2I1_5VX1 $T=110440 161280 0 180 $X=106090 $Y=156160
X62680 1 2 339 5312 5990 NO2I1_5VX1 $T=110440 206080 0 180 $X=106090 $Y=200960
X62681 1 2 362 5312 7129 NO2I1_5VX1 $T=112680 170240 1 180 $X=108330 $Y=169600
X62682 1 2 5670 5504 6042 NO2I1_5VX1 $T=109320 286720 1 0 $X=108890 $Y=281600
X62683 1 2 5165 5312 6066 NO2I1_5VX1 $T=109880 152320 1 0 $X=109450 $Y=147200
X62684 1 2 348 5312 6069 NO2I1_5VX1 $T=111560 206080 1 0 $X=111130 $Y=200960
X62685 1 2 6071 5504 6070 NO2I1_5VX1 $T=112120 224000 0 0 $X=111690 $Y=223360
X62686 1 2 6085 5312 9237 NO2I1_5VX1 $T=115480 206080 1 0 $X=115050 $Y=200960
X62687 1 2 9239 5312 7014 NO2I1_5VX1 $T=121080 197120 0 180 $X=116730 $Y=192000
X62688 1 2 6089 5504 6110 NO2I1_5VX1 $T=117160 268800 0 0 $X=116730 $Y=268160
X62689 1 2 9242 5312 9236 NO2I1_5VX1 $T=121640 170240 0 180 $X=117290 $Y=165120
X62690 1 2 6103 5504 6134 NO2I1_5VX1 $T=118280 215040 0 0 $X=117850 $Y=214400
X62691 1 2 9871 5504 6133 NO2I1_5VX1 $T=119400 206080 1 0 $X=118970 $Y=200960
X62692 1 2 6032 6009 6144 NO2I1_5VX1 $T=119960 349440 0 0 $X=119530 $Y=348800
X62693 1 2 9977 5504 6740 NO2I1_5VX1 $T=120520 322560 1 0 $X=120090 $Y=317440
X62694 1 2 6179 6147 5889 NO2I1_5VX1 $T=126680 80640 1 180 $X=122330 $Y=80000
X62695 1 2 6167 5504 6209 NO2I1_5VX1 $T=125560 250880 0 0 $X=125130 $Y=250240
X62696 1 2 6025 9259 6090 NO2I1_5VX1 $T=130600 394240 0 180 $X=126250 $Y=389120
X62697 1 2 346 5312 6205 NO2I1_5VX1 $T=133400 170240 0 180 $X=129050 $Y=165120
X62698 1 2 5833 5504 6223 NO2I1_5VX1 $T=129480 322560 1 0 $X=129050 $Y=317440
X62699 1 2 5985 6017 9259 NO2I1_5VX1 $T=136200 394240 1 180 $X=131850 $Y=393600
X62700 1 2 5788 5504 6531 NO2I1_5VX1 $T=132840 340480 0 0 $X=132410 $Y=339840
X62701 1 2 9274 5312 6233 NO2I1_5VX1 $T=137320 188160 0 180 $X=132970 $Y=183040
X62702 1 2 6231 5504 6994 NO2I1_5VX1 $T=133960 206080 0 0 $X=133530 $Y=205440
X62703 1 2 5848 5504 6264 NO2I1_5VX1 $T=133960 313600 1 0 $X=133530 $Y=308480
X62704 1 2 6059 5504 6390 NO2I1_5VX1 $T=133960 331520 0 0 $X=133530 $Y=330880
X62705 1 2 6260 5312 9290 NO2I1_5VX1 $T=151880 116480 1 0 $X=151450 $Y=111360
X62706 1 2 6272 5312 778 NO2I1_5VX1 $T=152440 188160 1 0 $X=152010 $Y=183040
X62707 1 2 6269 5504 6282 NO2I1_5VX1 $T=152440 349440 1 0 $X=152010 $Y=344320
X62708 1 2 6270 5312 6295 NO2I1_5VX1 $T=153560 107520 1 0 $X=153130 $Y=102400
X62709 1 2 9287 5312 6345 NO2I1_5VX1 $T=155240 170240 0 0 $X=154810 $Y=169600
X62710 1 2 5985 5504 6328 NO2I1_5VX1 $T=155800 376320 0 0 $X=155370 $Y=375680
X62711 1 2 783 6319 6339 NO2I1_5VX1 $T=156360 232960 1 0 $X=155930 $Y=227840
X62712 1 2 6160 5504 6340 NO2I1_5VX1 $T=158040 277760 1 0 $X=157610 $Y=272640
X62713 1 2 6350 5504 6327 NO2I1_5VX1 $T=161960 322560 1 180 $X=157610 $Y=321920
X62714 1 2 6321 443 6353 NO2I1_5VX1 $T=158600 44800 0 0 $X=158170 $Y=44160
X62715 1 2 6365 5312 6297 NO2I1_5VX1 $T=163640 143360 1 180 $X=159290 $Y=142720
X62716 1 2 6361 5312 6298 NO2I1_5VX1 $T=164200 161280 0 180 $X=159850 $Y=156160
X62717 1 2 6347 6360 6376 NO2I1_5VX1 $T=160840 71680 0 0 $X=160410 $Y=71040
X62718 1 2 9292 6367 9318 NO2I1_5VX1 $T=161960 206080 1 0 $X=161530 $Y=200960
X62719 1 2 6017 5504 6411 NO2I1_5VX1 $T=163640 349440 0 0 $X=163210 $Y=348800
X62720 1 2 9876 6360 6394 NO2I1_5VX1 $T=164200 89600 1 0 $X=163770 $Y=84480
X62721 1 2 9313 5504 6389 NO2I1_5VX1 $T=164200 286720 0 0 $X=163770 $Y=286080
X62722 1 2 7213 6360 9307 NO2I1_5VX1 $T=168680 53760 1 180 $X=164330 $Y=53120
X62723 1 2 9311 6360 785 NO2I1_5VX1 $T=164760 152320 0 0 $X=164330 $Y=151680
X62724 1 2 5565 5504 6415 NO2I1_5VX1 $T=165320 367360 0 0 $X=164890 $Y=366720
X62725 1 2 9310 6360 6416 NO2I1_5VX1 $T=166440 116480 0 0 $X=166010 $Y=115840
X62726 1 2 9316 6360 6424 NO2I1_5VX1 $T=166440 179200 0 0 $X=166010 $Y=178560
X62727 1 2 6404 443 490 NO2I1_5VX1 $T=167560 26880 0 0 $X=167130 $Y=26240
X62728 1 2 6395 6360 6423 NO2I1_5VX1 $T=167560 125440 0 0 $X=167130 $Y=124800
X62729 1 2 6407 6360 6422 NO2I1_5VX1 $T=168120 89600 1 0 $X=167690 $Y=84480
X62730 1 2 6378 5504 6431 NO2I1_5VX1 $T=168120 286720 1 0 $X=167690 $Y=281600
X62731 1 2 9978 6360 7224 NO2I1_5VX1 $T=168680 125440 1 0 $X=168250 $Y=120320
X62732 1 2 6412 786 9323 NO2I1_5VX1 $T=168680 250880 1 0 $X=168250 $Y=245760
X62733 1 2 796 6360 9878 NO2I1_5VX1 $T=173160 89600 1 180 $X=168810 $Y=88960
X62734 1 2 6381 6360 6469 NO2I1_5VX1 $T=169800 161280 0 0 $X=169370 $Y=160640
X62735 1 2 9324 5504 6440 NO2I1_5VX1 $T=170360 340480 1 0 $X=169930 $Y=335360
X62736 1 2 6421 5504 9332 NO2I1_5VX1 $T=170360 367360 1 0 $X=169930 $Y=362240
X62737 1 2 5649 443 6446 NO2I1_5VX1 $T=171480 26880 0 0 $X=171050 $Y=26240
X62738 1 2 6428 6360 9335 NO2I1_5VX1 $T=171480 197120 1 0 $X=171050 $Y=192000
X62739 1 2 6623 5504 6450 NO2I1_5VX1 $T=172040 322560 0 0 $X=171610 $Y=321920
X62740 1 2 6434 6360 6454 NO2I1_5VX1 $T=172600 134400 0 0 $X=172170 $Y=133760
X62741 1 2 6447 6360 7335 NO2I1_5VX1 $T=174280 53760 0 0 $X=173850 $Y=53120
X62742 1 2 6472 5504 6508 NO2I1_5VX1 $T=175960 367360 1 0 $X=175530 $Y=362240
X62743 1 2 6486 6360 9344 NO2I1_5VX1 $T=176520 197120 1 0 $X=176090 $Y=192000
X62744 1 2 6344 443 6236 NO2I1_5VX1 $T=183240 35840 1 180 $X=178890 $Y=35200
X62745 1 2 9346 6360 6503 NO2I1_5VX1 $T=184360 98560 1 180 $X=180010 $Y=97920
X62746 1 2 6451 6360 7353 NO2I1_5VX1 $T=181000 71680 1 0 $X=180570 $Y=66560
X62747 1 2 6512 5504 6549 NO2I1_5VX1 $T=181560 367360 1 0 $X=181130 $Y=362240
X62748 1 2 9352 6360 6521 NO2I1_5VX1 $T=186600 53760 1 180 $X=182250 $Y=53120
X62749 1 2 6545 6360 6509 NO2I1_5VX1 $T=186600 143360 1 180 $X=182250 $Y=142720
X62750 1 2 497 443 6554 NO2I1_5VX1 $T=183240 35840 0 0 $X=182810 $Y=35200
X62751 1 2 9343 6360 6546 NO2I1_5VX1 $T=183800 188160 1 0 $X=183370 $Y=183040
X62752 1 2 9950 6540 6551 NO2I1_5VX1 $T=183800 224000 1 0 $X=183370 $Y=218880
X62753 1 2 6532 6360 6580 NO2I1_5VX1 $T=185480 107520 1 0 $X=185050 $Y=102400
X62754 1 2 6609 6360 4658 NO2I1_5VX1 $T=189400 134400 0 180 $X=185050 $Y=129280
X62755 1 2 9347 6360 6615 NO2I1_5VX1 $T=186040 170240 1 0 $X=185610 $Y=165120
X62756 1 2 9353 6540 6587 NO2I1_5VX1 $T=186600 206080 1 0 $X=186170 $Y=200960
X62757 1 2 6550 6360 6610 NO2I1_5VX1 $T=187160 152320 1 0 $X=186730 $Y=147200
X62758 1 2 6565 443 6896 NO2I1_5VX1 $T=187720 35840 0 0 $X=187290 $Y=35200
X62759 1 2 9350 6360 6578 NO2I1_5VX1 $T=187720 161280 1 0 $X=187290 $Y=156160
X62760 1 2 9358 6540 6569 NO2I1_5VX1 $T=191640 224000 0 180 $X=187290 $Y=218880
X62761 1 2 6566 6360 9363 NO2I1_5VX1 $T=188280 98560 1 0 $X=187850 $Y=93440
X62762 1 2 6493 6360 6585 NO2I1_5VX1 $T=188280 98560 0 0 $X=187850 $Y=97920
X62763 1 2 6990 6360 6555 NO2I1_5VX1 $T=192200 143360 1 180 $X=187850 $Y=142720
X62764 1 2 9951 6360 6599 NO2I1_5VX1 $T=188840 179200 0 0 $X=188410 $Y=178560
X62765 1 2 6616 6360 9357 NO2I1_5VX1 $T=192760 188160 0 180 $X=188410 $Y=183040
X62766 1 2 6576 6360 6593 NO2I1_5VX1 $T=189400 125440 0 0 $X=188970 $Y=124800
X62767 1 2 6608 443 5689 NO2I1_5VX1 $T=194440 26880 1 180 $X=190090 $Y=26240
X62768 1 2 6614 6360 6626 NO2I1_5VX1 $T=193880 134400 1 0 $X=193450 $Y=129280
X62769 1 2 6636 6540 9364 NO2I1_5VX1 $T=198360 232960 0 180 $X=194010 $Y=227840
X62770 1 2 9952 6540 6657 NO2I1_5VX1 $T=197240 232960 0 0 $X=196810 $Y=232320
X62771 1 2 6643 6360 7245 NO2I1_5VX1 $T=200600 44800 0 0 $X=200170 $Y=44160
X62772 1 2 6653 6540 6683 NO2I1_5VX1 $T=201160 241920 0 0 $X=200730 $Y=241280
X62773 1 2 6670 6540 9382 NO2I1_5VX1 $T=202840 232960 0 0 $X=202410 $Y=232320
X62774 1 2 6697 6540 6720 NO2I1_5VX1 $T=206200 241920 0 0 $X=205770 $Y=241280
X62775 1 2 9397 6540 6699 NO2I1_5VX1 $T=211240 224000 1 180 $X=206890 $Y=223360
X62776 1 2 6735 6540 6756 NO2I1_5VX1 $T=211240 241920 0 0 $X=210810 $Y=241280
X62777 1 2 6732 6540 7045 NO2I1_5VX1 $T=211240 250880 0 0 $X=210810 $Y=250240
X62778 1 2 6768 6540 7180 NO2I1_5VX1 $T=219640 241920 1 180 $X=215290 $Y=241280
X62779 1 2 6779 6360 6794 NO2I1_5VX1 $T=219640 53760 0 0 $X=219210 $Y=53120
X62780 1 2 9413 6540 6801 NO2I1_5VX1 $T=219640 250880 0 0 $X=219210 $Y=250240
X62781 1 2 6784 6540 6789 NO2I1_5VX1 $T=220200 241920 0 0 $X=219770 $Y=241280
X62782 1 2 526 525 6708 NO2I1_5VX1 $T=224680 26880 0 180 $X=220330 $Y=21760
X62783 1 2 6908 6540 6835 NO2I1_5VX1 $T=224680 241920 1 0 $X=224250 $Y=236800
X62784 1 2 6764 6540 6843 NO2I1_5VX1 $T=225240 250880 1 0 $X=224810 $Y=245760
X62785 1 2 6769 6540 6844 NO2I1_5VX1 $T=225240 250880 0 0 $X=224810 $Y=250240
X62786 1 2 9435 6360 6831 NO2I1_5VX1 $T=230280 107520 0 180 $X=225930 $Y=102400
X62787 1 2 9979 6360 6855 NO2I1_5VX1 $T=234760 107520 0 180 $X=230410 $Y=102400
X62788 1 2 6853 6540 6891 NO2I1_5VX1 $T=230840 250880 1 0 $X=230410 $Y=245760
X62789 1 2 6882 6540 6879 NO2I1_5VX1 $T=233080 259840 1 0 $X=232650 $Y=254720
X62790 1 2 9450 6540 793 NO2I1_5VX1 $T=236440 250880 1 0 $X=236010 $Y=245760
X62791 1 2 6983 6360 6904 NO2I1_5VX1 $T=245960 98560 0 180 $X=241610 $Y=93440
X62792 1 2 6952 6540 6929 NO2I1_5VX1 $T=252680 125440 0 180 $X=248330 $Y=120320
X62793 1 2 6935 6540 6930 NO2I1_5VX1 $T=252680 206080 1 180 $X=248330 $Y=205440
X62794 1 2 6942 6540 6957 NO2I1_5VX1 $T=251560 134400 1 0 $X=251130 $Y=129280
X62795 1 2 9468 6540 6947 NO2I1_5VX1 $T=256040 116480 1 180 $X=251690 $Y=115840
X62796 1 2 6973 6540 6695 NO2I1_5VX1 $T=257720 143360 1 180 $X=253370 $Y=142720
X62797 1 2 6968 6540 6696 NO2I1_5VX1 $T=257720 170240 1 180 $X=253370 $Y=169600
X62798 1 2 6974 6540 6357 NO2I1_5VX1 $T=257720 179200 0 180 $X=253370 $Y=174080
X62799 1 2 6960 6540 6941 NO2I1_5VX1 $T=258280 125440 1 180 $X=253930 $Y=124800
X62800 1 2 9957 6540 6928 NO2I1_5VX1 $T=258840 197120 0 180 $X=254490 $Y=192000
X62801 1 2 6977 6540 6900 NO2I1_5VX1 $T=259960 98560 1 180 $X=255610 $Y=97920
X62802 1 2 7017 6540 7307 NO2I1_5VX1 $T=261640 152320 1 180 $X=257290 $Y=151680
X62803 1 2 7220 6540 6979 NO2I1_5VX1 $T=261640 188160 0 180 $X=257290 $Y=183040
X62804 1 2 9980 6540 6986 NO2I1_5VX1 $T=262760 107520 0 180 $X=258410 $Y=102400
X62805 1 2 7012 6540 7093 NO2I1_5VX1 $T=262760 170240 0 180 $X=258410 $Y=165120
X62806 1 2 6998 6540 6987 NO2I1_5VX1 $T=262760 179200 0 180 $X=258410 $Y=174080
X62807 1 2 7018 6540 798 NO2I1_5VX1 $T=262760 206080 0 180 $X=258410 $Y=200960
X62808 1 2 7013 6540 6577 NO2I1_5VX1 $T=263320 125440 1 180 $X=258970 $Y=124800
X62809 1 2 7010 6540 7052 NO2I1_5VX1 $T=263320 143360 1 180 $X=258970 $Y=142720
X62810 1 2 6997 6540 6674 NO2I1_5VX1 $T=263320 152320 0 180 $X=258970 $Y=147200
X62811 1 2 7004 6540 6682 NO2I1_5VX1 $T=263880 98560 1 180 $X=259530 $Y=97920
X62812 1 2 7007 6540 6988 NO2I1_5VX1 $T=264440 206080 1 180 $X=260090 $Y=205440
X62813 1 2 9477 6540 6992 NO2I1_5VX1 $T=265000 107520 1 180 $X=260650 $Y=106880
X62814 1 2 7003 6360 7022 NO2I1_5VX1 $T=262760 80640 0 0 $X=262330 $Y=80000
X62815 1 2 7023 6540 7005 NO2I1_5VX1 $T=268360 125440 1 180 $X=264010 $Y=124800
X62816 1 2 7029 6540 7701 NO2I1_5VX1 $T=268920 107520 1 180 $X=264570 $Y=106880
X62817 1 2 7035 6540 7000 NO2I1_5VX1 $T=269480 206080 0 180 $X=265130 $Y=200960
X62818 1 2 7020 525 6864 NO2I1_5VX1 $T=271720 26880 0 180 $X=267370 $Y=21760
X62819 1 2 7055 6360 7057 NO2I1_5VX1 $T=276200 80640 0 180 $X=271850 $Y=75520
X62820 1 2 7081 525 6766 NO2I1_5VX1 $T=277320 26880 0 180 $X=272970 $Y=21760
X62821 1 2 7056 6540 7058 NO2I1_5VX1 $T=277320 98560 0 180 $X=272970 $Y=93440
X62822 1 2 9494 7089 7041 NO2I1_5VX1 $T=280120 53760 0 180 $X=275770 $Y=48640
X62823 1 2 7095 6360 6645 NO2I1_5VX1 $T=280120 80640 0 180 $X=275770 $Y=75520
X62824 1 2 7115 7032 6750 NO2I1_5VX1 $T=284040 62720 1 180 $X=279690 $Y=62080
X62825 1 2 7042 6540 9495 NO2I1_5VX1 $T=285160 98560 1 180 $X=280810 $Y=97920
X62826 1 2 7289 6540 7107 NO2I1_5VX1 $T=285160 170240 1 180 $X=280810 $Y=169600
X62827 1 2 797 6540 7112 NO2I1_5VX1 $T=285160 197120 0 180 $X=280810 $Y=192000
X62828 1 2 7174 6540 7138 NO2I1_5VX1 $T=290200 125440 0 180 $X=285850 $Y=120320
X62829 1 2 7225 7032 6644 NO2I1_5VX1 $T=304200 53760 1 180 $X=299850 $Y=53120
X62830 1 2 7273 7032 7295 NO2I1_5VX1 $T=316520 89600 1 180 $X=312170 $Y=88960
X62831 1 2 7300 6540 7276 NO2I1_5VX1 $T=323800 188160 0 180 $X=319450 $Y=183040
X62832 1 2 9556 6540 7298 NO2I1_5VX1 $T=323800 197120 0 180 $X=319450 $Y=192000
X62833 1 2 7294 6540 7308 NO2I1_5VX1 $T=321560 170240 1 0 $X=321130 $Y=165120
X62834 1 2 7318 6540 7192 NO2I1_5VX1 $T=326600 206080 1 180 $X=322250 $Y=205440
X62835 1 2 7311 6540 9555 NO2I1_5VX1 $T=326600 215040 0 180 $X=322250 $Y=209920
X62836 1 2 7314 7032 7177 NO2I1_5VX1 $T=327720 98560 1 180 $X=323370 $Y=97920
X62837 1 2 7345 6540 7290 NO2I1_5VX1 $T=328840 188160 1 180 $X=324490 $Y=187520
X62838 1 2 9563 6540 7265 NO2I1_5VX1 $T=328840 197120 0 180 $X=324490 $Y=192000
X62839 1 2 7324 7032 7074 NO2I1_5VX1 $T=329400 134400 1 180 $X=325050 $Y=133760
X62840 1 2 7310 7032 7333 NO2I1_5VX1 $T=326040 107520 0 0 $X=325610 $Y=106880
X62841 1 2 7341 6540 7320 NO2I1_5VX1 $T=330520 170240 0 180 $X=326170 $Y=165120
X62842 1 2 7344 7032 6884 NO2I1_5VX1 $T=331640 89600 1 180 $X=327290 $Y=88960
X62843 1 2 9567 6540 7275 NO2I1_5VX1 $T=331640 206080 0 180 $X=327290 $Y=200960
X62844 1 2 7420 7032 7339 NO2I1_5VX1 $T=335000 80640 0 180 $X=330650 $Y=75520
X62845 1 2 7338 7032 7279 NO2I1_5VX1 $T=331080 80640 0 0 $X=330650 $Y=80000
X62846 1 2 7342 6540 7358 NO2I1_5VX1 $T=332200 170240 1 0 $X=331770 $Y=165120
X62847 1 2 7350 7032 9573 NO2I1_5VX1 $T=332760 89600 0 0 $X=332330 $Y=88960
X62848 1 2 7367 7032 7304 NO2I1_5VX1 $T=336680 125440 1 180 $X=332330 $Y=124800
X62849 1 2 7365 6540 7352 NO2I1_5VX1 $T=336680 161280 0 180 $X=332330 $Y=156160
X62850 1 2 7371 7032 7206 NO2I1_5VX1 $T=339480 62720 0 180 $X=335130 $Y=57600
X62851 1 2 7377 7032 9569 NO2I1_5VX1 $T=339480 134400 0 180 $X=335130 $Y=129280
X62852 1 2 7372 7032 9572 NO2I1_5VX1 $T=340040 134400 1 180 $X=335690 $Y=133760
X62853 1 2 7475 7032 7087 NO2I1_5VX1 $T=340600 152320 1 180 $X=336250 $Y=151680
X62854 1 2 7382 7032 6921 NO2I1_5VX1 $T=341160 107520 0 180 $X=336810 $Y=102400
X62855 1 2 7394 7032 9560 NO2I1_5VX1 $T=342840 161280 0 180 $X=338490 $Y=156160
X62856 1 2 7385 7032 9577 NO2I1_5VX1 $T=343400 62720 0 180 $X=339050 $Y=57600
X62857 1 2 7900 7032 7351 NO2I1_5VX1 $T=343960 116480 1 180 $X=339610 $Y=115840
X62858 1 2 7925 443 9574 NO2I1_5VX1 $T=345640 44800 0 180 $X=341290 $Y=39680
X62859 1 2 7415 7032 9570 NO2I1_5VX1 $T=346760 71680 1 180 $X=342410 $Y=71040
X62860 1 2 7419 7032 7392 NO2I1_5VX1 $T=346760 179200 0 180 $X=342410 $Y=174080
X62861 1 2 9580 443 7414 NO2I1_5VX1 $T=343960 35840 1 0 $X=343530 $Y=30720
X62862 1 2 9585 443 7381 NO2I1_5VX1 $T=347880 53760 0 180 $X=343530 $Y=48640
X62863 1 2 7422 7032 7407 NO2I1_5VX1 $T=348440 161280 0 180 $X=344090 $Y=156160
X62864 1 2 7491 7032 7383 NO2I1_5VX1 $T=348440 170240 0 180 $X=344090 $Y=165120
X62865 1 2 7452 7032 9579 NO2I1_5VX1 $T=351800 179200 1 180 $X=347450 $Y=178560
X62866 1 2 7387 7032 7443 NO2I1_5VX1 $T=349000 215040 0 0 $X=348570 $Y=214400
X62867 1 2 9592 443 7931 NO2I1_5VX1 $T=352360 17920 1 0 $X=351930 $Y=12800
X62868 1 2 7465 443 9594 NO2I1_5VX1 $T=356280 26880 0 180 $X=351930 $Y=21760
X62869 1 2 7926 443 7461 NO2I1_5VX1 $T=359080 17920 1 180 $X=354730 $Y=17280
X62870 1 2 9610 7032 7512 NO2I1_5VX1 $T=363000 215040 1 0 $X=362570 $Y=209920
X62871 1 2 548 7495 7538 NO2I1_5VX1 $T=367480 80640 0 0 $X=367050 $Y=80000
X62872 1 2 9620 7032 7527 NO2I1_5VX1 $T=367480 206080 1 0 $X=367050 $Y=200960
X62873 1 2 545 7504 7571 NO2I1_5VX1 $T=369160 161280 0 0 $X=368730 $Y=160640
X62874 1 2 9627 7032 7460 NO2I1_5VX1 $T=374200 215040 0 180 $X=369850 $Y=209920
X62875 1 2 7549 7032 9629 NO2I1_5VX1 $T=379240 215040 0 180 $X=374890 $Y=209920
X62876 1 2 9644 7032 7550 NO2I1_5VX1 $T=385960 197120 1 180 $X=381610 $Y=196480
X62877 1 2 7604 800 7599 NO2I1_5VX1 $T=407240 143360 0 0 $X=406810 $Y=142720
X62878 1 2 7639 7032 7612 NO2I1_5VX1 $T=412280 197120 1 180 $X=407930 $Y=196480
X62879 1 2 7662 7032 9666 NO2I1_5VX1 $T=417320 206080 0 180 $X=412970 $Y=200960
X62880 1 2 9686 7032 802 NO2I1_5VX1 $T=429080 206080 1 180 $X=424730 $Y=205440
X62881 1 2 9981 7032 7788 NO2I1_5VX1 $T=431880 170240 0 180 $X=427530 $Y=165120
X62882 1 2 7735 7032 7734 NO2I1_5VX1 $T=430200 170240 0 0 $X=429770 $Y=169600
X62883 1 2 7706 7032 9690 NO2I1_5VX1 $T=434680 206080 0 0 $X=434250 $Y=205440
X62884 1 2 7751 7032 9695 NO2I1_5VX1 $T=444200 152320 1 180 $X=439850 $Y=151680
X62885 1 2 7747 7032 7732 NO2I1_5VX1 $T=445320 143360 1 180 $X=440970 $Y=142720
X62886 1 2 7737 7032 9709 NO2I1_5VX1 $T=443640 134400 1 0 $X=443210 $Y=129280
X62887 1 2 7722 7032 7917 NO2I1_5VX1 $T=444760 125440 1 0 $X=444330 $Y=120320
X62888 1 2 9698 7032 7755 NO2I1_5VX1 $T=446440 206080 0 0 $X=446010 $Y=205440
X62889 1 2 545 7032 9712 NO2I1_5VX1 $T=447000 197120 1 0 $X=446570 $Y=192000
X62890 1 2 9982 7032 9808 NO2I1_5VX1 $T=451480 107520 1 180 $X=447130 $Y=106880
X62891 1 2 550 7032 9713 NO2I1_5VX1 $T=453160 188160 0 180 $X=448810 $Y=183040
X62892 1 2 9983 7032 7775 NO2I1_5VX1 $T=455400 188160 0 0 $X=454970 $Y=187520
X62893 1 2 7779 7032 9734 NO2I1_5VX1 $T=458200 116480 1 0 $X=457770 $Y=111360
X62894 1 2 7909 7032 9728 NO2I1_5VX1 $T=463240 107520 0 180 $X=458890 $Y=102400
X62895 1 2 548 7032 7792 NO2I1_5VX1 $T=459320 188160 1 0 $X=458890 $Y=183040
X62896 1 2 7803 7032 9730 NO2I1_5VX1 $T=465480 89600 1 180 $X=461130 $Y=88960
X62897 1 2 547 7032 9741 NO2I1_5VX1 $T=463800 143360 0 0 $X=463370 $Y=142720
X62898 1 2 544 7032 7815 NO2I1_5VX1 $T=463800 161280 0 0 $X=463370 $Y=160640
X62899 1 2 542 7032 9739 NO2I1_5VX1 $T=466040 152320 1 0 $X=465610 $Y=147200
X62900 1 2 7810 7032 7832 NO2I1_5VX1 $T=468840 170240 0 0 $X=468410 $Y=169600
X62901 1 2 7816 7032 7841 NO2I1_5VX1 $T=470520 179200 0 0 $X=470090 $Y=178560
X62902 1 2 9744 7032 7886 NO2I1_5VX1 $T=472760 152320 0 0 $X=472330 $Y=151680
X62903 1 2 7822 7032 9753 NO2I1_5VX1 $T=473320 161280 0 0 $X=472890 $Y=160640
X62904 1 2 546 7032 7827 NO2I1_5VX1 $T=475000 134400 0 0 $X=474570 $Y=133760
X62905 1 2 7812 7032 7848 NO2I1_5VX1 $T=480040 125440 0 0 $X=479610 $Y=124800
X62906 1 2 533 7032 7837 NO2I1_5VX1 $T=480600 134400 1 0 $X=480170 $Y=129280
X62907 1 2 7843 7032 7856 NO2I1_5VX1 $T=480600 134400 0 0 $X=480170 $Y=133760
X62908 1 2 532 680 7834 NO2I1_5VX1 $T=482280 98560 1 0 $X=481850 $Y=93440
X62909 1 2 9758 680 9765 NO2I1_5VX1 $T=484520 80640 0 0 $X=484090 $Y=80000
X62910 1 2 7875 7032 7852 NO2I1_5VX1 $T=488440 107520 1 180 $X=484090 $Y=106880
X62911 1 2 528 680 9759 NO2I1_5VX1 $T=490680 89600 0 180 $X=486330 $Y=84480
X62912 1 2 9774 680 7929 NO2I1_5VX1 $T=491800 98560 0 180 $X=487450 $Y=93440
X62913 1 2 7879 680 9769 NO2I1_5VX1 $T=495160 71680 1 180 $X=490810 $Y=71040
X62914 1 2 535 680 7880 NO2I1_5VX1 $T=491800 80640 0 0 $X=491370 $Y=80000
X62915 1 2 9938 680 9778 NO2I1_5VX1 $T=497400 71680 1 0 $X=496970 $Y=66560
X62916 1 2 9776 680 7896 NO2I1_5VX1 $T=499640 89600 0 0 $X=499210 $Y=88960
X62917 1 2 7913 680 7895 NO2I1_5VX1 $T=504120 53760 1 180 $X=499770 $Y=53120
X62918 1 2 9782 680 7902 NO2I1_5VX1 $T=501880 80640 1 0 $X=501450 $Y=75520
X62919 1 2 9784 680 7911 NO2I1_5VX1 $T=506360 44800 1 0 $X=505930 $Y=39680
X62920 1 2 7906 680 9788 NO2I1_5VX1 $T=506920 17920 0 0 $X=506490 $Y=17280
X62921 1 2 9783 680 7912 NO2I1_5VX1 $T=506920 53760 0 0 $X=506490 $Y=53120
X62922 1 2 9786 680 7915 NO2I1_5VX1 $T=507480 35840 1 0 $X=507050 $Y=30720
X62923 1 2 536 680 7916 NO2I1_5VX1 $T=511400 62720 1 0 $X=510970 $Y=57600
X62924 1 2 40 43 8158 EN2_5VX1 $T=-439480 62720 0 0 $X=-439910 $Y=62080
X62925 1 2 41 40 1687 EN2_5VX1 $T=-438920 53760 1 0 $X=-439350 $Y=48640
X62926 1 2 43 39 8182 EN2_5VX1 $T=-432760 71680 0 0 $X=-433190 $Y=71040
X62927 1 2 1160 1719 8164 EN2_5VX1 $T=-426600 268800 0 180 $X=-433190 $Y=263680
X62928 1 2 1419 1880 8188 EN2_5VX1 $T=-426040 215040 0 0 $X=-426470 $Y=214400
X62929 1 2 1763 8187 1737 EN2_5VX1 $T=-417640 89600 1 180 $X=-424230 $Y=88960
X62930 1 2 1661 17 8187 EN2_5VX1 $T=-410360 89600 1 180 $X=-416950 $Y=88960
X62931 1 2 54 1661 8214 EN2_5VX1 $T=-412040 17920 0 0 $X=-412470 $Y=17280
X62932 1 2 135 2780 2859 EN2_5VX1 $T=-278200 35840 1 0 $X=-278630 $Y=30720
X62933 1 2 43 39 8452 EN2_5VX1 $T=-267560 161280 1 0 $X=-267990 $Y=156160
X62934 1 2 2963 8452 3050 EN2_5VX1 $T=-260840 161280 1 0 $X=-261270 $Y=156160
X62935 1 2 47 2748 3105 EN2_5VX1 $T=-247960 107520 0 0 $X=-248390 $Y=106880
X62936 1 2 2963 156 3092 EN2_5VX1 $T=-244040 161280 0 0 $X=-244470 $Y=160640
X62937 1 2 3189 3092 8511 EN2_5VX1 $T=-230040 161280 1 180 $X=-236630 $Y=160640
X62938 1 2 2605 3286 8554 EN2_5VX1 $T=-219960 125440 1 0 $X=-220390 $Y=120320
X62939 1 2 2963 156 3346 EN2_5VX1 $T=-211000 161280 0 0 $X=-211430 $Y=160640
X62940 1 2 3208 3311 3279 EN2_5VX1 $T=-203720 107520 1 180 $X=-210310 $Y=106880
X62941 1 2 3189 3346 8586 EN2_5VX1 $T=-209320 170240 0 0 $X=-209750 $Y=169600
X62942 1 2 720 200 3357 EN2_5VX1 $T=-199240 89600 0 180 $X=-205830 $Y=84480
X62943 1 2 3361 47 3433 EN2_5VX1 $T=-204840 80640 0 0 $X=-205270 $Y=80000
X62944 1 2 77 74 3361 EN2_5VX1 $T=-193080 89600 0 180 $X=-199670 $Y=84480
X62945 1 2 3038 3767 8630 EN2_5VX1 $T=-175720 358400 0 180 $X=-182310 $Y=353280
X62946 1 2 2771 3645 8634 EN2_5VX1 $T=-173480 134400 0 180 $X=-180070 $Y=129280
X62947 1 2 3385 3881 3735 EN2_5VX1 $T=-170680 304640 0 0 $X=-171110 $Y=304000
X62948 1 2 2907 3768 8679 EN2_5VX1 $T=-166760 161280 0 0 $X=-167190 $Y=160640
X62949 1 2 2789 3789 3806 EN2_5VX1 $T=-164520 134400 1 0 $X=-164950 $Y=129280
X62950 1 2 1907 3810 3827 EN2_5VX1 $T=-161720 179200 0 0 $X=-162150 $Y=178560
X62951 1 2 2836 3807 3888 EN2_5VX1 $T=-156120 143360 0 0 $X=-156550 $Y=142720
X62952 1 2 739 3917 3185 EN2_5VX1 $T=-146040 170240 0 180 $X=-152630 $Y=165120
X62953 1 2 2575 3908 8710 EN2_5VX1 $T=-150520 179200 1 0 $X=-150950 $Y=174080
X62954 1 2 2766 3808 3845 EN2_5VX1 $T=-143800 143360 1 180 $X=-150390 $Y=142720
X62955 1 2 8722 4004 3883 EN2_5VX1 $T=-140440 62720 0 180 $X=-147030 $Y=57600
X62956 1 2 4009 2566 3917 EN2_5VX1 $T=-137640 170240 1 180 $X=-144230 $Y=169600
X62957 1 2 9929 4005 3901 EN2_5VX1 $T=-134840 80640 0 180 $X=-141430 $Y=75520
X62958 1 2 4075 4019 3678 EN2_5VX1 $T=-129240 35840 0 180 $X=-135830 $Y=30720
X62959 1 2 4631 4744 4662 EN2_5VX1 $T=-57560 89600 1 0 $X=-57990 $Y=84480
X62960 1 2 346 340 8894 EN2_5VX1 $T=-50840 62720 0 0 $X=-51270 $Y=62080
X62961 1 2 359 363 4717 EN2_5VX1 $T=-49160 17920 0 0 $X=-49590 $Y=17280
X62962 1 2 330 4744 8889 EN2_5VX1 $T=-37960 89600 1 180 $X=-44550 $Y=88960
X62963 1 2 351 369 4788 EN2_5VX1 $T=-43000 17920 0 0 $X=-43430 $Y=17280
X62964 1 2 4740 4751 8909 EN2_5VX1 $T=-41320 179200 0 0 $X=-41750 $Y=178560
X62965 1 2 4751 326 4784 EN2_5VX1 $T=-30120 188160 0 180 $X=-36710 $Y=183040
X62966 1 2 4792 348 4842 EN2_5VX1 $T=-35720 215040 1 0 $X=-36150 $Y=209920
X62967 1 2 4824 4740 8912 EN2_5VX1 $T=-26200 170240 1 180 $X=-32790 $Y=169600
X62968 1 2 4860 362 4904 EN2_5VX1 $T=-29000 62720 0 0 $X=-29430 $Y=62080
X62969 1 2 4825 4842 4890 EN2_5VX1 $T=-28440 215040 0 0 $X=-28870 $Y=214400
X62970 1 2 8938 4923 4847 EN2_5VX1 $T=-18920 116480 1 180 $X=-25510 $Y=115840
X62971 1 2 4611 4824 9859 EN2_5VX1 $T=-15000 152320 1 180 $X=-21590 $Y=151680
X62972 1 2 346 326 4959 EN2_5VX1 $T=-9400 134400 0 180 $X=-15990 $Y=129280
X62973 1 2 339 4959 8949 EN2_5VX1 $T=-8840 125440 1 180 $X=-15430 $Y=124800
X62974 1 2 353 4611 8963 EN2_5VX1 $T=-2680 125440 1 180 $X=-9270 $Y=124800
X62975 1 2 4922 5081 8974 EN2_5VX1 $T=3480 107520 0 180 $X=-3110 $Y=102400
X62976 1 2 335 378 8995 EN2_5VX1 $T=-440 44800 0 0 $X=-870 $Y=44160
X62977 1 2 8986 5162 5108 EN2_5VX1 $T=1240 161280 0 0 $X=810 $Y=160640
X62978 1 2 323 320 9000 EN2_5VX1 $T=11880 44800 1 180 $X=5290 $Y=44160
X62979 1 2 378 4922 5180 EN2_5VX1 $T=6840 89600 1 0 $X=6410 $Y=84480
X62980 1 2 5583 5751 5640 EN2_5VX1 $T=71240 358400 0 0 $X=70810 $Y=357760
X62981 1 2 5877 5889 5907 EN2_5VX1 $T=91960 71680 1 0 $X=91530 $Y=66560
X62982 1 2 5993 339 9208 EN2_5VX1 $T=111000 62720 1 180 $X=104410 $Y=62080
X62983 1 2 353 458 6049 EN2_5VX1 $T=109320 44800 1 0 $X=108890 $Y=39680
X62984 1 2 6016 6112 6211 EN2_5VX1 $T=136200 340480 0 180 $X=129610 $Y=335360
X62985 1 2 6272 9292 6267 EN2_5VX1 $T=152440 206080 1 0 $X=152010 $Y=200960
X62986 1 2 532 563 9469 EN2_5VX1 $T=266680 26880 1 180 $X=260090 $Y=26240
X62987 1 2 542 565 7037 EN2_5VX1 $T=263320 35840 1 0 $X=262890 $Y=30720
X62988 1 2 7041 550 7094 EN2_5VX1 $T=269480 71680 1 0 $X=269050 $Y=66560
X62989 1 2 546 7041 7072 EN2_5VX1 $T=270040 53760 1 0 $X=269610 $Y=48640
X62990 1 2 9523 540 7229 EN2_5VX1 $T=301960 107520 0 0 $X=301530 $Y=106880
X62991 1 2 9539 550 9523 EN2_5VX1 $T=309240 161280 0 180 $X=302650 $Y=156160
X62992 1 2 550 545 7258 EN2_5VX1 $T=319320 170240 1 180 $X=312730 $Y=169600
X62993 1 2 523 536 7260 EN2_5VX1 $T=326040 35840 1 180 $X=319450 $Y=35200
X62994 1 2 532 7312 7322 EN2_5VX1 $T=322680 71680 1 0 $X=322250 $Y=66560
X62995 1 2 550 7479 7484 EN2_5VX1 $T=366920 116480 0 180 $X=360330 $Y=111360
X62996 1 2 7509 540 9613 EN2_5VX1 $T=371400 143360 1 180 $X=364810 $Y=142720
X62997 1 2 7504 550 7510 EN2_5VX1 $T=367480 179200 1 0 $X=367050 $Y=174080
X62998 1 2 550 540 7536 EN2_5VX1 $T=368040 116480 1 0 $X=367610 $Y=111360
X62999 1 2 7523 545 7559 EN2_5VX1 $T=375320 116480 0 0 $X=374890 $Y=115840
X63000 1 2 7599 550 9635 EN2_5VX1 $T=388200 143360 0 180 $X=381610 $Y=138240
X63001 1 2 7607 7579 7519 EN2_5VX1 $T=407800 44800 1 180 $X=401210 $Y=44160
X63002 1 2 9650 9654 7568 EN2_5VX1 $T=401640 116480 0 0 $X=401210 $Y=115840
X63003 1 2 7526 542 7617 EN2_5VX1 $T=401640 125440 0 0 $X=401210 $Y=124800
X63004 1 2 7630 9663 7594 EN2_5VX1 $T=415640 62720 0 180 $X=409050 $Y=57600
X63005 1 2 801 9663 7544 EN2_5VX1 $T=417320 53760 0 180 $X=410730 $Y=48640
X63006 1 2 533 7599 7619 EN2_5VX1 $T=419000 143360 1 180 $X=412410 $Y=142720
X63007 1 2 644 7617 7641 EN2_5VX1 $T=422920 107520 1 180 $X=416330 $Y=106880
X63008 1 2 532 9675 7608 EN2_5VX1 $T=426840 89600 1 180 $X=420250 $Y=88960
X63009 1 2 542 544 9710 EN2_5VX1 $T=457640 161280 0 180 $X=451050 $Y=156160
X63010 1 2 544 548 9711 EN2_5VX1 $T=458200 179200 0 180 $X=451610 $Y=174080
X63011 1 2 547 542 7794 EN2_5VX1 $T=469400 134400 1 180 $X=462810 $Y=133760
X63012 1 2 528 532 7800 EN2_5VX1 $T=472760 71680 1 180 $X=466170 $Y=71040
X63013 1 2 532 533 9740 EN2_5VX1 $T=472760 89600 0 180 $X=466170 $Y=84480
X63014 1 2 546 533 7808 EN2_5VX1 $T=472760 107520 0 180 $X=466170 $Y=102400
X63015 1 2 536 528 7777 EN2_5VX1 $T=473880 53760 0 180 $X=467290 $Y=48640
X63016 1 2 546 547 7785 EN2_5VX1 $T=475560 134400 0 180 $X=468970 $Y=129280
X63017 1 2 535 528 9755 EN2_5VX1 $T=476680 53760 0 0 $X=476250 $Y=53120
X63018 1 2 536 535 7849 EN2_5VX1 $T=486760 35840 0 180 $X=480170 $Y=30720
X63019 1 2 1010 1027 958 NA2_5VX1 $T=-542520 206080 0 0 $X=-542950 $Y=205440
X63020 1 2 1036 7994 9811 NA2_5VX1 $T=-533560 206080 1 0 $X=-533990 $Y=200960
X63021 1 2 1051 1036 1048 NA2_5VX1 $T=-530200 197120 0 180 $X=-533430 $Y=192000
X63022 1 2 1048 1173 1219 NA2_5VX1 $T=-503880 241920 0 180 $X=-507110 $Y=236800
X63023 1 2 958 1264 1374 NA2_5VX1 $T=-478680 250880 1 180 $X=-481910 $Y=250240
X63024 1 2 1219 1473 1436 NA2_5VX1 $T=-469720 277760 1 0 $X=-470150 $Y=272640
X63025 1 2 1441 709 1644 NA2_5VX1 $T=-440040 125440 1 0 $X=-440470 $Y=120320
X63026 1 2 709 1722 1693 NA2_5VX1 $T=-434440 116480 1 0 $X=-434870 $Y=111360
X63027 1 2 1500 8157 1715 NA2_5VX1 $T=-427720 125440 1 180 $X=-430950 $Y=124800
X63028 1 2 1680 1760 1790 NA2_5VX1 $T=-415960 268800 1 180 $X=-419190 $Y=268160
X63029 1 2 1848 1874 1864 NA2_5VX1 $T=-408120 224000 0 180 $X=-411350 $Y=218880
X63030 1 2 1644 1903 1988 NA2_5VX1 $T=-407000 143360 0 0 $X=-407430 $Y=142720
X63031 1 2 1715 1993 8248 NA2_5VX1 $T=-393560 152320 0 0 $X=-393990 $Y=151680
X63032 1 2 2096 2101 2050 NA2_5VX1 $T=-386280 206080 0 0 $X=-386710 $Y=205440
X63033 1 2 1988 2110 2094 NA2_5VX1 $T=-385720 152320 1 0 $X=-386150 $Y=147200
X63034 1 2 2118 2226 2046 NA2_5VX1 $T=-381800 206080 0 0 $X=-382230 $Y=205440
X63035 1 2 2226 715 2101 NA2_5VX1 $T=-367240 215040 0 180 $X=-370470 $Y=209920
X63036 1 2 77 2775 74 NA2_5VX1 $T=-286600 80640 0 0 $X=-287030 $Y=80000
X63037 1 2 2743 2778 2828 NA2_5VX1 $T=-282120 277760 0 180 $X=-285350 $Y=272640
X63038 1 2 2767 2774 2574 NA2_5VX1 $T=-284920 295680 1 0 $X=-285350 $Y=290560
X63039 1 2 2778 2857 2842 NA2_5VX1 $T=-278760 286720 0 0 $X=-279190 $Y=286080
X63040 1 2 132 727 77 NA2_5VX1 $T=-269240 26880 0 180 $X=-272470 $Y=21760
X63041 1 2 2828 2910 2936 NA2_5VX1 $T=-269240 331520 0 0 $X=-269670 $Y=330880
X63042 1 2 47 2888 41 NA2_5VX1 $T=-265880 80640 0 180 $X=-269110 $Y=75520
X63043 1 2 41 2967 40 NA2_5VX1 $T=-261400 53760 0 0 $X=-261830 $Y=53120
X63044 1 2 2574 8472 732 NA2_5VX1 $T=-256360 349440 1 0 $X=-256790 $Y=344320
X63045 1 2 2936 3263 3253 NA2_5VX1 $T=-222760 358400 0 0 $X=-223190 $Y=357760
X63046 1 2 3357 3313 3270 NA2_5VX1 $T=-217160 80640 0 0 $X=-217590 $Y=80000
X63047 1 2 3279 9840 8551 NA2_5VX1 $T=-217160 107520 1 0 $X=-217590 $Y=102400
X63048 1 2 8554 3283 3292 NA2_5VX1 $T=-212680 116480 1 180 $X=-215910 $Y=115840
X63049 1 2 8634 8629 3358 NA2_5VX1 $T=-180200 125440 1 180 $X=-183430 $Y=124800
X63050 1 2 3685 3747 3716 NA2_5VX1 $T=-164520 367360 0 180 $X=-167750 $Y=362240
X63051 1 2 3726 737 3744 NA2_5VX1 $T=-163400 206080 0 0 $X=-163830 $Y=205440
X63052 1 2 3770 8690 3797 NA2_5VX1 $T=-162280 215040 0 0 $X=-162710 $Y=214400
X63053 1 2 3827 9846 3809 NA2_5VX1 $T=-160600 179200 1 0 $X=-161030 $Y=174080
X63054 1 2 8679 8694 8697 NA2_5VX1 $T=-158920 161280 0 0 $X=-159350 $Y=160640
X63055 1 2 737 3859 3783 NA2_5VX1 $T=-156120 197120 0 0 $X=-156550 $Y=196480
X63056 1 2 3845 8702 3821 NA2_5VX1 $T=-155000 152320 1 0 $X=-155430 $Y=147200
X63057 1 2 3766 3828 3839 NA2_5VX1 $T=-152200 322560 0 180 $X=-155430 $Y=317440
X63058 1 2 3806 8698 3755 NA2_5VX1 $T=-151640 134400 1 180 $X=-154870 $Y=133760
X63059 1 2 3888 3941 3795 NA2_5VX1 $T=-151640 143360 1 0 $X=-152070 $Y=138240
X63060 1 2 8710 3976 3894 NA2_5VX1 $T=-146600 170240 0 0 $X=-147030 $Y=169600
X63061 1 2 3744 3977 3967 NA2_5VX1 $T=-146600 224000 1 0 $X=-147030 $Y=218880
X63062 1 2 3797 4014 4011 NA2_5VX1 $T=-139880 232960 1 0 $X=-140310 $Y=227840
X63063 1 2 3967 4079 745 NA2_5VX1 $T=-131480 232960 0 0 $X=-131910 $Y=232320
X63064 1 2 4066 4067 4137 NA2_5VX1 $T=-123640 71680 1 180 $X=-126870 $Y=71040
X63065 1 2 4135 4158 4058 NA2_5VX1 $T=-125320 304640 1 0 $X=-125750 $Y=299520
X63066 1 2 8787 9850 4158 NA2_5VX1 $T=-115240 304640 0 180 $X=-118470 $Y=299520
X63067 1 2 4080 8787 746 NA2_5VX1 $T=-113000 304640 1 180 $X=-116230 $Y=304000
X63068 1 2 359 5017 366 NA2_5VX1 $T=-10520 62720 0 0 $X=-10950 $Y=62080
X63069 1 2 351 758 353 NA2_5VX1 $T=4040 35840 1 180 $X=810 $Y=35200
X63070 1 2 362 5093 326 NA2_5VX1 $T=6840 134400 0 180 $X=3610 $Y=129280
X63071 1 2 346 5094 339 NA2_5VX1 $T=4600 152320 1 0 $X=4170 $Y=147200
X63072 1 2 761 5191 359 NA2_5VX1 $T=11880 98560 1 0 $X=11450 $Y=93440
X63073 1 2 9009 5176 5149 NA2_5VX1 $T=11880 304640 1 0 $X=11450 $Y=299520
X63074 1 2 366 5201 346 NA2_5VX1 $T=14120 134400 0 0 $X=13690 $Y=133760
X63075 1 2 5150 5156 5182 NA2_5VX1 $T=16920 331520 1 180 $X=13690 $Y=330880
X63076 1 2 5134 5188 5150 NA2_5VX1 $T=14680 295680 0 0 $X=14250 $Y=295040
X63077 1 2 5211 403 5206 NA2_5VX1 $T=15800 53760 0 0 $X=15370 $Y=53120
X63078 1 2 326 5194 348 NA2_5VX1 $T=18600 161280 0 180 $X=15370 $Y=156160
X63079 1 2 4779 5151 4951 NA2_5VX1 $T=19160 322560 0 180 $X=15930 $Y=317440
X63080 1 2 765 9009 4779 NA2_5VX1 $T=20280 295680 1 180 $X=17050 $Y=295040
X63081 1 2 4951 5197 763 NA2_5VX1 $T=21960 367360 0 180 $X=18730 $Y=362240
X63082 1 2 353 5316 366 NA2_5VX1 $T=24200 80640 1 0 $X=23770 $Y=75520
X63083 1 2 5601 5711 5565 NA2_5VX1 $T=75160 367360 1 180 $X=71930 $Y=366720
X63084 1 2 6032 6024 6048 NA2_5VX1 $T=110440 358400 1 0 $X=110010 $Y=353280
X63085 1 2 326 6179 348 NA2_5VX1 $T=123320 89600 0 0 $X=122890 $Y=88960
X63086 1 2 6280 783 6292 NA2_5VX1 $T=154120 241920 1 0 $X=153690 $Y=236800
X63087 1 2 783 6430 6398 NA2_5VX1 $T=166440 241920 1 0 $X=166010 $Y=236800
X63088 1 2 6397 6412 6449 NA2_5VX1 $T=168680 250880 0 0 $X=168250 $Y=250240
X63089 1 2 6292 790 6518 NA2_5VX1 $T=183240 268800 1 0 $X=182810 $Y=263680
X63090 1 2 6571 6570 6520 NA2_5VX1 $T=187720 358400 0 0 $X=187290 $Y=357760
X63091 1 2 6449 6560 6547 NA2_5VX1 $T=188280 277760 1 0 $X=187850 $Y=272640
X63092 1 2 6518 6622 6561 NA2_5VX1 $T=193320 268800 0 0 $X=192890 $Y=268160
X63093 1 2 6563 6672 6642 NA2_5VX1 $T=197800 349440 0 0 $X=197370 $Y=348800
X63094 1 2 6672 6690 6570 NA2_5VX1 $T=202840 349440 0 0 $X=202410 $Y=348800
X63095 1 2 550 6946 540 NA2_5VX1 $T=264440 53760 1 180 $X=261210 $Y=53120
X63096 1 2 542 9494 544 NA2_5VX1 $T=284040 62720 0 180 $X=280810 $Y=57600
X63097 1 2 547 7604 544 NA2_5VX1 $T=409480 152320 1 180 $X=406250 $Y=151680
X63098 1 2 546 642 533 NA2_5VX1 $T=417880 35840 1 0 $X=417450 $Y=30720
X63099 1 2 4026 3886 8753 3964 AO21_5VX1 $T=-135960 89600 0 0 $X=-136390 $Y=88960
X63100 1 2 4305 4223 4334 4335 AO21_5VX1 $T=-96200 125440 0 0 $X=-96630 $Y=124800
X63101 1 2 4340 4335 4368 4199 AO21_5VX1 $T=-64840 143360 1 180 $X=-70310 $Y=142720
X63102 1 2 8860 4552 4574 4470 AO21_5VX1 $T=-63720 188160 1 180 $X=-69190 $Y=187520
X63103 1 2 4685 752 4674 8896 AO21_5VX1 $T=-44120 224000 1 0 $X=-44550 $Y=218880
X63104 1 2 5053 5072 5094 8986 AO21_5VX1 $T=5160 152320 1 180 $X=-310 $Y=151680
X63105 1 2 7593 7602 7597 9650 AO21_5VX1 $T=408360 62720 0 180 $X=402890 $Y=57600
X63106 1 2 1004 1016 7958 OR2_5VX1 $T=-550920 188160 0 180 $X=-555270 $Y=183040
X63107 1 2 1167 930 1265 OR2_5VX1 $T=-506680 259840 0 0 $X=-507110 $Y=259200
X63108 1 2 930 901 1184 OR2_5VX1 $T=-502200 250880 1 180 $X=-506550 $Y=250240
X63109 1 2 1229 1167 8040 OR2_5VX1 $T=-500520 277760 0 180 $X=-504870 $Y=272640
X63110 1 2 1204 1270 8060 OR2_5VX1 $T=-487080 143360 0 180 $X=-491430 $Y=138240
X63111 1 2 1431 1379 1443 OR2_5VX1 $T=-472520 197120 1 0 $X=-472950 $Y=192000
X63112 1 2 1315 1513 1417 OR2_5VX1 $T=-462440 125440 0 180 $X=-466790 $Y=120320
X63113 1 2 1426 1431 8137 OR2_5VX1 $T=-450120 215040 1 0 $X=-450550 $Y=209920
X63114 1 2 1628 1426 1646 OR2_5VX1 $T=-441720 215040 1 0 $X=-442150 $Y=209920
X63115 1 2 40 41 8161 OR2_5VX1 $T=-428280 62720 1 180 $X=-432630 $Y=62080
X63116 1 2 1698 1603 1652 OR2_5VX1 $T=-427720 152320 1 180 $X=-432070 $Y=151680
X63117 1 2 41 47 8165 OR2_5VX1 $T=-427160 53760 0 180 $X=-431510 $Y=48640
X63118 1 2 43 40 8180 OR2_5VX1 $T=-427720 62720 0 0 $X=-428150 $Y=62080
X63119 1 2 39 43 9823 OR2_5VX1 $T=-415400 71680 1 180 $X=-419750 $Y=71040
X63120 1 2 710 1698 8207 OR2_5VX1 $T=-416520 170240 0 0 $X=-416950 $Y=169600
X63121 1 2 1764 710 8236 OR2_5VX1 $T=-392440 179200 0 180 $X=-396790 $Y=174080
X63122 1 2 2031 1764 8235 OR2_5VX1 $T=-389640 188160 0 180 $X=-393990 $Y=183040
X63123 1 2 2654 2541 2636 OR2_5VX1 $T=-300600 268800 1 180 $X=-304950 $Y=268160
X63124 1 2 2794 2657 2837 OR2_5VX1 $T=-282120 331520 0 0 $X=-282550 $Y=330880
X63125 1 2 2785 2794 8425 OR2_5VX1 $T=-267560 349440 1 180 $X=-271910 $Y=348800
X63126 1 2 2909 2665 8526 OR2_5VX1 $T=-231160 232960 1 0 $X=-231590 $Y=227840
X63127 1 2 2984 2785 3233 OR2_5VX1 $T=-216040 367360 0 180 $X=-220390 $Y=362240
X63128 1 2 3261 3255 3295 OR2_5VX1 $T=-218280 277760 0 0 $X=-218710 $Y=277120
X63129 1 2 3386 3261 3422 OR2_5VX1 $T=-202040 295680 1 0 $X=-202470 $Y=290560
X63130 1 2 2191 3434 3428 OR2_5VX1 $T=-199240 215040 1 0 $X=-199670 $Y=209920
X63131 1 2 3522 3386 3543 OR2_5VX1 $T=-189160 304640 1 0 $X=-189590 $Y=299520
X63132 1 2 736 3597 3625 OR2_5VX1 $T=-181320 250880 0 0 $X=-181750 $Y=250240
X63133 1 2 3718 736 8667 OR2_5VX1 $T=-163400 268800 0 180 $X=-167750 $Y=263680
X63134 1 2 3846 3718 3778 OR2_5VX1 $T=-149960 268800 1 180 $X=-154310 $Y=268160
X63135 1 2 3944 3846 3924 OR2_5VX1 $T=-141000 277760 0 180 $X=-145350 $Y=272640
X63136 1 2 4047 743 8753 OR2_5VX1 $T=-127000 89600 1 180 $X=-131350 $Y=88960
X63137 1 2 278 276 4061 OR2_5VX1 $T=-125320 35840 0 180 $X=-129670 $Y=30720
X63138 1 2 8816 4357 4368 OR2_5VX1 $T=-91720 143360 0 0 $X=-92150 $Y=142720
X63139 1 2 4360 4339 4334 OR2_5VX1 $T=-85000 125440 0 180 $X=-89350 $Y=120320
X63140 1 2 4520 4501 4574 OR2_5VX1 $T=-58680 188160 1 180 $X=-63030 $Y=187520
X63141 1 2 4654 4702 4674 OR2_5VX1 $T=-55320 224000 0 0 $X=-55750 $Y=223360
X63142 1 2 326 4751 8899 OR2_5VX1 $T=-42440 197120 1 0 $X=-42870 $Y=192000
X63143 1 2 4751 4740 8898 OR2_5VX1 $T=-41320 188160 1 0 $X=-41750 $Y=183040
X63144 1 2 4740 4824 8913 OR2_5VX1 $T=-29560 179200 0 180 $X=-33910 $Y=174080
X63145 1 2 4557 4834 4856 OR2_5VX1 $T=-31800 277760 0 0 $X=-32230 $Y=277120
X63146 1 2 4824 4611 4839 OR2_5VX1 $T=-21720 161280 1 180 $X=-26070 $Y=160640
X63147 1 2 4611 353 4935 OR2_5VX1 $T=-12760 143360 0 180 $X=-17110 $Y=138240
X63148 1 2 4982 4942 4923 OR2_5VX1 $T=-11640 107520 1 180 $X=-15990 $Y=106880
X63149 1 2 4922 378 8979 OR2_5VX1 $T=-5480 98560 1 0 $X=-5910 $Y=93440
X63150 1 2 353 761 5022 OR2_5VX1 $T=-440 116480 1 180 $X=-4790 $Y=115840
X63151 1 2 5026 757 8983 OR2_5VX1 $T=2920 322560 1 180 $X=-1430 $Y=321920
X63152 1 2 335 319 5112 OR2_5VX1 $T=680 44800 1 0 $X=250 $Y=39680
X63153 1 2 4857 5026 8991 OR2_5VX1 $T=6840 331520 1 180 $X=2490 $Y=330880
X63154 1 2 378 335 5164 OR2_5VX1 $T=6840 80640 1 0 $X=6410 $Y=75520
X63155 1 2 4987 4857 9945 OR2_5VX1 $T=13000 358400 0 180 $X=8650 $Y=353280
X63156 1 2 5833 5848 5874 OR2_5VX1 $T=87480 340480 0 0 $X=87050 $Y=339840
X63157 1 2 772 5766 5805 OR2_5VX1 $T=91960 250880 1 180 $X=87610 $Y=250240
X63158 1 2 5864 5847 9175 OR2_5VX1 $T=91960 304640 0 180 $X=87610 $Y=299520
X63159 1 2 5848 5864 9202 OR2_5VX1 $T=107080 313600 1 180 $X=102730 $Y=312960
X63160 1 2 6195 6146 9280 OR2_5VX1 $T=131160 241920 1 0 $X=130730 $Y=236800
X63161 1 2 6268 6349 6285 OR2_5VX1 $T=152440 304640 0 0 $X=152010 $Y=304000
X63162 1 2 6349 6224 6274 OR2_5VX1 $T=161960 295680 1 180 $X=157610 $Y=295040
X63163 1 2 6275 6268 9319 OR2_5VX1 $T=164760 322560 0 0 $X=164330 $Y=321920
X63164 1 2 6465 6275 6435 OR2_5VX1 $T=182120 331520 1 180 $X=177770 $Y=330880
X63165 1 2 9598 7487 9612 OR2_5VX1 $T=367480 80640 1 180 $X=363130 $Y=80000
X63166 1 2 9651 7571 7498 OR2_5VX1 $T=387640 161280 0 180 $X=383290 $Y=156160
X63167 1 2 548 544 9681 OR2_5VX1 $T=424600 170240 0 0 $X=424170 $Y=169600
X63168 1 2 544 542 9707 OR2_5VX1 $T=452600 170240 0 180 $X=448250 $Y=165120
X63169 1 2 547 546 9720 OR2_5VX1 $T=449800 134400 1 0 $X=449370 $Y=129280
X63170 1 2 542 547 9895 OR2_5VX1 $T=455400 152320 0 180 $X=451050 $Y=147200
X63171 1 2 532 528 9737 OR2_5VX1 $T=469960 80640 0 180 $X=465610 $Y=75520
X63172 1 2 533 532 9743 OR2_5VX1 $T=467720 98560 1 0 $X=467290 $Y=93440
X63173 1 2 533 546 7786 OR2_5VX1 $T=475000 125440 0 180 $X=470650 $Y=120320
X63174 1 2 528 535 7828 OR2_5VX1 $T=478920 62720 1 180 $X=474570 $Y=62080
X63175 1 2 535 536 9751 OR2_5VX1 $T=481720 44800 1 180 $X=477370 $Y=44160
X63176 1 2 536 523 7842 OR2_5VX1 $T=487880 26880 0 180 $X=483530 $Y=21760
X63177 1 2 1051 7978 1048 NO2_5VX1 $T=-538040 197120 1 0 $X=-538470 $Y=192000
X63178 1 2 1058 1079 9811 NO2_5VX1 $T=-533000 206080 0 0 $X=-533430 $Y=205440
X63179 1 2 1070 8001 1079 NO2_5VX1 $T=-533000 224000 1 0 $X=-533430 $Y=218880
X63180 1 2 1010 1058 958 NO2_5VX1 $T=-525720 206080 1 180 $X=-528950 $Y=205440
X63181 1 2 1112 1127 1151 NO2_5VX1 $T=-515080 322560 1 180 $X=-518310 $Y=321920
X63182 1 2 1048 1187 1219 NO2_5VX1 $T=-503880 232960 1 180 $X=-507110 $Y=232320
X63183 1 2 958 1252 1374 NO2_5VX1 $T=-483160 250880 1 180 $X=-486390 $Y=250240
X63184 1 2 1219 1459 1436 NO2_5VX1 $T=-468600 277760 0 0 $X=-469030 $Y=277120
X63185 1 2 1441 1614 1644 NO2_5VX1 $T=-445080 125440 1 0 $X=-445510 $Y=120320
X63186 1 2 1500 1697 1715 NO2_5VX1 $T=-426040 125440 0 0 $X=-426470 $Y=124800
X63187 1 2 1697 1771 1693 NO2_5VX1 $T=-424360 125440 1 0 $X=-424790 $Y=120320
X63188 1 2 8162 1832 1771 NO2_5VX1 $T=-420440 125440 1 0 $X=-420870 $Y=120320
X63189 1 2 1680 1749 1790 NO2_5VX1 $T=-417640 268800 0 180 $X=-420870 $Y=263680
X63190 1 2 1848 1814 1864 NO2_5VX1 $T=-404200 215040 1 180 $X=-407430 $Y=214400
X63191 1 2 43 51 1661 NO2_5VX1 $T=-399720 26880 0 180 $X=-402950 $Y=21760
X63192 1 2 1644 1886 1988 NO2_5VX1 $T=-401960 143360 0 0 $X=-402390 $Y=142720
X63193 1 2 1715 1976 8248 NO2_5VX1 $T=-390760 152320 1 0 $X=-391190 $Y=147200
X63194 1 2 1988 2088 2094 NO2_5VX1 $T=-386840 152320 0 0 $X=-387270 $Y=151680
X63195 1 2 40 122 43 NO2_5VX1 $T=-297240 17920 0 180 $X=-300470 $Y=12800
X63196 1 2 2658 2666 2681 NO2_5VX1 $T=-293880 385280 1 180 $X=-297110 $Y=384640
X63197 1 2 2732 2701 1661 NO2_5VX1 $T=-293320 62720 0 180 $X=-296550 $Y=57600
X63198 1 2 39 2765 1661 NO2_5VX1 $T=-289960 35840 0 180 $X=-293190 $Y=30720
X63199 1 2 2687 8391 2551 NO2_5VX1 $T=-292200 44800 1 0 $X=-292630 $Y=39680
X63200 1 2 2747 126 2732 NO2_5VX1 $T=-286600 44800 0 180 $X=-289830 $Y=39680
X63201 1 2 126 2856 122 NO2_5VX1 $T=-286600 44800 1 0 $X=-287030 $Y=39680
X63202 1 2 2743 2841 2828 NO2_5VX1 $T=-280440 277760 1 0 $X=-280870 $Y=272640
X63203 1 2 2767 2814 2574 NO2_5VX1 $T=-280440 295680 1 0 $X=-280870 $Y=290560
X63204 1 2 2814 2843 2842 NO2_5VX1 $T=-276520 295680 1 0 $X=-276950 $Y=290560
X63205 1 2 2783 2830 2843 NO2_5VX1 $T=-273720 304640 1 180 $X=-276950 $Y=304000
X63206 1 2 47 2912 40 NO2_5VX1 $T=-267560 44800 1 0 $X=-267990 $Y=39680
X63207 1 2 41 730 40 NO2_5VX1 $T=-265880 71680 1 0 $X=-266310 $Y=66560
X63208 1 2 47 2940 41 NO2_5VX1 $T=-263080 80640 0 180 $X=-266310 $Y=75520
X63209 1 2 77 728 74 NO2_5VX1 $T=-260280 80640 0 180 $X=-263510 $Y=75520
X63210 1 2 2828 8433 2936 NO2_5VX1 $T=-260280 331520 0 180 $X=-263510 $Y=326400
X63211 1 2 2574 3046 732 NO2_5VX1 $T=-259160 340480 0 0 $X=-259590 $Y=339840
X63212 1 2 2936 8555 3253 NO2_5VX1 $T=-223880 358400 1 0 $X=-224310 $Y=353280
X63213 1 2 41 216 43 NO2_5VX1 $T=-202040 44800 1 0 $X=-202470 $Y=39680
X63214 1 2 40 214 39 NO2_5VX1 $T=-194760 53760 1 180 $X=-197990 $Y=53120
X63215 1 2 39 3495 17 NO2_5VX1 $T=-193640 62720 0 0 $X=-194070 $Y=62080
X63216 1 2 3465 212 3489 NO2_5VX1 $T=-185800 80640 0 180 $X=-189030 $Y=75520
X63217 1 2 3685 8663 3716 NO2_5VX1 $T=-172360 358400 0 0 $X=-172790 $Y=357760
X63218 1 2 3726 3752 3744 NO2_5VX1 $T=-170120 206080 1 0 $X=-170550 $Y=200960
X63219 1 2 3766 8692 3839 NO2_5VX1 $T=-157800 313600 1 0 $X=-158230 $Y=308480
X63220 1 2 3770 3811 3797 NO2_5VX1 $T=-156680 215040 0 0 $X=-157110 $Y=214400
X63221 1 2 3811 3872 3783 NO2_5VX1 $T=-155000 206080 0 0 $X=-155430 $Y=205440
X63222 1 2 3889 3909 3872 NO2_5VX1 $T=-149960 206080 0 0 $X=-150390 $Y=205440
X63223 1 2 3744 3958 3967 NO2_5VX1 $T=-144920 224000 0 0 $X=-145350 $Y=223360
X63224 1 2 3797 4016 4011 NO2_5VX1 $T=-140440 224000 0 0 $X=-140870 $Y=223360
X63225 1 2 3978 8748 745 NO2_5VX1 $T=-134280 232960 0 0 $X=-134710 $Y=232320
X63226 1 2 4117 4025 8756 NO2_5VX1 $T=-128680 44800 0 180 $X=-131910 $Y=39680
X63227 1 2 4119 3989 4113 NO2_5VX1 $T=-127560 53760 0 180 $X=-130790 $Y=48640
X63228 1 2 4554 4677 4630 NO2_5VX1 $T=-59240 358400 1 0 $X=-59670 $Y=353280
X63229 1 2 346 4604 339 NO2_5VX1 $T=-43560 35840 1 180 $X=-46790 $Y=35200
X63230 1 2 326 8937 339 NO2_5VX1 $T=-13880 80640 1 180 $X=-17110 $Y=80000
X63231 1 2 326 4956 348 NO2_5VX1 $T=-6600 98560 0 180 $X=-9830 $Y=93440
X63232 1 2 351 5062 353 NO2_5VX1 $T=-7160 44800 0 0 $X=-7590 $Y=44160
X63233 1 2 339 4982 348 NO2_5VX1 $T=-4360 107520 0 180 $X=-7590 $Y=102400
X63234 1 2 359 5047 366 NO2_5VX1 $T=-6040 62720 0 0 $X=-6470 $Y=62080
X63235 1 2 362 8985 326 NO2_5VX1 $T=4600 143360 1 0 $X=4170 $Y=138240
X63236 1 2 5134 5141 5150 NO2_5VX1 $T=5720 304640 0 0 $X=5290 $Y=304000
X63237 1 2 5141 5154 5149 NO2_5VX1 $T=6280 304640 1 0 $X=5850 $Y=299520
X63238 1 2 9013 9015 5154 NO2_5VX1 $T=9080 304640 1 0 $X=8650 $Y=299520
X63239 1 2 4779 760 4951 NO2_5VX1 $T=12440 322560 1 180 $X=9210 $Y=321920
X63240 1 2 5150 9010 5182 NO2_5VX1 $T=14680 331520 0 180 $X=11450 $Y=326400
X63241 1 2 323 5183 320 NO2_5VX1 $T=12440 53760 1 0 $X=12010 $Y=48640
X63242 1 2 359 9023 362 NO2_5VX1 $T=12440 116480 0 0 $X=12010 $Y=115840
X63243 1 2 326 762 348 NO2_5VX1 $T=13000 161280 1 0 $X=12570 $Y=156160
X63244 1 2 4951 9024 763 NO2_5VX1 $T=13560 358400 0 0 $X=13130 $Y=357760
X63245 1 2 761 5228 359 NO2_5VX1 $T=16360 98560 1 0 $X=15930 $Y=93440
X63246 1 2 366 766 346 NO2_5VX1 $T=16360 134400 1 0 $X=15930 $Y=129280
X63247 1 2 320 5190 351 NO2_5VX1 $T=21960 80640 1 180 $X=18730 $Y=80000
X63248 1 2 765 5234 4779 NO2_5VX1 $T=23080 295680 1 180 $X=19850 $Y=295040
X63249 1 2 353 9058 366 NO2_5VX1 $T=36520 71680 1 180 $X=33290 $Y=71040
X63250 1 2 5601 5681 5565 NO2_5VX1 $T=67320 376320 1 0 $X=66890 $Y=371200
X63251 1 2 326 9206 339 NO2_5VX1 $T=101480 53760 0 0 $X=101050 $Y=53120
X63252 1 2 5963 5993 5992 NO2_5VX1 $T=104840 44800 0 0 $X=104410 $Y=44160
X63253 1 2 5956 5992 6199 NO2_5VX1 $T=110440 44800 1 180 $X=107210 $Y=44160
X63254 1 2 6032 9217 6048 NO2_5VX1 $T=112120 349440 1 0 $X=111690 $Y=344320
X63255 1 2 362 5963 346 NO2_5VX1 $T=115480 35840 0 180 $X=112250 $Y=30720
X63256 1 2 6011 5934 6038 NO2_5VX1 $T=118840 62720 1 180 $X=115610 $Y=62080
X63257 1 2 326 6147 348 NO2_5VX1 $T=131160 89600 1 180 $X=127930 $Y=88960
X63258 1 2 6280 6319 6292 NO2_5VX1 $T=159160 232960 0 0 $X=158730 $Y=232320
X63259 1 2 778 6367 806 NO2_5VX1 $T=161960 197120 1 0 $X=161530 $Y=192000
X63260 1 2 9292 806 6360 NO2_5VX1 $T=167000 197120 1 0 $X=166570 $Y=192000
X63261 1 2 6397 786 6449 NO2_5VX1 $T=171480 250880 0 0 $X=171050 $Y=250240
X63262 1 2 786 6482 6398 NO2_5VX1 $T=172600 250880 1 0 $X=172170 $Y=245760
X63263 1 2 6463 788 6482 NO2_5VX1 $T=176520 241920 0 0 $X=176090 $Y=241280
X63264 1 2 6292 6514 6518 NO2_5VX1 $T=179880 268800 1 0 $X=179450 $Y=263680
X63265 1 2 6449 6541 6547 NO2_5VX1 $T=183800 277760 1 0 $X=183370 $Y=272640
X63266 1 2 6518 9374 6561 NO2_5VX1 $T=197800 268800 0 0 $X=197370 $Y=268160
X63267 1 2 550 6945 540 NO2_5VX1 $T=257720 53760 1 180 $X=254490 $Y=53120
X63268 1 2 542 7089 544 NO2_5VX1 $T=299720 44800 0 180 $X=296490 $Y=39680
X63269 1 2 7216 9527 540 NO2_5VX1 $T=301960 134400 0 0 $X=301530 $Y=133760
X63270 1 2 532 594 546 NO2_5VX1 $T=315400 35840 1 0 $X=314970 $Y=30720
X63271 1 2 533 7277 547 NO2_5VX1 $T=323800 44800 1 180 $X=320570 $Y=44160
X63272 1 2 7292 599 7293 NO2_5VX1 $T=327720 44800 1 180 $X=324490 $Y=44160
X63273 1 2 9606 9597 540 NO2_5VX1 $T=350680 80640 0 0 $X=350250 $Y=80000
X63274 1 2 7495 7487 9606 NO2_5VX1 $T=363560 80640 1 180 $X=360330 $Y=80000
X63275 1 2 550 9598 545 NO2_5VX1 $T=368600 71680 1 180 $X=365370 $Y=71040
X63276 1 2 548 7511 550 NO2_5VX1 $T=375320 62720 1 180 $X=372090 $Y=62080
X63277 1 2 544 7515 548 NO2_5VX1 $T=377000 62720 0 0 $X=376570 $Y=62080
X63278 1 2 544 7545 550 NO2_5VX1 $T=404440 134400 1 180 $X=401210 $Y=133760
X63279 1 2 548 9651 545 NO2_5VX1 $T=405000 152320 1 180 $X=401770 $Y=151680
X63280 1 2 547 800 544 NO2_5VX1 $T=408360 143360 0 180 $X=405130 $Y=138240
X63281 1 2 546 7593 547 NO2_5VX1 $T=411720 35840 1 180 $X=408490 $Y=35200
X63282 1 2 536 7625 535 NO2_5VX1 $T=410600 44800 1 0 $X=410170 $Y=39680
X63283 1 2 542 7628 544 NO2_5VX1 $T=415640 107520 1 180 $X=412410 $Y=106880
X63284 1 2 532 639 533 NO2_5VX1 $T=413400 35840 1 0 $X=412970 $Y=30720
X63285 1 2 532 7634 546 NO2_5VX1 $T=413400 35840 0 0 $X=412970 $Y=35200
X63286 1 2 533 7647 547 NO2_5VX1 $T=422360 80640 0 180 $X=419130 $Y=75520
X63287 1 2 535 7668 528 NO2_5VX1 $T=421240 35840 0 0 $X=420810 $Y=35200
X63288 1 2 7627 7666 7668 NO2_5VX1 $T=421800 53760 1 0 $X=421370 $Y=48640
X63289 1 2 9894 7627 9685 NO2_5VX1 $T=434120 26880 0 180 $X=430890 $Y=21760
X63290 1 2 535 644 532 NO2_5VX1 $T=456520 35840 1 0 $X=456090 $Y=30720
X63291 1 2 528 656 533 NO2_5VX1 $T=473880 35840 0 180 $X=470650 $Y=30720
X63292 1 2 536 676 528 NO2_5VX1 $T=483960 17920 0 180 $X=480730 $Y=12800
X63293 1 2 901 1041 7983 NA2I1_5VX1 $T=-533560 224000 1 180 $X=-537910 $Y=223360
X63294 1 2 7978 7987 9811 NA2I1_5VX1 $T=-534680 188160 0 0 $X=-535110 $Y=187520
X63295 1 2 1074 1075 1082 NA2I1_5VX1 $T=-533000 224000 0 0 $X=-533430 $Y=223360
X63296 1 2 1046 1089 1075 NA2I1_5VX1 $T=-527400 232960 1 180 $X=-531750 $Y=232320
X63297 1 2 1187 1173 9813 NA2I1_5VX1 $T=-507240 241920 0 180 $X=-511590 $Y=236800
X63298 1 2 1252 1264 9919 NA2I1_5VX1 $T=-499960 250880 1 0 $X=-500390 $Y=245760
X63299 1 2 1379 1328 8065 NA2I1_5VX1 $T=-485960 170240 0 180 $X=-490310 $Y=165120
X63300 1 2 1459 1473 8110 NA2I1_5VX1 $T=-465800 268800 0 0 $X=-466230 $Y=268160
X63301 1 2 1229 1579 1509 NA2I1_5VX1 $T=-449000 286720 1 180 $X=-453350 $Y=286080
X63302 1 2 1603 1529 8129 NA2I1_5VX1 $T=-448440 143360 0 180 $X=-452790 $Y=138240
X63303 1 2 1598 1579 1617 NA2I1_5VX1 $T=-446200 295680 0 0 $X=-446630 $Y=295040
X63304 1 2 1614 1539 1693 NA2I1_5VX1 $T=-440040 116480 1 0 $X=-440470 $Y=111360
X63305 1 2 1749 1760 1719 NA2I1_5VX1 $T=-424920 268800 1 0 $X=-425350 $Y=263680
X63306 1 2 1674 1598 1802 NA2I1_5VX1 $T=-417640 295680 0 0 $X=-418070 $Y=295040
X63307 1 2 1796 1776 8208 NA2I1_5VX1 $T=-415960 125440 0 0 $X=-416390 $Y=124800
X63308 1 2 1528 1857 1776 NA2I1_5VX1 $T=-409800 134400 0 180 $X=-414150 $Y=129280
X63309 1 2 1628 1859 8203 NA2I1_5VX1 $T=-409800 232960 1 180 $X=-414150 $Y=232320
X63310 1 2 1814 1874 1880 NA2I1_5VX1 $T=-413160 215040 0 0 $X=-413590 $Y=214400
X63311 1 2 1886 1903 8223 NA2I1_5VX1 $T=-407560 143360 1 0 $X=-407990 $Y=138240
X63312 1 2 1848 1514 1931 NA2I1_5VX1 $T=-405320 224000 1 0 $X=-405750 $Y=218880
X63313 1 2 1901 711 1485 NA2I1_5VX1 $T=-400840 277760 0 180 $X=-405190 $Y=272640
X63314 1 2 1929 1859 8233 NA2I1_5VX1 $T=-402520 232960 0 0 $X=-402950 $Y=232320
X63315 1 2 1680 1491 711 NA2I1_5VX1 $T=-397480 277760 1 180 $X=-401830 $Y=277120
X63316 1 2 1976 1993 2014 NA2I1_5VX1 $T=-397480 143360 0 0 $X=-397910 $Y=142720
X63317 1 2 1956 1931 1853 NA2I1_5VX1 $T=-393560 215040 0 180 $X=-397910 $Y=209920
X63318 1 2 2031 2118 8261 NA2I1_5VX1 $T=-383480 197120 1 0 $X=-383910 $Y=192000
X63319 1 2 2088 2110 8267 NA2I1_5VX1 $T=-374520 161280 0 180 $X=-378870 $Y=156160
X63320 1 2 2069 1929 2052 NA2I1_5VX1 $T=-372280 241920 0 180 $X=-376630 $Y=236800
X63321 1 2 2657 2723 8407 NA2I1_5VX1 $T=-287720 313600 1 0 $X=-288150 $Y=308480
X63322 1 2 2863 8413 8420 NA2I1_5VX1 $T=-282120 313600 1 0 $X=-282550 $Y=308480
X63323 1 2 2825 2835 8413 NA2I1_5VX1 $T=-279880 322560 1 0 $X=-280310 $Y=317440
X63324 1 2 2841 8424 2842 NA2I1_5VX1 $T=-272040 277760 0 180 $X=-276390 $Y=272640
X63325 1 2 8433 2910 8448 NA2I1_5VX1 $T=-268680 331520 1 0 $X=-269110 $Y=326400
X63326 1 2 728 2775 2748 NA2I1_5VX1 $T=-261400 98560 0 0 $X=-261830 $Y=97920
X63327 1 2 3046 8472 9921 NA2I1_5VX1 $T=-254120 340480 0 0 $X=-254550 $Y=339840
X63328 1 2 3255 3221 3198 NA2I1_5VX1 $T=-220520 250880 1 180 $X=-224870 $Y=250240
X63329 1 2 8555 3263 8550 NA2I1_5VX1 $T=-218840 358400 1 0 $X=-219270 $Y=353280
X63330 1 2 206 208 3342 NA2I1_5VX1 $T=-212680 26880 1 0 $X=-213110 $Y=21760
X63331 1 2 2984 3330 8571 NA2I1_5VX1 $T=-210440 385280 1 0 $X=-210870 $Y=380160
X63332 1 2 3389 3330 3545 NA2I1_5VX1 $T=-195320 385280 1 0 $X=-195750 $Y=380160
X63333 1 2 3597 3504 8617 NA2I1_5VX1 $T=-182440 232960 1 180 $X=-186790 $Y=232320
X63334 1 2 3656 3389 3668 NA2I1_5VX1 $T=-166760 385280 1 180 $X=-171110 $Y=384640
X63335 1 2 8663 3747 3767 NA2I1_5VX1 $T=-168440 358400 0 0 $X=-168870 $Y=357760
X63336 1 2 3752 8668 3783 NA2I1_5VX1 $T=-165640 206080 1 0 $X=-166070 $Y=200960
X63337 1 2 3824 3861 3481 NA2I1_5VX1 $T=-156680 358400 1 0 $X=-157110 $Y=353280
X63338 1 2 3685 3206 3861 NA2I1_5VX1 $T=-156680 367360 1 0 $X=-157110 $Y=362240
X63339 1 2 8692 3828 3881 NA2I1_5VX1 $T=-154440 304640 0 0 $X=-154870 $Y=304000
X63340 1 2 2498 3902 3879 NA2I1_5VX1 $T=-151640 215040 0 0 $X=-152070 $Y=214400
X63341 1 2 3766 3746 3962 NA2I1_5VX1 $T=-150520 322560 1 0 $X=-150950 $Y=317440
X63342 1 2 3522 3979 3816 NA2I1_5VX1 $T=-146600 322560 1 180 $X=-150950 $Y=321920
X63343 1 2 3896 3879 9848 NA2I1_5VX1 $T=-146600 215040 0 0 $X=-147030 $Y=214400
X63344 1 2 3925 3962 3649 NA2I1_5VX1 $T=-141560 313600 1 180 $X=-145910 $Y=312960
X63345 1 2 3898 3979 4044 NA2I1_5VX1 $T=-143800 322560 0 0 $X=-144230 $Y=321920
X63346 1 2 3958 3977 3966 NA2I1_5VX1 $T=-137080 215040 1 180 $X=-141430 $Y=214400
X63347 1 2 4016 4014 4040 NA2I1_5VX1 $T=-137080 232960 1 0 $X=-137510 $Y=227840
X63348 1 2 8748 4079 4086 NA2I1_5VX1 $T=-133160 232960 1 0 $X=-133590 $Y=227840
X63349 1 2 3944 4080 8792 NA2I1_5VX1 $T=-116360 286720 1 0 $X=-116790 $Y=281600
X63350 1 2 4109 3898 4106 NA2I1_5VX1 $T=-112440 331520 0 180 $X=-116790 $Y=326400
X63351 1 2 326 4724 355 NA2I1_5VX1 $T=-41320 44800 0 180 $X=-45670 $Y=39680
X63352 1 2 757 4970 8961 NA2I1_5VX1 $T=-3800 313600 0 180 $X=-8150 $Y=308480
X63353 1 2 4987 5131 5158 NA2I1_5VX1 $T=4600 376320 0 0 $X=4170 $Y=375680
X63354 1 2 760 5151 5110 NA2I1_5VX1 $T=10200 322560 0 180 $X=5850 $Y=317440
X63355 1 2 9010 5156 5111 NA2I1_5VX1 $T=10760 331520 1 180 $X=6410 $Y=330880
X63356 1 2 762 5194 5162 NA2I1_5VX1 $T=13000 161280 1 180 $X=8650 $Y=160640
X63357 1 2 9027 5196 5155 NA2I1_5VX1 $T=17480 304640 1 180 $X=13130 $Y=304000
X63358 1 2 9024 5197 9923 NA2I1_5VX1 $T=13560 358400 1 0 $X=13130 $Y=353280
X63359 1 2 5172 5131 5205 NA2I1_5VX1 $T=13560 394240 0 0 $X=13130 $Y=393600
X63360 1 2 766 5201 5118 NA2I1_5VX1 $T=19160 143360 0 180 $X=14810 $Y=138240
X63361 1 2 5234 5107 5149 NA2I1_5VX1 $T=19720 286720 1 180 $X=15370 $Y=286080
X63362 1 2 4910 5262 5196 NA2I1_5VX1 $T=27000 304640 1 180 $X=22650 $Y=304000
X63363 1 2 9058 5316 5309 NA2I1_5VX1 $T=32040 71680 1 180 $X=27690 $Y=71040
X63364 1 2 5266 5172 5362 NA2I1_5VX1 $T=35400 403200 0 0 $X=34970 $Y=402560
X63365 1 2 9160 5727 9148 NA2I1_5VX1 $T=76840 376320 1 180 $X=72490 $Y=375680
X63366 1 2 5681 5711 5751 NA2I1_5VX1 $T=73480 367360 1 0 $X=73050 $Y=362240
X63367 1 2 5601 5235 5727 NA2I1_5VX1 $T=84680 376320 0 180 $X=80330 $Y=371200
X63368 1 2 5847 5951 9207 NA2I1_5VX1 $T=101480 286720 1 0 $X=101050 $Y=281600
X63369 1 2 5833 5955 9218 NA2I1_5VX1 $T=105400 367360 1 0 $X=104970 $Y=362240
X63370 1 2 6017 5955 9241 NA2I1_5VX1 $T=109880 367360 0 0 $X=109450 $Y=366720
X63371 1 2 9217 6024 6112 NA2I1_5VX1 $T=116040 349440 1 0 $X=115610 $Y=344320
X63372 1 2 6032 6009 781 NA2I1_5VX1 $T=120520 358400 1 0 $X=120090 $Y=353280
X63373 1 2 5985 6017 6025 NA2I1_5VX1 $T=122760 385280 0 0 $X=122330 $Y=384640
X63374 1 2 6144 781 6100 NA2I1_5VX1 $T=132840 340480 1 180 $X=128490 $Y=339840
X63375 1 2 6224 6153 9272 NA2I1_5VX1 $T=132840 277760 0 0 $X=132410 $Y=277120
X63376 1 2 6367 6316 9303 NA2I1_5VX1 $T=164200 206080 1 180 $X=159850 $Y=205440
X63377 1 2 6319 9312 6398 NA2I1_5VX1 $T=163640 232960 0 0 $X=163210 $Y=232320
X63378 1 2 6477 6471 9339 NA2I1_5VX1 $T=177080 259840 1 0 $X=176650 $Y=254720
X63379 1 2 6418 6501 6471 NA2I1_5VX1 $T=182120 259840 1 180 $X=177770 $Y=259200
X63380 1 2 6514 790 9351 NA2I1_5VX1 $T=183800 259840 1 0 $X=183370 $Y=254720
X63381 1 2 6541 6560 9355 NA2I1_5VX1 $T=186040 268800 1 0 $X=185610 $Y=263680
X63382 1 2 6465 6563 6511 NA2I1_5VX1 $T=190520 340480 1 180 $X=186170 $Y=339840
X63383 1 2 9374 6622 9804 NA2I1_5VX1 $T=202280 268800 0 0 $X=201850 $Y=268160
X63384 1 2 6945 6946 9470 NA2I1_5VX1 $T=257720 53760 0 0 $X=257290 $Y=53120
X63385 1 2 520 9558 7257 NA2I1_5VX1 $T=319320 35840 1 180 $X=314970 $Y=35200
X63386 1 2 536 9558 7330 NA2I1_5VX1 $T=324920 44800 1 0 $X=324490 $Y=39680
X63387 1 2 1459 1356 1534 1473 ON21_5VX1 $T=-459080 268800 0 0 $X=-459510 $Y=268160
X63388 1 2 9911 1749 1707 1760 ON21_5VX1 $T=-426040 259840 0 0 $X=-426470 $Y=259200
X63389 1 2 8175 1814 1828 1874 ON21_5VX1 $T=-418200 215040 0 0 $X=-418630 $Y=214400
X63390 1 2 8189 1829 1830 1802 ON21_5VX1 $T=-416520 286720 0 0 $X=-416950 $Y=286080
X63391 1 2 1901 8220 8225 711 ON21_5VX1 $T=-404760 268800 1 0 $X=-405190 $Y=263680
X63392 1 2 1956 1923 1978 1931 ON21_5VX1 $T=-400840 215040 0 0 $X=-401270 $Y=214400
X63393 1 2 2088 2139 2180 2110 ON21_5VX1 $T=-368920 161280 0 180 $X=-373270 $Y=156160
X63394 1 2 2196 2047 2153 2052 ON21_5VX1 $T=-370600 241920 1 0 $X=-371030 $Y=236800
X63395 1 2 8555 3144 3332 3263 ON21_5VX1 $T=-213240 358400 1 0 $X=-213670 $Y=353280
X63396 1 2 9915 8663 3722 3747 ON21_5VX1 $T=-171800 358400 1 0 $X=-172230 $Y=353280
X63397 1 2 3793 8692 738 3828 ON21_5VX1 $T=-160040 304640 0 0 $X=-160470 $Y=304000
X63398 1 2 8680 3740 3996 3668 ON21_5VX1 $T=-159480 376320 0 0 $X=-159910 $Y=375680
X63399 1 2 3824 3837 8718 3861 ON21_5VX1 $T=-150520 358400 0 0 $X=-150950 $Y=357760
X63400 1 2 3925 8723 741 3962 ON21_5VX1 $T=-139320 313600 0 0 $X=-139750 $Y=312960
X63401 1 2 8748 8772 4141 4079 ON21_5VX1 $T=-124760 232960 0 0 $X=-125190 $Y=232320
X63402 1 2 4153 4203 4210 4106 ON21_5VX1 $T=-116920 331520 0 0 $X=-117350 $Y=330880
X63403 1 2 326 4637 4631 4686 ON21_5VX1 $T=-52520 35840 1 0 $X=-52950 $Y=30720
X63404 1 2 346 4912 8938 9917 ON21_5VX1 $T=-25080 98560 1 0 $X=-25510 $Y=93440
X63405 1 2 9024 764 5306 5197 ON21_5VX1 $T=18040 358400 0 0 $X=17610 $Y=357760
X63406 1 2 5301 9033 5256 9040 ON21_5VX1 $T=27000 71680 1 180 $X=22650 $Y=71040
X63407 1 2 5440 5431 5712 5362 ON21_5VX1 $T=39880 394240 0 0 $X=39450 $Y=393600
X63408 1 2 9146 5681 5632 5711 ON21_5VX1 $T=72360 367360 0 180 $X=68010 $Y=362240
X63409 1 2 9160 5698 5774 5727 ON21_5VX1 $T=77960 376320 0 0 $X=77530 $Y=375680
X63410 1 2 9212 9217 6020 6024 ON21_5VX1 $T=107080 349440 1 0 $X=106650 $Y=344320
X63411 1 2 6144 6105 780 781 ON21_5VX1 $T=135080 358400 0 180 $X=130730 $Y=353280
X63412 1 2 9259 6114 6258 6025 ON21_5VX1 $T=133960 394240 1 0 $X=133530 $Y=389120
X63413 1 2 9374 6658 9385 6622 ON21_5VX1 $T=200600 277760 0 0 $X=200170 $Y=277120
X63414 1 2 57 53 1889 51 NO22_5VX1 $T=-409800 26880 1 0 $X=-410230 $Y=21760
X63415 1 2 2669 121 8378 2701 NO22_5VX1 $T=-301160 53760 0 0 $X=-301590 $Y=53120
X63416 1 2 8391 124 2465 2765 NO22_5VX1 $T=-291080 26880 1 180 $X=-296550 $Y=26240
X63417 1 2 2669 40 2622 2701 NO22_5VX1 $T=-286600 80640 1 180 $X=-292070 $Y=80000
X63418 1 2 126 128 2753 122 NO22_5VX1 $T=-291080 26880 0 0 $X=-291510 $Y=26240
X63419 1 2 8391 2747 2760 2765 NO22_5VX1 $T=-289960 35840 1 0 $X=-290390 $Y=30720
X63420 1 2 2961 2855 2981 2912 NO22_5VX1 $T=-260280 71680 0 0 $X=-260710 $Y=71040
X63421 1 2 2961 155 2989 2912 NO22_5VX1 $T=-258600 44800 0 0 $X=-259030 $Y=44160
X63422 1 2 212 3425 3383 214 NO22_5VX1 $T=-205400 44800 0 0 $X=-205830 $Y=44160
X63423 1 2 212 3375 3345 214 NO22_5VX1 $T=-198120 71680 1 180 $X=-203590 $Y=71040
X63424 1 2 218 3414 3395 216 NO22_5VX1 $T=-196440 62720 1 180 $X=-201910 $Y=62080
X63425 1 2 3463 222 3599 3495 NO22_5VX1 $T=-192520 53760 0 0 $X=-192950 $Y=53120
X63426 1 2 3463 3445 8612 3495 NO22_5VX1 $T=-191400 71680 0 0 $X=-191830 $Y=71040
X63427 1 2 3989 4004 4005 8734 NO22_5VX1 $T=-140440 62720 1 0 $X=-140870 $Y=57600
X63428 1 2 4025 4019 4004 4002 NO22_5VX1 $T=-134840 35840 1 180 $X=-140310 $Y=35200
X63429 1 2 4637 352 345 4604 NO22_5VX1 $T=-54760 26880 0 180 $X=-60230 $Y=21760
X63430 1 2 4637 349 4671 4604 NO22_5VX1 $T=-48040 35840 1 180 $X=-53510 $Y=35200
X63431 1 2 4912 4917 8927 8937 NO22_5VX1 $T=-23960 80640 0 0 $X=-24390 $Y=80000
X63432 1 2 8959 8953 4938 4956 NO22_5VX1 $T=-11640 98560 0 180 $X=-17110 $Y=93440
X63433 1 2 8959 4990 4931 4956 NO22_5VX1 $T=-11080 89600 1 180 $X=-16550 $Y=88960
X63434 1 2 4942 4996 4913 4982 NO22_5VX1 $T=-9400 107520 0 180 $X=-14870 $Y=102400
X63435 1 2 5153 9017 5181 9023 NO22_5VX1 $T=10200 116480 1 0 $X=9770 $Y=111360
X63436 1 2 5153 353 9019 9023 NO22_5VX1 $T=10200 125440 1 0 $X=9770 $Y=120320
X63437 1 2 5934 447 9199 9206 NO22_5VX1 $T=99240 44800 1 0 $X=98810 $Y=39680
X63438 1 2 5992 451 449 5963 NO22_5VX1 $T=107080 17920 0 180 $X=101610 $Y=12800
X63439 1 2 5992 452 5984 5963 NO22_5VX1 $T=109320 44800 0 180 $X=103850 $Y=39680
X63440 1 2 5934 5956 9213 9206 NO22_5VX1 $T=111560 53760 1 180 $X=106090 $Y=53120
X63441 1 2 9527 544 7241 9538 NO22_5VX1 $T=304200 125440 1 0 $X=303770 $Y=120320
X63442 1 2 9527 7235 9534 9538 NO22_5VX1 $T=304760 125440 0 0 $X=304330 $Y=124800
X63443 1 2 7303 596 7286 7277 NO22_5VX1 $T=323800 26880 1 180 $X=318330 $Y=26240
X63444 1 2 7303 601 600 7277 NO22_5VX1 $T=330520 26880 0 180 $X=325050 $Y=21760
X63445 1 2 599 528 7332 594 NO22_5VX1 $T=325480 35840 1 0 $X=325050 $Y=30720
X63446 1 2 7303 7292 7327 7277 NO22_5VX1 $T=335000 53760 0 180 $X=329530 $Y=48640
X63447 1 2 7454 9597 7473 7462 NO22_5VX1 $T=354600 89600 1 0 $X=354170 $Y=84480
X63448 1 2 9597 7470 7478 7462 NO22_5VX1 $T=355720 80640 0 0 $X=355290 $Y=80000
X63449 1 2 7487 7483 7454 9598 NO22_5VX1 $T=362440 71680 1 180 $X=356970 $Y=71040
X63450 1 2 7487 7519 9614 9598 NO22_5VX1 $T=371400 62720 0 180 $X=365930 $Y=57600
X63451 1 2 9628 7538 7535 7511 NO22_5VX1 $T=376440 89600 0 180 $X=370970 $Y=84480
X63452 1 2 7538 7544 9626 7511 NO22_5VX1 $T=378680 62720 0 180 $X=373210 $Y=57600
X63453 1 2 7560 7526 7497 7545 NO22_5VX1 $T=380920 134400 1 180 $X=375450 $Y=133760
X63454 1 2 7565 7560 7492 7545 NO22_5VX1 $T=381480 143360 0 180 $X=376010 $Y=138240
X63455 1 2 7576 7573 9638 7515 NO22_5VX1 $T=387640 44800 1 180 $X=382170 $Y=44160
X63456 1 2 9661 9656 7595 7628 NO22_5VX1 $T=407240 107520 1 180 $X=401770 $Y=106880
X63457 1 2 7576 7598 7644 7515 NO22_5VX1 $T=402760 89600 0 0 $X=402330 $Y=88960
X63458 1 2 7571 7605 9657 9651 NO22_5VX1 $T=407800 161280 0 180 $X=402330 $Y=156160
X63459 1 2 9658 7585 633 7593 NO22_5VX1 $T=408360 26880 1 180 $X=402890 $Y=26240
X63460 1 2 7560 7609 7614 7545 NO22_5VX1 $T=405560 134400 1 0 $X=405130 $Y=129280
X63461 1 2 9661 7627 7603 7628 NO22_5VX1 $T=412280 107520 1 180 $X=406810 $Y=106880
X63462 1 2 7636 7630 9664 7647 NO22_5VX1 $T=416200 71680 1 180 $X=410730 $Y=71040
X63463 1 2 671 668 9729 656 NO22_5VX1 $T=462680 17920 1 180 $X=457210 $Y=17280
X63464 1 2 1027 1036 1070 1058 AN21_5VX1 $T=-538600 206080 0 0 $X=-539030 $Y=205440
X63465 1 2 1219 1374 8097 1436 AN21_5VX1 $T=-473080 277760 0 0 $X=-473510 $Y=277120
X63466 1 2 8157 709 8162 1697 AN21_5VX1 $T=-435560 125440 1 0 $X=-435990 $Y=120320
X63467 1 2 49 8179 1702 51 AN21_5VX1 $T=-422680 26880 0 180 $X=-427030 $Y=21760
X63468 1 2 41 8179 8199 51 AN21_5VX1 $T=-419320 26880 1 0 $X=-419750 $Y=21760
X63469 1 2 1988 8248 2133 2094 AN21_5VX1 $T=-383480 161280 1 0 $X=-383910 $Y=156160
X63470 1 2 2774 2778 2783 2814 AN21_5VX1 $T=-286600 286720 0 0 $X=-287030 $Y=286080
X63471 1 2 136 727 8443 2866 AN21_5VX1 $T=-277080 26880 1 0 $X=-277510 $Y=21760
X63472 1 2 135 727 2953 2866 AN21_5VX1 $T=-275400 26880 0 0 $X=-275830 $Y=26240
X63473 1 2 2832 2888 2848 2940 AN21_5VX1 $T=-268120 71680 1 180 $X=-272470 $Y=71040
X63474 1 2 148 2775 2939 728 AN21_5VX1 $T=-269800 71680 1 0 $X=-270230 $Y=66560
X63475 1 2 2775 2860 2922 728 AN21_5VX1 $T=-268680 107520 0 0 $X=-269110 $Y=106880
X63476 1 2 2882 2967 3018 730 AN21_5VX1 $T=-258600 53760 0 0 $X=-259030 $Y=53120
X63477 1 2 2936 732 3290 3253 AN21_5VX1 $T=-228920 358400 0 0 $X=-229350 $Y=357760
X63478 1 2 8690 737 3889 3811 AN21_5VX1 $T=-158360 215040 1 0 $X=-158790 $Y=209920
X63479 1 2 4061 273 4019 272 AN21_5VX1 $T=-130920 35840 1 180 $X=-135270 $Y=35200
X63480 1 2 3967 4011 4102 745 AN21_5VX1 $T=-128680 232960 0 0 $X=-129110 $Y=232320
X63481 1 2 758 4860 4996 5062 AN21_5VX1 $T=-4360 53760 0 180 $X=-8710 $Y=48640
X63482 1 2 5017 8967 8962 5047 AN21_5VX1 $T=-8280 71680 1 0 $X=-8710 $Y=66560
X63483 1 2 393 5017 756 5047 AN21_5VX1 $T=1240 62720 0 180 $X=-3110 $Y=57600
X63484 1 2 395 758 391 5062 AN21_5VX1 $T=2360 17920 1 180 $X=-1990 $Y=17280
X63485 1 2 4973 5093 5039 8985 AN21_5VX1 $T=2920 143360 0 180 $X=-1430 $Y=138240
X63486 1 2 366 5094 5058 5053 AN21_5VX1 $T=2920 152320 0 180 $X=-1430 $Y=147200
X63487 1 2 9006 5094 8998 5053 AN21_5VX1 $T=10200 152320 1 180 $X=5850 $Y=151680
X63488 1 2 5113 5093 9020 8985 AN21_5VX1 $T=9080 143360 1 0 $X=8650 $Y=138240
X63489 1 2 5188 9009 9013 5141 AN21_5VX1 $T=14680 295680 1 180 $X=10330 $Y=295040
X63490 1 2 5191 5194 5209 762 AN21_5VX1 $T=14120 161280 0 0 $X=13690 $Y=160640
X63491 1 2 4951 5182 9984 763 AN21_5VX1 $T=14120 367360 0 0 $X=13690 $Y=366720
X63492 1 2 404 5191 9031 5228 AN21_5VX1 $T=23080 98560 0 180 $X=18730 $Y=93440
X63493 1 2 5218 5201 9946 766 AN21_5VX1 $T=19160 134400 0 0 $X=18730 $Y=133760
X63494 1 2 353 5201 5214 766 AN21_5VX1 $T=27000 143360 0 180 $X=22650 $Y=138240
X63495 1 2 5329 5316 5345 9058 AN21_5VX1 $T=29240 80640 1 0 $X=28810 $Y=75520
X63496 1 2 5256 5316 9067 9058 AN21_5VX1 $T=33160 71680 1 0 $X=32730 $Y=66560
X63497 1 2 6199 6179 6171 6147 AN21_5VX1 $T=131720 89600 0 180 $X=127370 $Y=84480
X63498 1 2 6412 783 6463 786 AN21_5VX1 $T=170920 241920 0 0 $X=170490 $Y=241280
X63499 1 2 6518 6547 6613 6561 AN21_5VX1 $T=189400 277760 0 0 $X=188970 $Y=277120
X63500 1 2 546 9494 7050 7089 AN21_5VX1 $T=284040 53760 0 180 $X=279690 $Y=48640
X63501 1 2 533 7604 9653 800 AN21_5VX1 $T=402200 143360 0 0 $X=401770 $Y=142720
X63502 1 2 7607 7597 7578 7593 AN21_5VX1 $T=406680 53760 0 180 $X=402330 $Y=48640
X63503 1 2 7625 7643 7649 7647 AN21_5VX1 $T=416200 62720 0 0 $X=415770 $Y=62080
X63504 1 2 638 7646 7566 639 AN21_5VX1 $T=421800 26880 1 180 $X=417450 $Y=26240
X63505 1 2 801 642 7657 641 AN21_5VX1 $T=424040 44800 0 180 $X=419690 $Y=39680
X63506 1 2 647 9674 645 7625 AN21_5VX1 $T=426280 35840 0 180 $X=421930 $Y=30720
X63507 1 2 640 9676 643 7668 AN21_5VX1 $T=427400 17920 1 180 $X=423050 $Y=17280
X63508 1 2 1151 1117 1112 1120 NO3I2_5VX1 $T=-521800 322560 1 180 $X=-526710 $Y=321920
X63509 1 2 2681 8373 2658 2644 NO3I2_5VX1 $T=-298920 394240 0 180 $X=-303830 $Y=389120
X63510 1 2 4630 4651 4554 9856 NO3I2_5VX1 $T=-63160 358400 0 180 $X=-68070 $Y=353280
X63511 1 2 1016 1004 7963 EN2_5VX0 $T=-541960 188160 0 180 $X=-548550 $Y=183040
X63512 1 2 930 901 7974 EN2_5VX0 $T=-532440 232960 1 180 $X=-539030 $Y=232320
X63513 1 2 1167 930 1116 EN2_5VX0 $T=-513400 259840 0 180 $X=-519990 $Y=254720
X63514 1 2 1229 1167 1247 EN2_5VX0 $T=-503880 268800 1 0 $X=-504310 $Y=263680
X63515 1 2 1270 1204 1240 EN2_5VX0 $T=-493240 134400 1 180 $X=-499830 $Y=133760
X63516 1 2 1376 1229 8071 EN2_5VX0 $T=-480920 268800 1 180 $X=-487510 $Y=268160
X63517 1 2 1431 1379 8080 EN2_5VX0 $T=-476440 179200 0 180 $X=-483030 $Y=174080
X63518 1 2 1513 1315 8090 EN2_5VX0 $T=-480360 125440 1 0 $X=-480790 $Y=120320
X63519 1 2 1426 1431 8109 EN2_5VX0 $T=-466920 197120 1 0 $X=-467350 $Y=192000
X63520 1 2 1598 1376 1492 EN2_5VX0 $T=-442280 277760 1 180 $X=-448870 $Y=277120
X63521 1 2 1628 1426 1567 EN2_5VX0 $T=-438920 206080 1 180 $X=-445510 $Y=205440
X63522 1 2 1698 1603 8150 EN2_5VX0 $T=-433880 152320 1 180 $X=-440470 $Y=151680
X63523 1 2 1648 1628 1671 EN2_5VX0 $T=-427160 224000 0 180 $X=-433750 $Y=218880
X63524 1 2 710 1698 8173 EN2_5VX0 $T=-422680 170240 1 180 $X=-429270 $Y=169600
X63525 1 2 1764 710 8193 EN2_5VX0 $T=-422680 170240 0 0 $X=-423110 $Y=169600
X63526 1 2 1929 1648 8196 EN2_5VX0 $T=-400840 232960 0 180 $X=-407430 $Y=227840
X63527 1 2 2031 1764 1954 EN2_5VX0 $T=-389080 179200 1 180 $X=-395670 $Y=178560
X63528 1 2 2050 2031 1955 EN2_5VX0 $T=-384600 206080 0 180 $X=-391190 $Y=200960
X63529 1 2 2541 2654 8381 EN2_5VX0 $T=-292200 268800 1 180 $X=-298790 $Y=268160
X63530 1 2 2794 2657 8399 EN2_5VX0 $T=-281000 322560 0 180 $X=-287590 $Y=317440
X63531 1 2 2856 1661 2802 EN2_5VX0 $T=-274280 62720 1 180 $X=-280870 $Y=62080
X63532 1 2 2785 2794 8419 EN2_5VX0 $T=-270360 331520 1 180 $X=-276950 $Y=330880
X63533 1 2 2872 43 729 EN2_5VX0 $T=-270920 116480 1 0 $X=-271350 $Y=111360
X63534 1 2 2984 2785 8451 EN2_5VX0 $T=-255800 349440 1 180 $X=-262390 $Y=348800
X63535 1 2 2665 2909 8521 EN2_5VX0 $T=-239000 224000 1 0 $X=-239430 $Y=218880
X63536 1 2 3261 3255 8533 EN2_5VX0 $T=-219960 268800 0 180 $X=-226550 $Y=263680
X63537 1 2 3324 2984 3182 EN2_5VX0 $T=-211000 367360 1 180 $X=-217590 $Y=366720
X63538 1 2 3386 3261 8567 EN2_5VX0 $T=-204280 295680 0 180 $X=-210870 $Y=290560
X63539 1 2 3389 3324 8564 EN2_5VX0 $T=-203160 376320 1 180 $X=-209750 $Y=375680
X63540 1 2 3434 2191 8573 EN2_5VX0 $T=-201480 215040 1 180 $X=-208070 $Y=214400
X63541 1 2 3522 3386 8609 EN2_5VX0 $T=-188040 295680 0 180 $X=-194630 $Y=290560
X63542 1 2 3584 3522 8622 EN2_5VX0 $T=-181320 313600 0 180 $X=-187910 $Y=308480
X63543 1 2 736 3597 8626 EN2_5VX0 $T=-176840 241920 0 180 $X=-183430 $Y=236800
X63544 1 2 3718 736 3676 EN2_5VX0 $T=-169000 250880 1 180 $X=-175590 $Y=250240
X63545 1 2 3846 3718 8688 EN2_5VX0 $T=-155000 268800 1 180 $X=-161590 $Y=268160
X63546 1 2 3898 3584 3786 EN2_5VX0 $T=-149400 331520 0 180 $X=-155990 $Y=326400
X63547 1 2 3944 3846 8704 EN2_5VX0 $T=-145480 277760 0 180 $X=-152070 $Y=272640
X63548 1 2 4058 3944 8729 EN2_5VX0 $T=-132600 286720 0 180 $X=-139190 $Y=281600
X63549 1 2 4873 4923 8951 EN2_5VX0 $T=-8280 116480 1 180 $X=-14870 $Y=115840
X63550 1 2 8956 346 5021 EN2_5VX0 $T=-12760 71680 0 0 $X=-13190 $Y=71040
X63551 1 2 4857 5026 8969 EN2_5VX0 $T=-11080 331520 1 0 $X=-11510 $Y=326400
X63552 1 2 4834 4557 8975 EN2_5VX0 $T=-8840 286720 1 0 $X=-9270 $Y=281600
X63553 1 2 5026 757 4979 EN2_5VX0 $T=2360 313600 0 180 $X=-4230 $Y=308480
X63554 1 2 8981 366 8993 EN2_5VX0 $T=-2120 53760 1 0 $X=-2550 $Y=48640
X63555 1 2 5069 4987 8992 EN2_5VX0 $T=-2120 367360 1 0 $X=-2550 $Y=362240
X63556 1 2 4987 4857 8987 EN2_5VX0 $T=6280 349440 1 180 $X=-310 $Y=348800
X63557 1 2 5172 5069 8996 EN2_5VX0 $T=11320 385280 1 180 $X=4730 $Y=384640
X63558 1 2 5766 772 5787 EN2_5VX0 $T=80200 250880 1 0 $X=79770 $Y=245760
X63559 1 2 5848 5864 5820 EN2_5VX0 $T=96440 313600 0 180 $X=89850 $Y=308480
X63560 1 2 5864 5847 9194 EN2_5VX0 $T=94200 295680 1 0 $X=93770 $Y=290560
X63561 1 2 5833 5848 5927 EN2_5VX0 $T=95320 322560 0 0 $X=94890 $Y=321920
X63562 1 2 6059 5833 5906 EN2_5VX0 $T=103720 349440 1 180 $X=97130 $Y=348800
X63563 1 2 6017 6059 9209 EN2_5VX0 $T=109880 349440 1 180 $X=103290 $Y=348800
X63564 1 2 6146 6195 6191 EN2_5VX0 $T=125000 241920 1 0 $X=124570 $Y=236800
X63565 1 2 6349 6224 9258 EN2_5VX0 $T=136760 295680 1 180 $X=130170 $Y=295040
X63566 1 2 6275 6268 6335 EN2_5VX0 $T=153560 313600 1 0 $X=153130 $Y=308480
X63567 1 2 6268 6349 9315 EN2_5VX0 $T=173160 322560 0 180 $X=166570 $Y=317440
X63568 1 2 6465 6275 6419 EN2_5VX0 $T=175400 331520 1 180 $X=168810 $Y=330880
X63569 1 2 6520 6465 9337 EN2_5VX0 $T=183800 349440 0 180 $X=177210 $Y=344320
X63570 1 2 6970 9470 6996 EN2_5VX0 $T=257160 53760 1 0 $X=256730 $Y=48640
X63571 1 2 9541 9891 7231 EN2_5VX0 $T=311480 179200 0 180 $X=304890 $Y=174080
X63572 1 2 7579 544 7525 EN2_5VX0 $T=387080 62720 1 180 $X=380490 $Y=62080
X63573 1 2 638 9660 7573 EN2_5VX0 $T=416200 26880 1 180 $X=409610 $Y=26240
X63574 1 2 4701 752 4741 EO2_5VX0 $T=-46920 215040 0 0 $X=-47350 $Y=214400
X63575 1 2 6022 9226 6084 EO2_5VX0 $T=111000 197120 1 0 $X=110570 $Y=192000
X63576 1 2 6222 6166 6254 EO2_5VX0 $T=131160 197120 1 0 $X=130730 $Y=192000
X63577 1 2 9736 9749 804 EO2_5VX0 $T=464920 197120 0 180 $X=458330 $Y=192000
X63578 1 2 2236 2226 2101 2427 NA22_5VX1 $T=-366680 206080 1 0 $X=-367110 $Y=200960
X63579 1 2 4134 8787 4158 4269 NA22_5VX1 $T=-117480 295680 0 0 $X=-117910 $Y=295040
X63580 1 2 6707 6672 6570 6737 NA22_5VX1 $T=207880 349440 0 0 $X=207450 $Y=348800
X63581 1 2 806 804 6309 9742 NA22_5VX1 $T=458760 197120 0 0 $X=458330 $Y=196480
X63582 1 2 806 7806 6218 7814 NA22_5VX1 $T=466040 197120 1 0 $X=465610 $Y=192000
X63583 1 2 806 805 6180 7833 NA22_5VX1 $T=468280 197120 0 0 $X=467850 $Y=196480
X63584 1 2 806 7835 6151 9761 NA22_5VX1 $T=480600 179200 0 0 $X=480170 $Y=178560
X63585 1 2 806 7840 6204 7860 NA22_5VX1 $T=485080 161280 1 0 $X=484650 $Y=156160
X63586 1 2 806 9766 6145 7867 NA22_5VX1 $T=486760 125440 0 0 $X=486330 $Y=124800
X63587 1 2 806 7864 6142 7876 NA22_5VX1 $T=487880 143360 1 0 $X=487450 $Y=138240
X63588 1 2 806 7865 5948 7883 NA22_5VX1 $T=492360 107520 0 0 $X=491930 $Y=106880
X63589 1 2 806 9780 5949 7901 NA22_5VX1 $T=500760 125440 0 0 $X=500330 $Y=124800
X63590 1 2 806 9777 9188 7908 NA22_5VX1 $T=501320 107520 0 0 $X=500890 $Y=106880
X63591 1 2 806 9781 5941 7903 NA22_5VX1 $T=501880 116480 1 0 $X=501450 $Y=111360
X63592 1 2 730 2932 2912 2940 NO3_5VX1 $T=-260280 71680 1 180 $X=-264630 $Y=71040
X63593 1 2 5312 5890 6299 6272 NO3_5VX1 $T=156920 197120 0 180 $X=152570 $Y=192000
X63594 1 2 641 7483 639 7634 NO3_5VX1 $T=418440 44800 0 180 $X=414090 $Y=39680
X63595 1 2 1356 8097 1473 1486 1498 OA211_5VX1 $T=-466360 277760 1 0 $X=-466790 $Y=272640
X63596 1 2 2139 2133 2110 9798 2330 OA211_5VX1 $T=-367240 161280 0 0 $X=-367670 $Y=160640
X63597 1 2 3144 3290 3263 8558 3323 OA211_5VX1 $T=-217160 358400 0 0 $X=-217590 $Y=357760
X63598 1 2 8772 4102 4079 4150 4063 OA211_5VX1 $T=-124760 241920 1 0 $X=-125190 $Y=236800
X63599 1 2 764 9984 5197 9043 9063 OA211_5VX1 $T=19160 367360 0 0 $X=18730 $Y=366720
X63600 1 2 6658 6613 6622 9372 9370 OA211_5VX1 $T=202280 277760 0 180 $X=196250 $Y=272640
X63601 1 2 8554 3292 3283 74 ON21_5VX4 $T=-213800 116480 0 180 $X=-223750 $Y=111360
X63602 1 2 193 196 204 206 ON21_5VX4 $T=-221080 17920 1 0 $X=-221510 $Y=12800
X63603 1 2 3279 8551 9840 77 ON21_5VX4 $T=-209880 98560 0 180 $X=-219830 $Y=93440
X63604 1 2 3357 3270 3313 132 ON21_5VX4 $T=-214360 80640 0 0 $X=-214790 $Y=80000
X63605 1 2 8634 3358 8629 47 ON21_5VX4 $T=-183000 125440 1 180 $X=-192950 $Y=124800
X63606 1 2 3827 3809 9846 1661 ON21_5VX4 $T=-154440 170240 1 180 $X=-164390 $Y=169600
X63607 1 2 8679 8697 8694 39 ON21_5VX4 $T=-153880 161280 0 180 $X=-163830 $Y=156160
X63608 1 2 3806 3755 8698 41 ON21_5VX4 $T=-157800 134400 1 0 $X=-158230 $Y=129280
X63609 1 2 3845 3821 8702 43 ON21_5VX4 $T=-155560 152320 0 0 $X=-155990 $Y=151680
X63610 1 2 3888 3795 3941 40 ON21_5VX4 $T=-141560 134400 1 180 $X=-151510 $Y=133760
X63611 1 2 8710 3894 3976 17 ON21_5VX4 $T=-144360 179200 1 0 $X=-144790 $Y=174080
X63612 1 2 319 4302 3998 4288 4362 FA_5VX4 $T=-75480 53760 0 180 $X=-98310 $Y=48640
X63613 1 2 320 4362 3920 4289 4359 FA_5VX4 $T=-75480 71680 1 180 $X=-98310 $Y=71040
X63614 1 2 350 4359 4949 4434 4469 FA_5VX4 $T=-54200 98560 1 180 $X=-77030 $Y=97920
X63615 1 2 520 512 6989 508 9379 FA_5VX4 $T=217400 35840 0 180 $X=194570 $Y=30720
X63616 1 2 523 9379 6652 6651 6701 FA_5VX4 $T=221880 44800 0 180 $X=199050 $Y=39680
X63617 1 2 528 6809 6715 6703 6757 FA_5VX4 $T=229720 89600 1 180 $X=206890 $Y=88960
X63618 1 2 532 6757 6754 6772 6796 FA_5VX4 $T=236440 125440 1 180 $X=213610 $Y=124800
X63619 1 2 536 6701 6788 6787 9431 FA_5VX4 $T=242040 71680 1 180 $X=219210 $Y=71040
X63620 1 2 533 6796 6797 6747 6839 FA_5VX4 $T=242040 143360 0 180 $X=219210 $Y=138240
X63621 1 2 535 9431 6805 6770 6809 FA_5VX4 $T=244280 80640 0 180 $X=221450 $Y=75520
X63622 1 2 542 9445 7070 9425 9438 FA_5VX4 $T=246520 161280 1 180 $X=223690 $Y=160640
X63623 1 2 544 9438 6832 6806 9440 FA_5VX4 $T=248200 170240 1 180 $X=225370 $Y=169600
X63624 1 2 545 9447 6833 9428 6869 FA_5VX4 $T=248200 188160 1 180 $X=225370 $Y=187520
X63625 1 2 546 6839 6840 6829 9439 FA_5VX4 $T=248760 152320 0 180 $X=225930 $Y=147200
X63626 1 2 547 9439 7211 9424 9445 FA_5VX4 $T=249880 161280 0 180 $X=227050 $Y=156160
X63627 1 2 548 9440 6852 9433 9446 FA_5VX4 $T=249880 179200 0 180 $X=227050 $Y=174080
X63628 1 2 550 9446 6842 9953 9447 FA_5VX4 $T=251000 188160 0 180 $X=228170 $Y=183040
X63629 1 2 842 895 888 DFRQ_5VX1 $T=-590120 224000 1 0 $X=-590550 $Y=218880
X63630 1 2 850 878 839 DFRQ_5VX1 $T=-588440 179200 0 0 $X=-588870 $Y=178560
X63631 1 2 9810 895 849 DFRQ_5VX1 $T=-587320 250880 1 0 $X=-587750 $Y=245760
X63632 1 2 861 7936 7942 DFRQ_5VX1 $T=-585640 116480 0 0 $X=-586070 $Y=115840
X63633 1 2 7935 7936 886 DFRQ_5VX1 $T=-585080 107520 0 0 $X=-585510 $Y=106880
X63634 1 2 865 878 856 DFRQ_5VX1 $T=-584520 143360 1 0 $X=-584950 $Y=138240
X63635 1 2 866 878 705 DFRQ_5VX1 $T=-584520 152320 0 0 $X=-584950 $Y=151680
X63636 1 2 867 878 7940 DFRQ_5VX1 $T=-584520 188160 1 0 $X=-584950 $Y=183040
X63637 1 2 851 878 900 DFRQ_5VX1 $T=-584520 215040 0 0 $X=-584950 $Y=214400
X63638 1 2 868 878 891 DFRQ_5VX1 $T=-583960 170240 0 0 $X=-584390 $Y=169600
X63639 1 2 847 878 906 DFRQ_5VX1 $T=-582840 197120 0 0 $X=-583270 $Y=196480
X63640 1 2 873 878 912 DFRQ_5VX1 $T=-582840 206080 0 0 $X=-583270 $Y=205440
X63641 1 2 7937 895 917 DFRQ_5VX1 $T=-582840 268800 1 0 $X=-583270 $Y=263680
X63642 1 2 872 7936 706 DFRQ_5VX1 $T=-582280 134400 0 0 $X=-582710 $Y=133760
X63643 1 2 863 895 915 DFRQ_5VX1 $T=-582280 241920 1 0 $X=-582710 $Y=236800
X63644 1 2 6 7936 7943 DFRQ_5VX1 $T=-581160 107520 1 0 $X=-581590 $Y=102400
X63645 1 2 846 878 904 DFRQ_5VX1 $T=-581160 161280 0 0 $X=-581590 $Y=160640
X63646 1 2 880 895 7941 DFRQ_5VX1 $T=-581160 232960 1 0 $X=-581590 $Y=227840
X63647 1 2 881 895 7947 DFRQ_5VX1 $T=-581160 259840 0 0 $X=-581590 $Y=259200
X63648 1 2 7 7936 7946 DFRQ_5VX1 $T=-580600 98560 0 0 $X=-581030 $Y=97920
X63649 1 2 8 7936 923 DFRQ_5VX1 $T=-580040 89600 0 0 $X=-580470 $Y=88960
X63650 1 2 897 7936 924 DFRQ_5VX1 $T=-577240 125440 1 0 $X=-577670 $Y=120320
X63651 1 2 7939 7936 902 DFRQ_5VX1 $T=-573880 116480 1 0 $X=-574310 $Y=111360
X63652 1 2 837 895 932 DFRQ_5VX1 $T=-572200 250880 1 0 $X=-572630 $Y=245760
X63653 1 2 855 878 929 DFRQ_5VX1 $T=-569400 152320 0 0 $X=-569830 $Y=151680
X63654 1 2 848 878 938 DFRQ_5VX1 $T=-569400 215040 0 0 $X=-569830 $Y=214400
X63655 1 2 925 895 957 DFRQ_5VX1 $T=-569400 241920 0 0 $X=-569830 $Y=241280
X63656 1 2 7944 7952 960 DFRQ_5VX1 $T=-568840 152320 1 0 $X=-569270 $Y=147200
X63657 1 2 7948 946 934 DFRQ_5VX1 $T=-567720 197120 0 0 $X=-568150 $Y=196480
X63658 1 2 7950 946 965 DFRQ_5VX1 $T=-567720 206080 0 0 $X=-568150 $Y=205440
X63659 1 2 936 895 944 DFRQ_5VX1 $T=-567160 268800 1 0 $X=-567590 $Y=263680
X63660 1 2 939 946 7961 DFRQ_5VX1 $T=-566040 224000 0 0 $X=-566470 $Y=223360
X63661 1 2 945 895 982 DFRQ_5VX1 $T=-564920 277760 0 0 $X=-565350 $Y=277120
X63662 1 2 892 7936 985 DFRQ_5VX1 $T=-563240 125440 0 0 $X=-563670 $Y=124800
X63663 1 2 943 946 947 DFRQ_5VX1 $T=-548680 179200 0 180 $X=-563670 $Y=174080
X63664 1 2 7957 895 962 DFRQ_5VX1 $T=-563240 268800 0 0 $X=-563670 $Y=268160
X63665 1 2 7956 1002 7969 DFRQ_5VX1 $T=-561000 98560 0 0 $X=-561430 $Y=97920
X63666 1 2 961 971 890 DFRQ_5VX1 $T=-559880 161280 0 0 $X=-560310 $Y=160640
X63667 1 2 989 7936 942 DFRQ_5VX1 $T=-544760 116480 0 180 $X=-559750 $Y=111360
X63668 1 2 845 878 956 DFRQ_5VX1 $T=-559320 134400 0 0 $X=-559750 $Y=133760
X63669 1 2 7954 971 7977 DFRQ_5VX1 $T=-558200 170240 1 0 $X=-558630 $Y=165120
X63670 1 2 967 1113 1007 DFRQ_5VX1 $T=-558200 286720 0 0 $X=-558630 $Y=286080
X63671 1 2 898 1113 1083 DFRQ_5VX1 $T=-558200 304640 1 0 $X=-558630 $Y=299520
X63672 1 2 7960 995 707 DFRQ_5VX1 $T=-557640 250880 0 0 $X=-558070 $Y=250240
X63673 1 2 7953 995 935 DFRQ_5VX1 $T=-555960 232960 0 0 $X=-556390 $Y=232320
X63674 1 2 7965 1002 1039 DFRQ_5VX1 $T=-553160 107520 1 0 $X=-553590 $Y=102400
X63675 1 2 968 7952 9962 DFRQ_5VX1 $T=-553160 134400 1 0 $X=-553590 $Y=129280
X63676 1 2 7964 7952 992 DFRQ_5VX1 $T=-553160 143360 1 0 $X=-553590 $Y=138240
X63677 1 2 862 946 1035 DFRQ_5VX1 $T=-553160 170240 0 0 $X=-553590 $Y=169600
X63678 1 2 844 971 7979 DFRQ_5VX1 $T=-552600 152320 1 0 $X=-553030 $Y=147200
X63679 1 2 874 7936 980 DFRQ_5VX1 $T=-536920 125440 0 180 $X=-551910 $Y=120320
X63680 1 2 981 995 894 DFRQ_5VX1 $T=-551480 259840 1 0 $X=-551910 $Y=254720
X63681 1 2 983 1113 994 DFRQ_5VX1 $T=-535240 286720 0 180 $X=-550230 $Y=281600
X63682 1 2 7962 995 1071 DFRQ_5VX1 $T=-549240 250880 1 0 $X=-549670 $Y=245760
X63683 1 2 1012 895 1023 DFRQ_5VX1 $T=-547560 268800 0 0 $X=-547990 $Y=268160
X63684 1 2 1032 1113 7997 DFRQ_5VX1 $T=-544760 295680 0 0 $X=-545190 $Y=295040
X63685 1 2 7975 1002 949 DFRQ_5VX1 $T=-544200 107520 0 0 $X=-544630 $Y=106880
X63686 1 2 1042 995 1000 DFRQ_5VX1 $T=-542520 241920 1 0 $X=-542950 $Y=236800
X63687 1 2 7988 995 920 DFRQ_5VX1 $T=-527960 250880 1 180 $X=-542950 $Y=250240
X63688 1 2 853 971 1110 DFRQ_5VX1 $T=-541960 143360 0 0 $X=-542390 $Y=142720
X63689 1 2 1055 1113 8004 DFRQ_5VX1 $T=-540280 313600 1 0 $X=-540710 $Y=308480
X63690 1 2 1061 1113 1090 DFRQ_5VX1 $T=-539720 286720 0 0 $X=-540150 $Y=286080
X63691 1 2 1054 7952 8000 DFRQ_5VX1 $T=-539160 125440 0 0 $X=-539590 $Y=124800
X63692 1 2 926 1113 1108 DFRQ_5VX1 $T=-538040 277760 0 0 $X=-538470 $Y=277120
X63693 1 2 7989 1161 953 DFRQ_5VX1 $T=-537480 259840 0 0 $X=-537910 $Y=259200
X63694 1 2 1047 1002 8007 DFRQ_5VX1 $T=-536360 98560 1 0 $X=-536790 $Y=93440
X63695 1 2 7991 1002 9812 DFRQ_5VX1 $T=-535240 116480 1 0 $X=-535670 $Y=111360
X63696 1 2 854 971 1135 DFRQ_5VX1 $T=-534680 188160 1 0 $X=-535110 $Y=183040
X63697 1 2 1086 1002 1104 DFRQ_5VX1 $T=-534120 107520 1 0 $X=-534550 $Y=102400
X63698 1 2 1094 1161 1106 DFRQ_5VX1 $T=-532440 277760 1 0 $X=-532870 $Y=272640
X63699 1 2 860 995 1080 DFRQ_5VX1 $T=-531880 250880 1 0 $X=-532310 $Y=245760
X63700 1 2 910 1113 8023 DFRQ_5VX1 $T=-531320 313600 0 0 $X=-531750 $Y=312960
X63701 1 2 8005 7952 8016 DFRQ_5VX1 $T=-528520 134400 1 0 $X=-528950 $Y=129280
X63702 1 2 1150 1113 1111 DFRQ_5VX1 $T=-513960 295680 1 180 $X=-528950 $Y=295040
X63703 1 2 1118 1113 8021 DFRQ_5VX1 $T=-527960 331520 1 0 $X=-528390 $Y=326400
X63704 1 2 1119 1147 1164 DFRQ_5VX1 $T=-527400 89600 0 0 $X=-527830 $Y=88960
X63705 1 2 1126 1147 8032 DFRQ_5VX1 $T=-525720 98560 0 0 $X=-526150 $Y=97920
X63706 1 2 8009 1161 1154 DFRQ_5VX1 $T=-525160 286720 0 0 $X=-525590 $Y=286080
X63707 1 2 1134 7952 8029 DFRQ_5VX1 $T=-524600 125440 0 0 $X=-525030 $Y=124800
X63708 1 2 1143 1161 1158 DFRQ_5VX1 $T=-523480 277760 0 0 $X=-523910 $Y=277120
X63709 1 2 883 1242 1200 DFRQ_5VX1 $T=-522920 179200 0 0 $X=-523350 $Y=178560
X63710 1 2 1076 1161 8035 DFRQ_5VX1 $T=-522920 259840 0 0 $X=-523350 $Y=259200
X63711 1 2 8017 1171 1217 DFRQ_5VX1 $T=-520680 116480 0 0 $X=-521110 $Y=115840
X63712 1 2 1153 1113 8036 DFRQ_5VX1 $T=-520680 304640 0 0 $X=-521110 $Y=304000
X63713 1 2 928 1161 1105 DFRQ_5VX1 $T=-519000 268800 1 0 $X=-519430 $Y=263680
X63714 1 2 877 1201 8046 DFRQ_5VX1 $T=-517880 224000 1 0 $X=-518310 $Y=218880
X63715 1 2 1077 1113 1202 DFRQ_5VX1 $T=-517320 295680 1 0 $X=-517750 $Y=290560
X63716 1 2 1183 1201 1073 DFRQ_5VX1 $T=-516200 206080 0 0 $X=-516630 $Y=205440
X63717 1 2 858 1201 1246 DFRQ_5VX1 $T=-516200 215040 0 0 $X=-516630 $Y=214400
X63718 1 2 1193 1147 8045 DFRQ_5VX1 $T=-513960 80640 1 0 $X=-514390 $Y=75520
X63719 1 2 1020 1171 1165 DFRQ_5VX1 $T=-512840 107520 0 0 $X=-513270 $Y=106880
X63720 1 2 1091 1147 8048 DFRQ_5VX1 $T=-512280 89600 0 0 $X=-512710 $Y=88960
X63721 1 2 1280 1235 1238 DFRQ_5VX1 $T=-510600 331520 1 0 $X=-511030 $Y=326400
X63722 1 2 8037 1235 8058 DFRQ_5VX1 $T=-509480 322560 1 0 $X=-509910 $Y=317440
X63723 1 2 1063 1242 8066 DFRQ_5VX1 $T=-508920 197120 1 0 $X=-509350 $Y=192000
X63724 1 2 1215 1258 1290 DFRQ_5VX1 $T=-508920 277760 0 0 $X=-509350 $Y=277120
X63725 1 2 8042 1171 8059 DFRQ_5VX1 $T=-507800 98560 0 0 $X=-508230 $Y=97920
X63726 1 2 1266 1235 1216 DFRQ_5VX1 $T=-493240 304640 0 180 $X=-508230 $Y=299520
X63727 1 2 8043 1258 8063 DFRQ_5VX1 $T=-506120 286720 0 0 $X=-506550 $Y=286080
X63728 1 2 1244 1242 922 DFRQ_5VX1 $T=-505560 206080 1 0 $X=-505990 $Y=200960
X63729 1 2 843 1201 871 DFRQ_5VX1 $T=-505560 232960 1 0 $X=-505990 $Y=227840
X63730 1 2 1239 1147 1314 DFRQ_5VX1 $T=-505000 98560 1 0 $X=-505430 $Y=93440
X63731 1 2 1255 1171 1315 DFRQ_5VX1 $T=-503320 107520 1 0 $X=-503750 $Y=102400
X63732 1 2 869 1242 1496 DFRQ_5VX1 $T=-502200 188160 1 0 $X=-502630 $Y=183040
X63733 1 2 8050 1258 1233 DFRQ_5VX1 $T=-502200 295680 0 0 $X=-502630 $Y=295040
X63734 1 2 8052 1147 9963 DFRQ_5VX1 $T=-501640 80640 0 0 $X=-502070 $Y=80000
X63735 1 2 1092 1171 1513 DFRQ_5VX1 $T=-497720 116480 0 0 $X=-498150 $Y=115840
X63736 1 2 1293 1258 1547 DFRQ_5VX1 $T=-497720 277760 1 0 $X=-498150 $Y=272640
X63737 1 2 1295 1321 1319 DFRQ_5VX1 $T=-497160 232960 0 0 $X=-497590 $Y=232320
X63738 1 2 1369 1235 1339 DFRQ_5VX1 $T=-495480 331520 1 0 $X=-495910 $Y=326400
X63739 1 2 896 1201 1384 DFRQ_5VX1 $T=-493800 206080 0 0 $X=-494230 $Y=205440
X63740 1 2 1033 1235 1377 DFRQ_5VX1 $T=-493800 313600 0 0 $X=-494230 $Y=312960
X63741 1 2 1359 1235 1301 DFRQ_5VX1 $T=-478680 304640 0 180 $X=-493670 $Y=299520
X63742 1 2 1361 1235 8064 DFRQ_5VX1 $T=-478120 313600 0 180 $X=-493110 $Y=308480
X63743 1 2 1097 1387 1268 DFRQ_5VX1 $T=-492120 80640 1 0 $X=-492550 $Y=75520
X63744 1 2 1298 1346 1465 DFRQ_5VX1 $T=-492120 152320 0 0 $X=-492550 $Y=151680
X63745 1 2 8062 1242 1394 DFRQ_5VX1 $T=-491560 197120 0 0 $X=-491990 $Y=196480
X63746 1 2 8073 1258 1335 DFRQ_5VX1 $T=-491560 286720 0 0 $X=-491990 $Y=286080
X63747 1 2 9793 8076 23 DFRQ_5VX1 $T=-491000 53760 1 0 $X=-491430 $Y=48640
X63748 1 2 870 1242 1448 DFRQ_5VX1 $T=-490440 206080 1 0 $X=-490870 $Y=200960
X63749 1 2 1253 8076 1326 DFRQ_5VX1 $T=-474200 17920 1 180 $X=-489190 $Y=17280
X63750 1 2 1383 1258 1338 DFRQ_5VX1 $T=-473080 277760 1 180 $X=-488070 $Y=277120
X63751 1 2 1354 1201 1418 DFRQ_5VX1 $T=-486520 224000 1 0 $X=-486950 $Y=218880
X63752 1 2 1345 1387 1441 DFRQ_5VX1 $T=-485400 89600 1 0 $X=-485830 $Y=84480
X63753 1 2 8091 8076 1438 DFRQ_5VX1 $T=-469720 44800 0 180 $X=-484710 $Y=39680
X63754 1 2 1381 1321 1596 DFRQ_5VX1 $T=-483720 215040 0 0 $X=-484150 $Y=214400
X63755 1 2 1416 8076 1364 DFRQ_5VX1 $T=-468600 62720 0 180 $X=-483590 $Y=57600
X63756 1 2 1277 8076 1185 DFRQ_5VX1 $T=-481480 35840 1 0 $X=-481910 $Y=30720
X63757 1 2 1393 1387 8100 DFRQ_5VX1 $T=-481480 98560 1 0 $X=-481910 $Y=93440
X63758 1 2 1209 8076 8094 DFRQ_5VX1 $T=-480920 71680 1 0 $X=-481350 $Y=66560
X63759 1 2 1390 1235 8102 DFRQ_5VX1 $T=-480920 349440 1 0 $X=-481350 $Y=344320
X63760 1 2 1406 1235 8082 DFRQ_5VX1 $T=-465800 322560 1 180 $X=-480790 $Y=321920
X63761 1 2 1026 1387 1523 DFRQ_5VX1 $T=-479240 80640 0 0 $X=-479670 $Y=80000
X63762 1 2 1404 1480 1428 DFRQ_5VX1 $T=-479240 295680 1 0 $X=-479670 $Y=290560
X63763 1 2 8099 1480 1360 DFRQ_5VX1 $T=-464120 304640 0 180 $X=-479110 $Y=299520
X63764 1 2 1449 1235 1411 DFRQ_5VX1 $T=-464120 313600 1 180 $X=-479110 $Y=312960
X63765 1 2 1410 1480 8105 DFRQ_5VX1 $T=-478120 250880 0 0 $X=-478550 $Y=250240
X63766 1 2 864 1321 8089 DFRQ_5VX1 $T=-462440 215040 0 180 $X=-477430 $Y=209920
X63767 1 2 1538 1387 1511 DFRQ_5VX1 $T=-474760 80640 1 0 $X=-475190 $Y=75520
X63768 1 2 1156 1171 1500 DFRQ_5VX1 $T=-474760 107520 1 0 $X=-475190 $Y=102400
X63769 1 2 1186 1387 33 DFRQ_5VX1 $T=-473080 71680 0 0 $X=-473510 $Y=71040
X63770 1 2 1490 1321 1419 DFRQ_5VX1 $T=-457400 224000 0 180 $X=-472390 $Y=218880
X63771 1 2 1495 1235 1454 DFRQ_5VX1 $T=-457400 331520 0 180 $X=-472390 $Y=326400
X63772 1 2 1542 1321 1344 DFRQ_5VX1 $T=-471400 232960 1 0 $X=-471830 $Y=227840
X63773 1 2 8112 1480 1397 DFRQ_5VX1 $T=-455720 295680 1 180 $X=-470710 $Y=295040
X63774 1 2 1476 1713 8123 DFRQ_5VX1 $T=-468040 322560 1 0 $X=-468470 $Y=317440
X63775 1 2 1477 1346 8124 DFRQ_5VX1 $T=-467480 143360 0 0 $X=-467910 $Y=142720
X63776 1 2 1479 1321 1507 DFRQ_5VX1 $T=-467480 241920 1 0 $X=-467910 $Y=236800
X63777 1 2 905 1346 1528 DFRQ_5VX1 $T=-466360 134400 0 0 $X=-466790 $Y=133760
X63778 1 2 1494 1713 1510 DFRQ_5VX1 $T=-466360 313600 1 0 $X=-466790 $Y=308480
X63779 1 2 997 1713 8127 DFRQ_5VX1 $T=-465800 349440 1 0 $X=-466230 $Y=344320
X63780 1 2 8115 1480 1637 DFRQ_5VX1 $T=-464120 304640 1 0 $X=-464550 $Y=299520
X63781 1 2 1508 1480 8136 DFRQ_5VX1 $T=-463560 250880 0 0 $X=-463990 $Y=250240
X63782 1 2 8120 1713 1600 DFRQ_5VX1 $T=-462440 331520 0 0 $X=-462870 $Y=330880
X63783 1 2 8117 1346 8141 DFRQ_5VX1 $T=-461880 161280 1 0 $X=-462310 $Y=156160
X63784 1 2 1100 1552 1603 DFRQ_5VX1 $T=-459080 161280 0 0 $X=-459510 $Y=160640
X63785 1 2 1123 1552 8140 DFRQ_5VX1 $T=-457960 170240 0 0 $X=-458390 $Y=169600
X63786 1 2 1549 1573 1608 DFRQ_5VX1 $T=-456840 224000 0 0 $X=-457270 $Y=223360
X63787 1 2 893 1346 1626 DFRQ_5VX1 $T=-454600 152320 0 0 $X=-455030 $Y=151680
X63788 1 2 1466 1573 9821 DFRQ_5VX1 $T=-454040 259840 0 0 $X=-454470 $Y=259200
X63789 1 2 8132 1346 1644 DFRQ_5VX1 $T=-453480 152320 1 0 $X=-453910 $Y=147200
X63790 1 2 1574 1573 1514 DFRQ_5VX1 $T=-453480 232960 1 0 $X=-453910 $Y=227840
X63791 1 2 1577 1573 1610 DFRQ_5VX1 $T=-452920 241920 1 0 $X=-453350 $Y=236800
X63792 1 2 1170 1387 1223 DFRQ_5VX1 $T=-452360 89600 0 0 $X=-452790 $Y=88960
X63793 1 2 1583 1713 1599 DFRQ_5VX1 $T=-452360 313600 0 0 $X=-452790 $Y=312960
X63794 1 2 1589 1713 1594 DFRQ_5VX1 $T=-451800 304640 0 0 $X=-452230 $Y=304000
X63795 1 2 8135 1713 1618 DFRQ_5VX1 $T=-451800 322560 0 0 $X=-452230 $Y=321920
X63796 1 2 1604 1713 1501 DFRQ_5VX1 $T=-436120 340480 0 180 $X=-451110 $Y=335360
X63797 1 2 1008 1822 1677 DFRQ_5VX1 $T=-447880 98560 0 0 $X=-448310 $Y=97920
X63798 1 2 1669 1573 1716 DFRQ_5VX1 $T=-447880 250880 1 0 $X=-448310 $Y=245760
X63799 1 2 9822 1552 8143 DFRQ_5VX1 $T=-431080 170240 0 180 $X=-446070 $Y=165120
X63800 1 2 1639 1552 1698 DFRQ_5VX1 $T=-443400 170240 0 0 $X=-443830 $Y=169600
X63801 1 2 1664 1552 1694 DFRQ_5VX1 $T=-441160 188160 1 0 $X=-441590 $Y=183040
X63802 1 2 8156 1835 8177 DFRQ_5VX1 $T=-439480 304640 1 0 $X=-439910 $Y=299520
X63803 1 2 1794 1573 1550 DFRQ_5VX1 $T=-438360 241920 1 0 $X=-438790 $Y=236800
X63804 1 2 1690 1835 1750 DFRQ_5VX1 $T=-437800 322560 1 0 $X=-438230 $Y=317440
X63805 1 2 1705 1713 1768 DFRQ_5VX1 $T=-436120 331520 0 0 $X=-436550 $Y=330880
X63806 1 2 1741 1713 1623 DFRQ_5VX1 $T=-421560 340480 0 180 $X=-436550 $Y=335360
X63807 1 2 1724 1730 1747 DFRQ_5VX1 $T=-434440 197120 1 0 $X=-434870 $Y=192000
X63808 1 2 859 1552 1715 DFRQ_5VX1 $T=-433880 161280 1 0 $X=-434310 $Y=156160
X63809 1 2 1726 1552 710 DFRQ_5VX1 $T=-432200 179200 1 0 $X=-432630 $Y=174080
X63810 1 2 1712 1835 1629 DFRQ_5VX1 $T=-432200 313600 0 0 $X=-432630 $Y=312960
X63811 1 2 1294 1822 1278 DFRQ_5VX1 $T=-415400 98560 1 180 $X=-430390 $Y=97920
X63812 1 2 1757 1835 8201 DFRQ_5VX1 $T=-429400 304640 0 0 $X=-429830 $Y=304000
X63813 1 2 8181 1730 1696 DFRQ_5VX1 $T=-428840 179200 0 0 $X=-429270 $Y=178560
X63814 1 2 1787 2189 8202 DFRQ_5VX1 $T=-424360 143360 1 0 $X=-424790 $Y=138240
X63815 1 2 1833 1730 1764 DFRQ_5VX1 $T=-409800 188160 1 180 $X=-424790 $Y=187520
X63816 1 2 1851 1822 8185 DFRQ_5VX1 $T=-407560 107520 1 180 $X=-422550 $Y=106880
X63817 1 2 1807 1730 8210 DFRQ_5VX1 $T=-421560 224000 0 0 $X=-421990 $Y=223360
X63818 1 2 8194 1835 1885 DFRQ_5VX1 $T=-421560 322560 1 0 $X=-421990 $Y=317440
X63819 1 2 1896 1835 8197 DFRQ_5VX1 $T=-403080 313600 0 180 $X=-418070 $Y=308480
X63820 1 2 1937 1919 1848 DFRQ_5VX1 $T=-396920 286720 1 180 $X=-411910 $Y=286080
X63821 1 2 1938 1835 1865 DFRQ_5VX1 $T=-396920 295680 1 180 $X=-411910 $Y=295040
X63822 1 2 1067 1822 9964 DFRQ_5VX1 $T=-409800 125440 1 0 $X=-410230 $Y=120320
X63823 1 2 8217 1730 1989 DFRQ_5VX1 $T=-409800 188160 0 0 $X=-410230 $Y=187520
X63824 1 2 1125 1822 1967 DFRQ_5VX1 $T=-409240 116480 1 0 $X=-409670 $Y=111360
X63825 1 2 1910 2189 1988 DFRQ_5VX1 $T=-409240 152320 1 0 $X=-409670 $Y=147200
X63826 1 2 1970 1919 2007 DFRQ_5VX1 $T=-403080 304640 0 0 $X=-403510 $Y=304000
X63827 1 2 2027 1730 8228 DFRQ_5VX1 $T=-386280 197120 0 180 $X=-401270 $Y=192000
X63828 1 2 2107 2189 8248 DFRQ_5VX1 $T=-400280 161280 1 0 $X=-400710 $Y=156160
X63829 1 2 2051 2223 8232 DFRQ_5VX1 $T=-384040 232960 0 180 $X=-399030 $Y=227840
X63830 1 2 2017 1919 9965 DFRQ_5VX1 $T=-396920 286720 0 0 $X=-397350 $Y=286080
X63831 1 2 1254 2189 1317 DFRQ_5VX1 $T=-381240 134400 0 180 $X=-396230 $Y=129280
X63832 1 2 2043 1822 1013 DFRQ_5VX1 $T=-380120 107520 0 180 $X=-395110 $Y=102400
X63833 1 2 2033 2223 2031 DFRQ_5VX1 $T=-393560 224000 1 0 $X=-393990 $Y=218880
X63834 1 2 2040 1919 2097 DFRQ_5VX1 $T=-393560 286720 1 0 $X=-393990 $Y=281600
X63835 1 2 2090 1919 1979 DFRQ_5VX1 $T=-390200 277760 1 0 $X=-390630 $Y=272640
X63836 1 2 2141 2103 2050 DFRQ_5VX1 $T=-374520 224000 1 180 $X=-389510 $Y=223360
X63837 1 2 2098 1919 1864 DFRQ_5VX1 $T=-388520 295680 0 0 $X=-388950 $Y=295040
X63838 1 2 2166 2103 8254 DFRQ_5VX1 $T=-370600 268800 1 180 $X=-385590 $Y=268160
X63839 1 2 2152 2189 1892 DFRQ_5VX1 $T=-381240 125440 0 0 $X=-381670 $Y=124800
X63840 1 2 2077 2103 8286 DFRQ_5VX1 $T=-379000 277760 0 0 $X=-379430 $Y=277120
X63841 1 2 2188 2103 8294 DFRQ_5VX1 $T=-378440 286720 1 0 $X=-378870 $Y=281600
X63842 1 2 2190 2103 2046 DFRQ_5VX1 $T=-362760 250880 1 180 $X=-377750 $Y=250240
X63843 1 2 2197 2223 2167 DFRQ_5VX1 $T=-376760 224000 1 0 $X=-377190 $Y=218880
X63844 1 2 2143 2345 2112 DFRQ_5VX1 $T=-376200 152320 0 0 $X=-376630 $Y=151680
X63845 1 2 2159 2223 717 DFRQ_5VX1 $T=-376200 179200 0 0 $X=-376630 $Y=178560
X63846 1 2 2161 2103 2243 DFRQ_5VX1 $T=-376200 232960 1 0 $X=-376630 $Y=227840
X63847 1 2 93 90 8284 DFRQ_5VX1 $T=-333640 17920 0 180 $X=-348630 $Y=12800
X63848 1 2 2250 2342 9966 DFRQ_5VX1 $T=-348200 26880 1 0 $X=-348630 $Y=21760
X63849 1 2 2365 2342 2219 DFRQ_5VX1 $T=-333640 53760 0 180 $X=-348630 $Y=48640
X63850 1 2 2366 2342 1642 DFRQ_5VX1 $T=-333640 62720 1 180 $X=-348630 $Y=62080
X63851 1 2 2276 2336 8318 DFRQ_5VX1 $T=-348200 71680 1 0 $X=-348630 $Y=66560
X63852 1 2 2367 2336 1351 DFRQ_5VX1 $T=-333640 80640 0 180 $X=-348630 $Y=75520
X63853 1 2 89 2344 8315 DFRQ_5VX1 $T=-348200 98560 0 0 $X=-348630 $Y=97920
X63854 1 2 2320 2345 8316 DFRQ_5VX1 $T=-348200 152320 1 0 $X=-348630 $Y=147200
X63855 1 2 1018 1713 2316 DFRQ_5VX1 $T=-348200 268800 0 0 $X=-348630 $Y=268160
X63856 1 2 8301 1713 2308 DFRQ_5VX1 $T=-348200 277760 0 0 $X=-348630 $Y=277120
X63857 1 2 2229 2342 8285 DFRQ_5VX1 $T=-333080 35840 0 180 $X=-348070 $Y=30720
X63858 1 2 2230 2342 1641 DFRQ_5VX1 $T=-347640 44800 1 0 $X=-348070 $Y=39680
X63859 1 2 1826 2359 8321 DFRQ_5VX1 $T=-347640 232960 1 0 $X=-348070 $Y=227840
X63860 1 2 1287 2342 8291 DFRQ_5VX1 $T=-332520 44800 1 180 $X=-347510 $Y=44160
X63861 1 2 1189 2336 2405 DFRQ_5VX1 $T=-347080 98560 1 0 $X=-347510 $Y=93440
X63862 1 2 2242 2344 95 DFRQ_5VX1 $T=-347080 107520 0 0 $X=-347510 $Y=106880
X63863 1 2 1773 2345 9967 DFRQ_5VX1 $T=-347080 143360 0 0 $X=-347510 $Y=142720
X63864 1 2 2338 2223 2094 DFRQ_5VX1 $T=-347080 215040 1 0 $X=-347510 $Y=209920
X63865 1 2 8303 2359 2215 DFRQ_5VX1 $T=-347080 259840 1 0 $X=-347510 $Y=254720
X63866 1 2 2327 2359 2401 DFRQ_5VX1 $T=-347080 304640 0 0 $X=-347510 $Y=304000
X63867 1 2 2204 2359 2402 DFRQ_5VX1 $T=-347080 313600 0 0 $X=-347510 $Y=312960
X63868 1 2 2337 2336 98 DFRQ_5VX1 $T=-345960 89600 1 0 $X=-346390 $Y=84480
X63869 1 2 2086 2344 2432 DFRQ_5VX1 $T=-345960 116480 0 0 $X=-346390 $Y=115840
X63870 1 2 2010 2359 2295 DFRQ_5VX1 $T=-345960 331520 1 0 $X=-346390 $Y=326400
X63871 1 2 92 2345 8332 DFRQ_5VX1 $T=-345400 125440 0 0 $X=-345830 $Y=124800
X63872 1 2 2351 2359 2210 DFRQ_5VX1 $T=-344840 286720 1 0 $X=-345270 $Y=281600
X63873 1 2 2354 2344 1738 DFRQ_5VX1 $T=-343720 125440 1 0 $X=-344150 $Y=120320
X63874 1 2 2357 2359 2070 DFRQ_5VX1 $T=-343720 295680 1 0 $X=-344150 $Y=290560
X63875 1 2 1197 2345 2473 DFRQ_5VX1 $T=-340920 134400 0 0 $X=-341350 $Y=133760
X63876 1 2 2251 2345 1793 DFRQ_5VX1 $T=-340920 143360 1 0 $X=-341350 $Y=138240
X63877 1 2 2383 2359 2300 DFRQ_5VX1 $T=-340920 259840 0 0 $X=-341350 $Y=259200
X63878 1 2 2381 2342 101 DFRQ_5VX1 $T=-340360 26880 0 0 $X=-340790 $Y=26240
X63879 1 2 951 2359 2441 DFRQ_5VX1 $T=-339800 241920 0 0 $X=-340230 $Y=241280
X63880 1 2 2416 2359 9985 DFRQ_5VX1 $T=-339240 304640 1 0 $X=-339670 $Y=299520
X63881 1 2 2394 2359 2493 DFRQ_5VX1 $T=-338680 340480 1 0 $X=-339110 $Y=335360
X63882 1 2 9800 2344 2445 DFRQ_5VX1 $T=-338120 116480 1 0 $X=-338550 $Y=111360
X63883 1 2 2407 2359 2301 DFRQ_5VX1 $T=-337560 322560 0 0 $X=-337990 $Y=321920
X63884 1 2 2421 2475 2284 DFRQ_5VX1 $T=-336440 313600 1 0 $X=-336870 $Y=308480
X63885 1 2 2430 2475 2333 DFRQ_5VX1 $T=-335880 340480 0 0 $X=-336310 $Y=339840
X63886 1 2 8323 2475 8341 DFRQ_5VX1 $T=-335320 232960 0 0 $X=-335750 $Y=232320
X63887 1 2 8327 2475 2532 DFRQ_5VX1 $T=-334200 277760 1 0 $X=-334630 $Y=272640
X63888 1 2 1824 2475 2303 DFRQ_5VX1 $T=-334200 358400 0 0 $X=-334630 $Y=357760
X63889 1 2 2495 2336 8277 DFRQ_5VX1 $T=-319080 71680 0 180 $X=-334070 $Y=66560
X63890 1 2 2129 2336 8343 DFRQ_5VX1 $T=-333640 80640 1 0 $X=-334070 $Y=75520
X63891 1 2 8288 2344 109 DFRQ_5VX1 $T=-332520 107520 1 0 $X=-332950 $Y=102400
X63892 1 2 105 2336 1634 DFRQ_5VX1 $T=-317400 80640 1 180 $X=-332390 $Y=80000
X63893 1 2 8330 2475 2559 DFRQ_5VX1 $T=-331960 232960 1 0 $X=-332390 $Y=227840
X63894 1 2 2343 2336 110 DFRQ_5VX1 $T=-331400 89600 0 0 $X=-331830 $Y=88960
X63895 1 2 1305 2344 111 DFRQ_5VX1 $T=-331400 107520 0 0 $X=-331830 $Y=106880
X63896 1 2 2369 2475 2514 DFRQ_5VX1 $T=-331400 250880 0 0 $X=-331830 $Y=250240
X63897 1 2 2282 2475 2561 DFRQ_5VX1 $T=-328040 277760 0 0 $X=-328470 $Y=277120
X63898 1 2 2113 2475 2515 DFRQ_5VX1 $T=-328040 286720 1 0 $X=-328470 $Y=281600
X63899 1 2 2466 2529 8356 DFRQ_5VX1 $T=-327480 161280 1 0 $X=-327910 $Y=156160
X63900 1 2 1654 2475 2568 DFRQ_5VX1 $T=-327480 376320 1 0 $X=-327910 $Y=371200
X63901 1 2 2500 2475 2560 DFRQ_5VX1 $T=-326920 250880 1 0 $X=-327350 $Y=245760
X63902 1 2 2106 2475 2525 DFRQ_5VX1 $T=-326920 268800 1 0 $X=-327350 $Y=263680
X63903 1 2 2264 2529 1493 DFRQ_5VX1 $T=-326360 161280 0 0 $X=-326790 $Y=160640
X63904 1 2 2508 2698 2563 DFRQ_5VX1 $T=-326360 295680 0 0 $X=-326790 $Y=295040
X63905 1 2 107 8345 1320 DFRQ_5VX1 $T=-325800 125440 0 0 $X=-326230 $Y=124800
X63906 1 2 1609 2529 1636 DFRQ_5VX1 $T=-325800 152320 1 0 $X=-326230 $Y=147200
X63907 1 2 2024 2529 2598 DFRQ_5VX1 $T=-325800 170240 0 0 $X=-326230 $Y=169600
X63908 1 2 2513 2698 2524 DFRQ_5VX1 $T=-324120 215040 0 0 $X=-324550 $Y=214400
X63909 1 2 2364 2552 2606 DFRQ_5VX1 $T=-323560 322560 1 0 $X=-323990 $Y=317440
X63910 1 2 1856 2529 1520 DFRQ_5VX1 $T=-323000 143360 1 0 $X=-323430 $Y=138240
X63911 1 2 8353 2698 2503 DFRQ_5VX1 $T=-308440 241920 0 180 $X=-323430 $Y=236800
X63912 1 2 2162 2552 2593 DFRQ_5VX1 $T=-323000 304640 0 0 $X=-323430 $Y=304000
X63913 1 2 2516 2552 2564 DFRQ_5VX1 $T=-323000 340480 1 0 $X=-323430 $Y=335360
X63914 1 2 2116 8345 116 DFRQ_5VX1 $T=-322440 125440 1 0 $X=-322870 $Y=120320
X63915 1 2 2496 2698 8364 DFRQ_5VX1 $T=-321880 215040 1 0 $X=-322310 $Y=209920
X63916 1 2 1660 2652 8367 DFRQ_5VX1 $T=-321880 376320 0 0 $X=-322310 $Y=375680
X63917 1 2 2406 2529 1544 DFRQ_5VX1 $T=-321320 170240 1 0 $X=-321750 $Y=165120
X63918 1 2 2255 2529 2605 DFRQ_5VX1 $T=-321320 179200 1 0 $X=-321750 $Y=174080
X63919 1 2 2388 2552 2651 DFRQ_5VX1 $T=-320760 349440 0 0 $X=-321190 $Y=348800
X63920 1 2 2537 2552 2587 DFRQ_5VX1 $T=-320200 331520 1 0 $X=-320630 $Y=326400
X63921 1 2 2507 2698 2573 DFRQ_5VX1 $T=-319640 224000 0 0 $X=-320070 $Y=223360
X63922 1 2 2509 2552 2583 DFRQ_5VX1 $T=-319640 358400 0 0 $X=-320070 $Y=357760
X63923 1 2 8354 2626 2571 DFRQ_5VX1 $T=-316280 250880 0 0 $X=-316710 $Y=250240
X63924 1 2 8355 2552 2677 DFRQ_5VX1 $T=-315720 367360 0 0 $X=-316150 $Y=366720
X63925 1 2 8357 2614 2398 DFRQ_5VX1 $T=-313480 277760 0 0 $X=-313910 $Y=277120
X63926 1 2 8360 2626 2420 DFRQ_5VX1 $T=-312360 268800 1 0 $X=-312790 $Y=263680
X63927 1 2 8361 2652 2634 DFRQ_5VX1 $T=-312360 376320 1 0 $X=-312790 $Y=371200
X63928 1 2 8359 2626 2221 DFRQ_5VX1 $T=-311800 250880 1 0 $X=-312230 $Y=245760
X63929 1 2 8365 2614 2543 DFRQ_5VX1 $T=-310680 286720 0 0 $X=-311110 $Y=286080
X63930 1 2 8366 2614 2728 DFRQ_5VX1 $T=-310680 295680 0 0 $X=-311110 $Y=295040
X63931 1 2 2619 2552 8382 DFRQ_5VX1 $T=-310120 340480 0 0 $X=-310550 $Y=339840
X63932 1 2 2625 2698 2705 DFRQ_5VX1 $T=-309560 206080 1 0 $X=-309990 $Y=200960
X63933 1 2 8368 2698 8385 DFRQ_5VX1 $T=-309560 215040 0 0 $X=-309990 $Y=214400
X63934 1 2 8369 2614 2199 DFRQ_5VX1 $T=-309560 313600 1 0 $X=-309990 $Y=308480
X63935 1 2 2809 2652 8388 DFRQ_5VX1 $T=-309000 403200 1 0 $X=-309430 $Y=398080
X63936 1 2 724 3104 8383 DFRQ_5VX1 $T=-308440 403200 0 0 $X=-308870 $Y=402560
X63937 1 2 8370 2626 2630 DFRQ_5VX1 $T=-307880 241920 1 0 $X=-308310 $Y=236800
X63938 1 2 8379 2552 2477 DFRQ_5VX1 $T=-293320 340480 0 180 $X=-308310 $Y=335360
X63939 1 2 2653 2626 8390 DFRQ_5VX1 $T=-305640 241920 0 0 $X=-306070 $Y=241280
X63940 1 2 2664 2698 2686 DFRQ_5VX1 $T=-305080 224000 0 0 $X=-305510 $Y=223360
X63941 1 2 8371 2614 2352 DFRQ_5VX1 $T=-303960 322560 0 0 $X=-304390 $Y=321920
X63942 1 2 2675 2614 2740 DFRQ_5VX1 $T=-303400 322560 1 0 $X=-303830 $Y=317440
X63943 1 2 2395 2552 2676 DFRQ_5VX1 $T=-303400 358400 1 0 $X=-303830 $Y=353280
X63944 1 2 3025 2698 2716 DFRQ_5VX1 $T=-301720 197120 0 0 $X=-302150 $Y=196480
X63945 1 2 2690 2626 2649 DFRQ_5VX1 $T=-301720 250880 0 0 $X=-302150 $Y=250240
X63946 1 2 2691 2626 2763 DFRQ_5VX1 $T=-301720 259840 1 0 $X=-302150 $Y=254720
X63947 1 2 2384 2552 2752 DFRQ_5VX1 $T=-301160 367360 1 0 $X=-301590 $Y=362240
X63948 1 2 2248 2754 2771 DFRQ_5VX1 $T=-300600 179200 0 0 $X=-301030 $Y=178560
X63949 1 2 2707 2733 2114 DFRQ_5VX1 $T=-300040 331520 0 0 $X=-300470 $Y=330880
X63950 1 2 2464 2552 8397 DFRQ_5VX1 $T=-298920 367360 0 0 $X=-299350 $Y=366720
X63951 1 2 2722 2698 2782 DFRQ_5VX1 $T=-297800 215040 1 0 $X=-298230 $Y=209920
X63952 1 2 2171 2754 2789 DFRQ_5VX1 $T=-296680 170240 0 0 $X=-297110 $Y=169600
X63953 1 2 2446 2762 2798 DFRQ_5VX1 $T=-295560 143360 1 0 $X=-295990 $Y=138240
X63954 1 2 2520 2762 3220 DFRQ_5VX1 $T=-295560 143360 0 0 $X=-295990 $Y=142720
X63955 1 2 2737 2754 2799 DFRQ_5VX1 $T=-295560 197120 1 0 $X=-295990 $Y=192000
X63956 1 2 2447 2762 2803 DFRQ_5VX1 $T=-295000 152320 0 0 $X=-295430 $Y=151680
X63957 1 2 2253 2762 2804 DFRQ_5VX1 $T=-295000 161280 1 0 $X=-295430 $Y=156160
X63958 1 2 8392 2840 2749 DFRQ_5VX1 $T=-295000 232960 0 0 $X=-295430 $Y=232320
X63959 1 2 2735 2840 8412 DFRQ_5VX1 $T=-294440 224000 1 0 $X=-294870 $Y=218880
X63960 1 2 2545 2652 2764 DFRQ_5VX1 $T=-294440 394240 0 0 $X=-294870 $Y=393600
X63961 1 2 2720 2652 2791 DFRQ_5VX1 $T=-293880 385280 0 0 $X=-294310 $Y=384640
X63962 1 2 2371 8345 2822 DFRQ_5VX1 $T=-293320 89600 0 0 $X=-293750 $Y=88960
X63963 1 2 1839 2772 1655 DFRQ_5VX1 $T=-292760 161280 0 0 $X=-293190 $Y=160640
X63964 1 2 2021 2754 2839 DFRQ_5VX1 $T=-292200 179200 1 0 $X=-292630 $Y=174080
X63965 1 2 8398 2733 2211 DFRQ_5VX1 $T=-291640 340480 1 0 $X=-292070 $Y=335360
X63966 1 2 2022 2772 2586 DFRQ_5VX1 $T=-291080 170240 1 0 $X=-291510 $Y=165120
X63967 1 2 8402 2733 2853 DFRQ_5VX1 $T=-288280 349440 0 0 $X=-288710 $Y=348800
X63968 1 2 2820 2733 2873 DFRQ_5VX1 $T=-286600 367360 1 0 $X=-287030 $Y=362240
X63969 1 2 8400 2733 2852 DFRQ_5VX1 $T=-286040 340480 0 0 $X=-286470 $Y=339840
X63970 1 2 8406 2754 9968 DFRQ_5VX1 $T=-285480 206080 1 0 $X=-285910 $Y=200960
X63971 1 2 8410 2840 2870 DFRQ_5VX1 $T=-284920 215040 0 0 $X=-285350 $Y=214400
X63972 1 2 2807 2733 2217 DFRQ_5VX1 $T=-283800 376320 1 0 $X=-284230 $Y=371200
X63973 1 2 2522 2762 8432 DFRQ_5VX1 $T=-283240 152320 1 0 $X=-283670 $Y=147200
X63974 1 2 2770 2840 2174 DFRQ_5VX1 $T=-282680 250880 1 0 $X=-283110 $Y=245760
X63975 1 2 2521 8345 2905 DFRQ_5VX1 $T=-281560 134400 1 0 $X=-281990 $Y=129280
X63976 1 2 2548 2762 2898 DFRQ_5VX1 $T=-281000 143360 1 0 $X=-281430 $Y=138240
X63977 1 2 2838 2772 2907 DFRQ_5VX1 $T=-281000 170240 0 0 $X=-281430 $Y=169600
X63978 1 2 8418 2754 2582 DFRQ_5VX1 $T=-281000 197120 1 0 $X=-281430 $Y=192000
X63979 1 2 2577 2840 2894 DFRQ_5VX1 $T=-281000 224000 0 0 $X=-281430 $Y=223360
X63980 1 2 2844 2762 2557 DFRQ_5VX1 $T=-280440 152320 0 0 $X=-280870 $Y=151680
X63981 1 2 2845 2840 2877 DFRQ_5VX1 $T=-280440 232960 0 0 $X=-280870 $Y=232320
X63982 1 2 2847 3104 8442 DFRQ_5VX1 $T=-280440 403200 1 0 $X=-280870 $Y=398080
X63983 1 2 8423 2652 2918 DFRQ_5VX1 $T=-279320 376320 0 0 $X=-279750 $Y=375680
X63984 1 2 2459 2652 2885 DFRQ_5VX1 $T=-279320 385280 1 0 $X=-279750 $Y=380160
X63985 1 2 1801 2772 2925 DFRQ_5VX1 $T=-278200 161280 0 0 $X=-278630 $Y=160640
X63986 1 2 2806 2880 9833 DFRQ_5VX1 $T=-277640 358400 0 0 $X=-278070 $Y=357760
X63987 1 2 2864 3104 2948 DFRQ_5VX1 $T=-277640 412160 1 0 $X=-278070 $Y=407040
X63988 1 2 2867 8345 2945 DFRQ_5VX1 $T=-277080 116480 0 0 $X=-277510 $Y=115840
X63989 1 2 2023 2772 2755 DFRQ_5VX1 $T=-275960 170240 1 0 $X=-276390 $Y=165120
X63990 1 2 2926 2698 8414 DFRQ_5VX1 $T=-260280 197120 1 180 $X=-275270 $Y=196480
X63991 1 2 2751 2947 2317 DFRQ_5VX1 $T=-274280 268800 0 0 $X=-274710 $Y=268160
X63992 1 2 721 3094 8455 DFRQ_5VX1 $T=-271480 215040 1 0 $X=-271910 $Y=209920
X63993 1 2 2908 3094 2805 DFRQ_5VX1 $T=-270920 224000 1 0 $X=-271350 $Y=218880
X63994 1 2 8438 2880 2980 DFRQ_5VX1 $T=-270920 367360 1 0 $X=-271350 $Y=362240
X63995 1 2 2964 2947 2699 DFRQ_5VX1 $T=-269800 286720 0 0 $X=-270230 $Y=286080
X63996 1 2 2796 2947 3004 DFRQ_5VX1 $T=-269800 304640 1 0 $X=-270230 $Y=299520
X63997 1 2 3335 2772 2993 DFRQ_5VX1 $T=-269240 179200 1 0 $X=-269670 $Y=174080
X63998 1 2 2890 2947 3054 DFRQ_5VX1 $T=-268120 295680 0 0 $X=-268550 $Y=295040
X63999 1 2 3525 2956 3009 DFRQ_5VX1 $T=-267560 188160 0 0 $X=-267990 $Y=187520
X64000 1 2 2943 2947 2429 DFRQ_5VX1 $T=-267560 277760 0 0 $X=-267990 $Y=277120
X64001 1 2 2504 3094 2570 DFRQ_5VX1 $T=-266440 224000 0 0 $X=-266870 $Y=223360
X64002 1 2 2949 2956 1867 DFRQ_5VX1 $T=-265880 188160 1 0 $X=-266310 $Y=183040
X64003 1 2 2950 2956 3011 DFRQ_5VX1 $T=-265880 197120 1 0 $X=-266310 $Y=192000
X64004 1 2 8463 2880 2917 DFRQ_5VX1 $T=-250760 376320 0 180 $X=-265750 $Y=371200
X64005 1 2 2603 2652 2938 DFRQ_5VX1 $T=-250760 394240 1 180 $X=-265750 $Y=393600
X64006 1 2 2871 2947 8483 DFRQ_5VX1 $T=-264760 313600 0 0 $X=-265190 $Y=312960
X64007 1 2 2958 2880 2297 DFRQ_5VX1 $T=-264760 376320 0 0 $X=-265190 $Y=375680
X64008 1 2 2572 3094 2834 DFRQ_5VX1 $T=-264200 215040 0 0 $X=-264630 $Y=214400
X64009 1 2 3108 2956 9969 DFRQ_5VX1 $T=-263080 206080 1 0 $X=-263510 $Y=200960
X64010 1 2 8447 2947 8513 DFRQ_5VX1 $T=-262520 304640 0 0 $X=-262950 $Y=304000
X64011 1 2 2580 3104 2959 DFRQ_5VX1 $T=-246840 412160 0 180 $X=-261830 $Y=407040
X64012 1 2 2149 2956 2889 DFRQ_5VX1 $T=-259160 179200 0 0 $X=-259590 $Y=178560
X64013 1 2 3005 3030 2482 DFRQ_5VX1 $T=-259160 331520 0 0 $X=-259590 $Y=330880
X64014 1 2 2960 3030 2306 DFRQ_5VX1 $T=-256920 358400 1 0 $X=-257350 $Y=353280
X64015 1 2 2881 2880 2378 DFRQ_5VX1 $T=-255240 358400 0 0 $X=-255670 $Y=357760
X64016 1 2 3069 2652 3006 DFRQ_5VX1 $T=-240680 385280 0 180 $X=-255670 $Y=380160
X64017 1 2 2458 2956 3134 DFRQ_5VX1 $T=-253000 197120 0 0 $X=-253430 $Y=196480
X64018 1 2 8497 2880 8473 DFRQ_5VX1 $T=-237880 367360 0 180 $X=-252870 $Y=362240
X64019 1 2 3058 2652 8508 DFRQ_5VX1 $T=-250760 394240 0 0 $X=-251190 $Y=393600
X64020 1 2 3024 3178 3093 DFRQ_5VX1 $T=-250200 188160 1 0 $X=-250630 $Y=183040
X64021 1 2 8500 2652 2971 DFRQ_5VX1 $T=-235640 376320 1 180 $X=-250630 $Y=375680
X64022 1 2 3063 3094 8507 DFRQ_5VX1 $T=-249640 215040 0 0 $X=-250070 $Y=214400
X64023 1 2 2693 3104 3121 DFRQ_5VX1 $T=-249080 421120 1 0 $X=-249510 $Y=416000
X64024 1 2 3082 3104 3146 DFRQ_5VX1 $T=-247960 403200 0 0 $X=-248390 $Y=402560
X64025 1 2 8504 4388 2339 DFRQ_5VX1 $T=-241800 385280 0 0 $X=-242230 $Y=384640
X64026 1 2 3065 3169 2975 DFRQ_5VX1 $T=-241240 277760 0 0 $X=-241670 $Y=277120
X64027 1 2 3138 3178 2291 DFRQ_5VX1 $T=-240680 215040 1 0 $X=-241110 $Y=209920
X64028 1 2 3156 3178 8542 DFRQ_5VX1 $T=-239000 206080 1 0 $X=-239430 $Y=200960
X64029 1 2 2746 4388 2305 DFRQ_5VX1 $T=-239000 367360 0 0 $X=-239430 $Y=366720
X64030 1 2 2005 3193 8534 DFRQ_5VX1 $T=-236760 125440 0 0 $X=-237190 $Y=124800
X64031 1 2 8520 3104 3235 DFRQ_5VX1 $T=-236760 421120 0 0 $X=-237190 $Y=420480
X64032 1 2 3177 3030 719 DFRQ_5VX1 $T=-236200 349440 0 0 $X=-236630 $Y=348800
X64033 1 2 8531 4388 3150 DFRQ_5VX1 $T=-221640 385280 0 180 $X=-236630 $Y=380160
X64034 1 2 179 3222 3907 DFRQ_5VX1 $T=-235640 80640 0 0 $X=-236070 $Y=80000
X64035 1 2 2692 3169 8270 DFRQ_5VX1 $T=-235640 295680 0 0 $X=-236070 $Y=295040
X64036 1 2 3181 3257 8539 DFRQ_5VX1 $T=-235640 313600 1 0 $X=-236070 $Y=308480
X64037 1 2 2268 3222 3246 DFRQ_5VX1 $T=-235080 62720 0 0 $X=-235510 $Y=62080
X64038 1 2 180 3222 3247 DFRQ_5VX1 $T=-235080 71680 1 0 $X=-235510 $Y=66560
X64039 1 2 3227 3104 3165 DFRQ_5VX1 $T=-220520 403200 0 180 $X=-235510 $Y=398080
X64040 1 2 3173 3178 8543 DFRQ_5VX1 $T=-234520 188160 1 0 $X=-234950 $Y=183040
X64041 1 2 3187 182 3258 DFRQ_5VX1 $T=-233960 17920 0 0 $X=-234390 $Y=17280
X64042 1 2 3192 3193 9789 DFRQ_5VX1 $T=-233960 98560 1 0 $X=-234390 $Y=93440
X64043 1 2 2453 3222 3677 DFRQ_5VX1 $T=-233400 44800 1 0 $X=-233830 $Y=39680
X64044 1 2 8524 3178 2332 DFRQ_5VX1 $T=-233400 188160 0 0 $X=-233830 $Y=187520
X64045 1 2 8525 3219 9837 DFRQ_5VX1 $T=-232840 134400 0 0 $X=-233270 $Y=133760
X64046 1 2 2816 3222 3269 DFRQ_5VX1 $T=-232280 44800 0 0 $X=-232710 $Y=44160
X64047 1 2 3203 3193 3271 DFRQ_5VX1 $T=-232280 107520 1 0 $X=-232710 $Y=102400
X64048 1 2 2786 3104 3207 DFRQ_5VX1 $T=-232280 403200 0 0 $X=-232710 $Y=402560
X64049 1 2 3174 3178 2356 DFRQ_5VX1 $T=-231720 197120 0 0 $X=-232150 $Y=196480
X64050 1 2 8519 3169 2929 DFRQ_5VX1 $T=-231720 286720 0 0 $X=-232150 $Y=286080
X64051 1 2 2854 3169 2175 DFRQ_5VX1 $T=-231720 295680 1 0 $X=-232150 $Y=290560
X64052 1 2 2923 3193 3272 DFRQ_5VX1 $T=-231160 107520 0 0 $X=-231590 $Y=106880
X64053 1 2 8528 3193 3230 DFRQ_5VX1 $T=-231160 116480 0 0 $X=-231590 $Y=115840
X64054 1 2 8530 3219 8548 DFRQ_5VX1 $T=-230600 161280 1 0 $X=-231030 $Y=156160
X64055 1 2 2340 3219 9971 DFRQ_5VX1 $T=-230040 152320 1 0 $X=-230470 $Y=147200
X64056 1 2 8532 3293 8556 DFRQ_5VX1 $T=-228920 170240 0 0 $X=-229350 $Y=169600
X64057 1 2 2511 3178 2073 DFRQ_5VX1 $T=-227800 206080 0 0 $X=-228230 $Y=205440
X64058 1 2 8523 3257 3191 DFRQ_5VX1 $T=-213240 322560 0 180 $X=-228230 $Y=317440
X64059 1 2 9836 4388 2436 DFRQ_5VX1 $T=-227240 385280 0 0 $X=-227670 $Y=384640
X64060 1 2 2979 3257 8563 DFRQ_5VX1 $T=-226680 322560 0 0 $X=-227110 $Y=321920
X64061 1 2 8541 182 3315 DFRQ_5VX1 $T=-226120 26880 0 0 $X=-226550 $Y=26240
X64062 1 2 191 3219 2426 DFRQ_5VX1 $T=-226120 161280 0 0 $X=-226550 $Y=160640
X64063 1 2 2164 3293 8559 DFRQ_5VX1 $T=-226120 179200 0 0 $X=-226550 $Y=178560
X64064 1 2 3211 3222 3664 DFRQ_5VX1 $T=-225560 35840 0 0 $X=-225990 $Y=35200
X64065 1 2 3115 3169 2289 DFRQ_5VX1 $T=-224440 268800 0 0 $X=-224870 $Y=268160
X64066 1 2 2621 3293 2104 DFRQ_5VX1 $T=-222200 215040 0 0 $X=-222630 $Y=214400
X64067 1 2 8545 3104 3340 DFRQ_5VX1 $T=-221640 421120 1 0 $X=-222070 $Y=416000
X64068 1 2 201 3219 3400 DFRQ_5VX1 $T=-221080 143360 1 0 $X=-221510 $Y=138240
X64069 1 2 2896 3257 3350 DFRQ_5VX1 $T=-221080 304640 0 0 $X=-221510 $Y=304000
X64070 1 2 9839 3222 3351 DFRQ_5VX1 $T=-220520 62720 0 0 $X=-220950 $Y=62080
X64071 1 2 3237 3219 211 DFRQ_5VX1 $T=-220520 125440 0 0 $X=-220950 $Y=124800
X64072 1 2 9801 3169 3381 DFRQ_5VX1 $T=-220520 277760 1 0 $X=-220950 $Y=272640
X64073 1 2 8547 3104 3355 DFRQ_5VX1 $T=-220520 403200 1 0 $X=-220950 $Y=398080
X64074 1 2 2874 3257 2205 DFRQ_5VX1 $T=-219960 313600 1 0 $X=-220390 $Y=308480
X64075 1 2 3291 3104 8582 DFRQ_5VX1 $T=-219960 412160 1 0 $X=-220390 $Y=407040
X64076 1 2 205 3219 8474 DFRQ_5VX1 $T=-219400 134400 1 0 $X=-219830 $Y=129280
X64077 1 2 3252 3030 8576 DFRQ_5VX1 $T=-219400 331520 0 0 $X=-219830 $Y=330880
X64078 1 2 3297 3293 3369 DFRQ_5VX1 $T=-218280 179200 1 0 $X=-218710 $Y=174080
X64079 1 2 3276 3257 3266 DFRQ_5VX1 $T=-217160 331520 1 0 $X=-217590 $Y=326400
X64080 1 2 3226 2652 3338 DFRQ_5VX1 $T=-217160 394240 1 0 $X=-217590 $Y=389120
X64081 1 2 2163 3219 3408 DFRQ_5VX1 $T=-216040 152320 0 0 $X=-216470 $Y=151680
X64082 1 2 8565 3533 3442 DFRQ_5VX1 $T=-215480 412160 0 0 $X=-215910 $Y=411520
X64083 1 2 2599 3257 3385 DFRQ_5VX1 $T=-214360 313600 0 0 $X=-214790 $Y=312960
X64084 1 2 8566 3030 3412 DFRQ_5VX1 $T=-214360 349440 0 0 $X=-214790 $Y=348800
X64085 1 2 2254 3293 3420 DFRQ_5VX1 $T=-211560 188160 0 0 $X=-211990 $Y=187520
X64086 1 2 3372 3533 8601 DFRQ_5VX1 $T=-208760 421120 0 0 $X=-209190 $Y=420480
X64087 1 2 2285 3293 1709 DFRQ_5VX1 $T=-207640 188160 1 0 $X=-208070 $Y=183040
X64088 1 2 3440 3030 3341 DFRQ_5VX1 $T=-190280 331520 1 180 $X=-205270 $Y=330880
X64089 1 2 3473 3533 3399 DFRQ_5VX1 $T=-190280 403200 0 180 $X=-205270 $Y=398080
X64090 1 2 3424 4388 2588 DFRQ_5VX1 $T=-200920 385280 0 0 $X=-201350 $Y=384640
X64091 1 2 3441 3493 3530 DFRQ_5VX1 $T=-200360 340480 1 0 $X=-200790 $Y=335360
X64092 1 2 3462 3493 3429 DFRQ_5VX1 $T=-199240 322560 0 0 $X=-199670 $Y=321920
X64093 1 2 3480 3493 3570 DFRQ_5VX1 $T=-198680 313600 0 0 $X=-199110 $Y=312960
X64094 1 2 3471 3556 3576 DFRQ_5VX1 $T=-197000 259840 0 0 $X=-197430 $Y=259200
X64095 1 2 8552 3521 3596 DFRQ_5VX1 $T=-196440 188160 0 0 $X=-196870 $Y=187520
X64096 1 2 8597 3586 2391 DFRQ_5VX1 $T=-196440 394240 1 0 $X=-196870 $Y=389120
X64097 1 2 3501 3493 3562 DFRQ_5VX1 $T=-194760 331520 1 0 $X=-195190 $Y=326400
X64098 1 2 3510 3533 3494 DFRQ_5VX1 $T=-194200 403200 0 0 $X=-194630 $Y=402560
X64099 1 2 3317 3521 3616 DFRQ_5VX1 $T=-193640 197120 1 0 $X=-194070 $Y=192000
X64100 1 2 3508 3556 2200 DFRQ_5VX1 $T=-193080 250880 1 0 $X=-193510 $Y=245760
X64101 1 2 3526 3556 3569 DFRQ_5VX1 $T=-191400 268800 0 0 $X=-191830 $Y=268160
X64102 1 2 8623 3586 3643 DFRQ_5VX1 $T=-189720 394240 0 0 $X=-190150 $Y=393600
X64103 1 2 225 3193 3659 DFRQ_5VX1 $T=-189160 107520 0 0 $X=-189590 $Y=106880
X64104 1 2 3632 3533 3523 DFRQ_5VX1 $T=-173480 421120 1 180 $X=-188470 $Y=420480
X64105 1 2 3579 3533 3657 DFRQ_5VX1 $T=-186920 421120 1 0 $X=-187350 $Y=416000
X64106 1 2 3590 3493 3746 DFRQ_5VX1 $T=-185800 340480 1 0 $X=-186230 $Y=335360
X64107 1 2 3577 3556 3617 DFRQ_5VX1 $T=-185240 259840 1 0 $X=-185670 $Y=254720
X64108 1 2 3626 3556 3557 DFRQ_5VX1 $T=-182440 259840 0 0 $X=-182870 $Y=259200
X64109 1 2 3700 3586 3592 DFRQ_5VX1 $T=-167320 394240 0 180 $X=-182310 $Y=389120
X64110 1 2 3251 3521 2758 DFRQ_5VX1 $T=-179640 206080 0 0 $X=-180070 $Y=205440
X64111 1 2 9844 3586 3686 DFRQ_5VX1 $T=-178520 403200 1 0 $X=-178950 $Y=398080
X64112 1 2 3684 3719 3718 DFRQ_5VX1 $T=-176840 268800 0 0 $X=-177270 $Y=268160
X64113 1 2 3648 3719 3732 DFRQ_5VX1 $T=-176840 277760 0 0 $X=-177270 $Y=277120
X64114 1 2 3738 3521 3466 DFRQ_5VX1 $T=-171240 224000 0 0 $X=-171670 $Y=223360
X64115 1 2 3715 3719 3822 DFRQ_5VX1 $T=-170680 313600 0 0 $X=-171110 $Y=312960
X64116 1 2 244 3830 3843 DFRQ_5VX1 $T=-170120 44800 1 0 $X=-170550 $Y=39680
X64117 1 2 3709 3774 4178 DFRQ_5VX1 $T=-170120 98560 0 0 $X=-170550 $Y=97920
X64118 1 2 3652 3586 3729 DFRQ_5VX1 $T=-155560 412160 1 180 $X=-170550 $Y=411520
X64119 1 2 3765 3521 2176 DFRQ_5VX1 $T=-168440 224000 1 0 $X=-168870 $Y=218880
X64120 1 2 8677 3719 3874 DFRQ_5VX1 $T=-167320 277760 1 0 $X=-167750 $Y=272640
X64121 1 2 252 3830 243 DFRQ_5VX1 $T=-152200 26880 1 180 $X=-167190 $Y=26240
X64122 1 2 248 3774 254 DFRQ_5VX1 $T=-165080 80640 0 0 $X=-165510 $Y=80000
X64123 1 2 249 3774 3884 DFRQ_5VX1 $T=-164520 71680 1 0 $X=-164950 $Y=66560
X64124 1 2 3183 3830 8685 DFRQ_5VX1 $T=-148840 35840 0 180 $X=-163830 $Y=30720
X64125 1 2 246 3774 260 DFRQ_5VX1 $T=-163400 71680 0 0 $X=-163830 $Y=71040
X64126 1 2 3772 3851 3906 DFRQ_5VX1 $T=-163400 403200 0 0 $X=-163830 $Y=402560
X64127 1 2 247 3774 2924 DFRQ_5VX1 $T=-162840 107520 1 0 $X=-163270 $Y=102400
X64128 1 2 3799 3774 1914 DFRQ_5VX1 $T=-162840 116480 0 0 $X=-163270 $Y=115840
X64129 1 2 3813 3719 3846 DFRQ_5VX1 $T=-162280 277760 0 0 $X=-162710 $Y=277120
X64130 1 2 8693 3851 3926 DFRQ_5VX1 $T=-162280 403200 1 0 $X=-162710 $Y=398080
X64131 1 2 3900 3851 3766 DFRQ_5VX1 $T=-146040 385280 1 180 $X=-161030 $Y=384640
X64132 1 2 3866 3851 3956 DFRQ_5VX1 $T=-158360 376320 1 0 $X=-158790 $Y=371200
X64133 1 2 3880 3911 3792 DFRQ_5VX1 $T=-156120 232960 1 0 $X=-156550 $Y=227840
X64134 1 2 257 3774 3273 DFRQ_5VX1 $T=-155560 80640 1 0 $X=-155990 $Y=75520
X64135 1 2 258 3916 3985 DFRQ_5VX1 $T=-155560 107520 0 0 $X=-155990 $Y=106880
X64136 1 2 3817 3493 8724 DFRQ_5VX1 $T=-155560 340480 1 0 $X=-155990 $Y=335360
X64137 1 2 259 3830 268 DFRQ_5VX1 $T=-154440 35840 0 0 $X=-154870 $Y=35200
X64138 1 2 3862 3851 8728 DFRQ_5VX1 $T=-153880 385280 1 0 $X=-154310 $Y=380160
X64139 1 2 266 264 269 DFRQ_5VX1 $T=-153320 17920 1 0 $X=-153750 $Y=12800
X64140 1 2 3912 3911 3059 DFRQ_5VX1 $T=-153320 232960 0 0 $X=-153750 $Y=232320
X64141 1 2 8717 3719 3802 DFRQ_5VX1 $T=-138760 286720 0 180 $X=-153750 $Y=281600
X64142 1 2 263 3830 3033 DFRQ_5VX1 $T=-151640 53760 0 0 $X=-152070 $Y=53120
X64143 1 2 3969 3994 4043 DFRQ_5VX1 $T=-147160 286720 0 0 $X=-147590 $Y=286080
X64144 1 2 4091 3911 2706 DFRQ_5VX1 $T=-146600 241920 1 0 $X=-147030 $Y=236800
X64145 1 2 4018 3851 3946 DFRQ_5VX1 $T=-132040 403200 0 180 $X=-147030 $Y=398080
X64146 1 2 3983 4154 8750 DFRQ_5VX1 $T=-145480 367360 1 0 $X=-145910 $Y=362240
X64147 1 2 3987 4154 3839 DFRQ_5VX1 $T=-144920 385280 0 0 $X=-145350 $Y=384640
X64148 1 2 4032 3830 3927 DFRQ_5VX1 $T=-129800 44800 1 180 $X=-144790 $Y=44160
X64149 1 2 4041 3911 3978 DFRQ_5VX1 $T=-129240 241920 1 180 $X=-144230 $Y=241280
X64150 1 2 4393 3994 3944 DFRQ_5VX1 $T=-127000 304640 0 180 $X=-141990 $Y=299520
X64151 1 2 8731 4168 274 DFRQ_5VX1 $T=-141000 179200 0 0 $X=-141430 $Y=178560
X64152 1 2 4023 3994 4058 DFRQ_5VX1 $T=-141000 322560 1 0 $X=-141430 $Y=317440
X64153 1 2 4065 4092 4206 DFRQ_5VX1 $T=-135400 62720 1 0 $X=-135830 $Y=57600
X64154 1 2 4068 3916 8777 DFRQ_5VX1 $T=-135400 89600 1 0 $X=-135830 $Y=84480
X64155 1 2 3986 4168 284 DFRQ_5VX1 $T=-134840 179200 1 0 $X=-135270 $Y=174080
X64156 1 2 4082 4092 4155 DFRQ_5VX1 $T=-133720 62720 0 0 $X=-134150 $Y=62080
X64157 1 2 8759 3916 4204 DFRQ_5VX1 $T=-133160 98560 0 0 $X=-133590 $Y=97920
X64158 1 2 282 264 4024 DFRQ_5VX1 $T=-118040 17920 0 180 $X=-133030 $Y=12800
X64159 1 2 277 4092 8782 DFRQ_5VX1 $T=-130360 26880 0 0 $X=-130790 $Y=26240
X64160 1 2 4111 3916 8786 DFRQ_5VX1 $T=-130360 107520 0 0 $X=-130790 $Y=106880
X64161 1 2 4060 4154 4052 DFRQ_5VX1 $T=-115240 385280 1 180 $X=-130230 $Y=384640
X64162 1 2 4120 3916 288 DFRQ_5VX1 $T=-128680 125440 1 0 $X=-129110 $Y=120320
X64163 1 2 4126 4154 8806 DFRQ_5VX1 $T=-128120 376320 0 0 $X=-128550 $Y=375680
X64164 1 2 4266 4092 8766 DFRQ_5VX1 $T=-113000 53760 0 180 $X=-127990 $Y=48640
X64165 1 2 3470 4161 291 DFRQ_5VX1 $T=-127560 170240 1 0 $X=-127990 $Y=165120
X64166 1 2 286 4092 4124 DFRQ_5VX1 $T=-112440 44800 0 180 $X=-127430 $Y=39680
X64167 1 2 4131 4092 8789 DFRQ_5VX1 $T=-127000 71680 1 0 $X=-127430 $Y=66560
X64168 1 2 280 4161 293 DFRQ_5VX1 $T=-127000 134400 1 0 $X=-127430 $Y=129280
X64169 1 2 4128 4161 4224 DFRQ_5VX1 $T=-127000 152320 0 0 $X=-127430 $Y=151680
X64170 1 2 4094 4161 8795 DFRQ_5VX1 $T=-127000 161280 1 0 $X=-127430 $Y=156160
X64171 1 2 4129 4168 292 DFRQ_5VX1 $T=-127000 170240 0 0 $X=-127430 $Y=169600
X64172 1 2 4110 4154 4074 DFRQ_5VX1 $T=-112440 367360 1 180 $X=-127430 $Y=366720
X64173 1 2 4193 264 281 DFRQ_5VX1 $T=-111880 17920 1 180 $X=-126870 $Y=17280
X64174 1 2 8821 3916 4127 DFRQ_5VX1 $T=-111880 80640 1 180 $X=-126870 $Y=80000
X64175 1 2 4132 4161 4217 DFRQ_5VX1 $T=-126440 143360 1 0 $X=-126870 $Y=138240
X64176 1 2 4133 4161 3155 DFRQ_5VX1 $T=-126440 143360 0 0 $X=-126870 $Y=142720
X64177 1 2 4107 4168 8798 DFRQ_5VX1 $T=-126440 188160 1 0 $X=-126870 $Y=183040
X64178 1 2 8774 4168 4226 DFRQ_5VX1 $T=-126440 188160 0 0 $X=-126870 $Y=187520
X64179 1 2 4059 4168 4036 DFRQ_5VX1 $T=-126440 197120 0 0 $X=-126870 $Y=196480
X64180 1 2 4195 3911 8428 DFRQ_5VX1 $T=-111880 250880 1 180 $X=-126870 $Y=250240
X64181 1 2 4234 3994 4116 DFRQ_5VX1 $T=-111880 322560 0 180 $X=-126870 $Y=317440
X64182 1 2 4136 4154 746 DFRQ_5VX1 $T=-126440 358400 0 0 $X=-126870 $Y=357760
X64183 1 2 8826 4348 8781 DFRQ_5VX1 $T=-83320 98560 0 180 $X=-98310 $Y=93440
X64184 1 2 4375 4348 306 DFRQ_5VX1 $T=-83320 107520 0 180 $X=-98310 $Y=102400
X64185 1 2 4186 4352 8797 DFRQ_5VX1 $T=-83320 179200 1 180 $X=-98310 $Y=178560
X64186 1 2 4327 4358 8799 DFRQ_5VX1 $T=-97880 188160 0 0 $X=-98310 $Y=187520
X64187 1 2 4323 4353 3784 DFRQ_5VX1 $T=-83320 215040 1 180 $X=-98310 $Y=214400
X64188 1 2 4277 4358 4181 DFRQ_5VX1 $T=-82760 206080 1 180 $X=-97750 $Y=205440
X64189 1 2 4216 4348 316 DFRQ_5VX1 $T=-96760 89600 1 0 $X=-97190 $Y=84480
X64190 1 2 4341 4352 4415 DFRQ_5VX1 $T=-96200 161280 0 0 $X=-96630 $Y=160640
X64191 1 2 4350 4352 4346 DFRQ_5VX1 $T=-96200 170240 1 0 $X=-96630 $Y=165120
X64192 1 2 4312 4352 4411 DFRQ_5VX1 $T=-96200 170240 0 0 $X=-96630 $Y=169600
X64193 1 2 4263 3994 4422 DFRQ_5VX1 $T=-96200 304640 1 0 $X=-96630 $Y=299520
X64194 1 2 4349 4348 8837 DFRQ_5VX1 $T=-95080 116480 0 0 $X=-95510 $Y=115840
X64195 1 2 4321 4348 8812 DFRQ_5VX1 $T=-79960 107520 1 180 $X=-94950 $Y=106880
X64196 1 2 4347 4353 4423 DFRQ_5VX1 $T=-94520 241920 1 0 $X=-94950 $Y=236800
X64197 1 2 8804 3994 4329 DFRQ_5VX1 $T=-79960 322560 1 180 $X=-94950 $Y=321920
X64198 1 2 4370 4358 4460 DFRQ_5VX1 $T=-92840 215040 1 0 $X=-93270 $Y=209920
X64199 1 2 4378 4353 4452 DFRQ_5VX1 $T=-91160 224000 0 0 $X=-91590 $Y=223360
X64200 1 2 4387 4358 4459 DFRQ_5VX1 $T=-90040 206080 1 0 $X=-90470 $Y=200960
X64201 1 2 4390 4352 4306 DFRQ_5VX1 $T=-89480 179200 1 0 $X=-89910 $Y=174080
X64202 1 2 4291 4511 4386 DFRQ_5VX1 $T=-71560 134400 1 180 $X=-86550 $Y=133760
X64203 1 2 4429 4353 4495 DFRQ_5VX1 $T=-85000 224000 1 0 $X=-85430 $Y=218880
X64204 1 2 5966 4358 3960 DFRQ_5VX1 $T=-84440 197120 1 0 $X=-84870 $Y=192000
X64205 1 2 4328 4352 4514 DFRQ_5VX1 $T=-83320 188160 1 0 $X=-83750 $Y=183040
X64206 1 2 4444 4358 4402 DFRQ_5VX1 $T=-83320 188160 0 0 $X=-83750 $Y=187520
X64207 1 2 4445 4353 4384 DFRQ_5VX1 $T=-83320 215040 0 0 $X=-83750 $Y=214400
X64208 1 2 4267 4353 4472 DFRQ_5VX1 $T=-82760 206080 0 0 $X=-83190 $Y=205440
X64209 1 2 4481 4496 4547 DFRQ_5VX1 $T=-79400 241920 1 0 $X=-79830 $Y=236800
X64210 1 2 3931 3533 4608 DFRQ_5VX1 $T=-78840 322560 1 0 $X=-79270 $Y=317440
X64211 1 2 4541 4511 4389 DFRQ_5VX1 $T=-62600 143360 0 180 $X=-77590 $Y=138240
X64212 1 2 4271 4496 4683 DFRQ_5VX1 $T=-76040 224000 0 0 $X=-76470 $Y=223360
X64213 1 2 8850 4496 4585 DFRQ_5VX1 $T=-76040 232960 1 0 $X=-76470 $Y=227840
X64214 1 2 4500 3533 4439 DFRQ_5VX1 $T=-76040 340480 1 0 $X=-76470 $Y=335360
X64215 1 2 4509 3533 9857 DFRQ_5VX1 $T=-73240 349440 0 0 $X=-73670 $Y=348800
X64216 1 2 4576 8858 4427 DFRQ_5VX1 $T=-58120 116480 0 180 $X=-73110 $Y=111360
X64217 1 2 4600 4511 4493 DFRQ_5VX1 $T=-57560 152320 1 180 $X=-72550 $Y=151680
X64218 1 2 4535 3533 9858 DFRQ_5VX1 $T=-71560 358400 0 0 $X=-71990 $Y=357760
X64219 1 2 4548 4496 4308 DFRQ_5VX1 $T=-70440 250880 1 0 $X=-70870 $Y=245760
X64220 1 2 4372 3533 8869 DFRQ_5VX1 $T=-70440 349440 1 0 $X=-70870 $Y=344320
X64221 1 2 4522 3533 4365 DFRQ_5VX1 $T=-69320 286720 0 0 $X=-69750 $Y=286080
X64222 1 2 4467 3533 4602 DFRQ_5VX1 $T=-69320 313600 0 0 $X=-69750 $Y=312960
X64223 1 2 8861 3533 8870 DFRQ_5VX1 $T=-69320 376320 1 0 $X=-69750 $Y=371200
X64224 1 2 4054 8858 4642 DFRQ_5VX1 $T=-68200 125440 0 0 $X=-68630 $Y=124800
X64225 1 2 4573 4610 4695 DFRQ_5VX1 $T=-67640 161280 0 0 $X=-68070 $Y=160640
X64226 1 2 4632 8858 3953 DFRQ_5VX1 $T=-52520 125440 0 180 $X=-67510 $Y=120320
X64227 1 2 4202 3533 4619 DFRQ_5VX1 $T=-67080 304640 1 0 $X=-67510 $Y=299520
X64228 1 2 4553 3533 4307 DFRQ_5VX1 $T=-65960 268800 1 0 $X=-66390 $Y=263680
X64229 1 2 4364 3533 4676 DFRQ_5VX1 $T=-65960 277760 0 0 $X=-66390 $Y=277120
X64230 1 2 4464 4496 4624 DFRQ_5VX1 $T=-64840 232960 0 0 $X=-65270 $Y=232320
X64231 1 2 4603 3533 4438 DFRQ_5VX1 $T=-64840 331520 1 0 $X=-65270 $Y=326400
X64232 1 2 4607 3533 4659 DFRQ_5VX1 $T=-64280 259840 1 0 $X=-64710 $Y=254720
X64233 1 2 4555 4496 8879 DFRQ_5VX1 $T=-63720 241920 0 0 $X=-64150 $Y=241280
X64234 1 2 4658 4511 4008 DFRQ_5VX1 $T=-48600 134400 1 180 $X=-63590 $Y=133760
X64235 1 2 4565 3533 4324 DFRQ_5VX1 $T=-63160 304640 0 0 $X=-63590 $Y=304000
X64236 1 2 4665 4511 4577 DFRQ_5VX1 $T=-48040 143360 1 180 $X=-63030 $Y=142720
X64237 1 2 4625 3533 4698 DFRQ_5VX1 $T=-62600 376320 0 0 $X=-63030 $Y=375680
X64238 1 2 4259 4610 361 DFRQ_5VX1 $T=-62040 170240 1 0 $X=-62470 $Y=165120
X64239 1 2 4680 8858 3997 DFRQ_5VX1 $T=-46920 116480 1 180 $X=-61910 $Y=115840
X64240 1 2 8868 3533 4696 DFRQ_5VX1 $T=-61480 331520 0 0 $X=-61910 $Y=330880
X64241 1 2 4272 3533 4684 DFRQ_5VX1 $T=-61480 403200 1 0 $X=-61910 $Y=398080
X64242 1 2 4689 8858 4609 DFRQ_5VX1 $T=-45800 134400 0 180 $X=-60790 $Y=129280
X64243 1 2 4688 8858 4033 DFRQ_5VX1 $T=-45240 107520 0 180 $X=-60230 $Y=102400
X64244 1 2 4643 4610 4734 DFRQ_5VX1 $T=-58680 170240 0 0 $X=-59110 $Y=169600
X64245 1 2 4270 3533 4710 DFRQ_5VX1 $T=-58680 367360 1 0 $X=-59110 $Y=362240
X64246 1 2 4646 3533 4691 DFRQ_5VX1 $T=-58680 385280 1 0 $X=-59110 $Y=380160
X64247 1 2 8873 3533 8892 DFRQ_5VX1 $T=-57000 322560 1 0 $X=-57430 $Y=317440
X64248 1 2 8874 3533 4753 DFRQ_5VX1 $T=-56440 286720 1 0 $X=-56870 $Y=281600
X64249 1 2 8876 3533 8897 DFRQ_5VX1 $T=-54760 295680 0 0 $X=-55190 $Y=295040
X64250 1 2 4601 3533 4669 DFRQ_5VX1 $T=-39080 268800 1 180 $X=-54070 $Y=268160
X64251 1 2 4690 3533 4736 DFRQ_5VX1 $T=-53080 313600 0 0 $X=-53510 $Y=312960
X64252 1 2 4765 3533 4667 DFRQ_5VX1 $T=-51400 224000 0 0 $X=-51830 $Y=223360
X64253 1 2 4628 3533 4594 DFRQ_5VX1 $T=-36840 268800 0 180 $X=-51830 $Y=263680
X64254 1 2 4748 4610 4649 DFRQ_5VX1 $T=-36280 152320 0 180 $X=-51270 $Y=147200
X64255 1 2 4361 3533 4785 DFRQ_5VX1 $T=-50280 232960 0 0 $X=-50710 $Y=232320
X64256 1 2 8885 3533 4096 DFRQ_5VX1 $T=-49720 259840 1 0 $X=-50150 $Y=254720
X64257 1 2 8887 3533 4819 DFRQ_5VX1 $T=-49160 412160 0 0 $X=-49590 $Y=411520
X64258 1 2 4586 3533 4793 DFRQ_5VX1 $T=-48600 295680 1 0 $X=-49030 $Y=290560
X64259 1 2 4489 3533 4777 DFRQ_5VX1 $T=-48600 304640 0 0 $X=-49030 $Y=304000
X64260 1 2 4704 3533 8906 DFRQ_5VX1 $T=-48040 349440 0 0 $X=-48470 $Y=348800
X64261 1 2 4728 4610 4823 DFRQ_5VX1 $T=-47480 170240 1 0 $X=-47910 $Y=165120
X64262 1 2 8890 3533 4621 DFRQ_5VX1 $T=-47480 403200 0 0 $X=-47910 $Y=402560
X64263 1 2 4363 3533 4668 DFRQ_5VX1 $T=-46920 250880 1 0 $X=-47350 $Y=245760
X64264 1 2 4485 3533 4816 DFRQ_5VX1 $T=-45800 349440 1 0 $X=-46230 $Y=344320
X64265 1 2 4381 3533 4835 DFRQ_5VX1 $T=-44680 358400 1 0 $X=-45110 $Y=353280
X64266 1 2 4768 3533 4794 DFRQ_5VX1 $T=-44120 322560 0 0 $X=-44550 $Y=321920
X64267 1 2 4770 3533 4723 DFRQ_5VX1 $T=-44120 331520 0 0 $X=-44550 $Y=330880
X64268 1 2 8805 3533 4737 DFRQ_5VX1 $T=-44120 367360 1 0 $X=-44550 $Y=362240
X64269 1 2 4757 3533 4812 DFRQ_5VX1 $T=-44120 385280 1 0 $X=-44550 $Y=380160
X64270 1 2 4769 3533 4848 DFRQ_5VX1 $T=-43000 340480 0 0 $X=-43430 $Y=339840
X64271 1 2 8902 3533 8916 DFRQ_5VX1 $T=-43000 394240 1 0 $X=-43430 $Y=389120
X64272 1 2 4801 4826 4618 DFRQ_5VX1 $T=-39640 277760 1 0 $X=-40070 $Y=272640
X64273 1 2 4756 4826 8930 DFRQ_5VX1 $T=-38520 376320 1 0 $X=-38950 $Y=371200
X64274 1 2 6555 4610 4093 DFRQ_5VX1 $T=-23400 152320 1 180 $X=-38390 $Y=151680
X64275 1 2 4832 4826 4927 DFRQ_5VX1 $T=-35720 232960 0 0 $X=-36150 $Y=232320
X64276 1 2 4752 4826 4761 DFRQ_5VX1 $T=-35160 259840 1 0 $X=-35590 $Y=254720
X64277 1 2 6509 4610 4021 DFRQ_5VX1 $T=-19480 152320 0 180 $X=-34470 $Y=147200
X64278 1 2 4810 4645 4929 DFRQ_5VX1 $T=-34040 304640 0 0 $X=-34470 $Y=304000
X64279 1 2 8917 4826 9986 DFRQ_5VX1 $T=-33480 421120 1 0 $X=-33910 $Y=416000
X64280 1 2 4850 4645 4937 DFRQ_5VX1 $T=-32920 286720 0 0 $X=-33350 $Y=286080
X64281 1 2 4804 4645 4678 DFRQ_5VX1 $T=-32920 295680 1 0 $X=-33350 $Y=290560
X64282 1 2 8918 4826 4815 DFRQ_5VX1 $T=-32360 250880 1 0 $X=-32790 $Y=245760
X64283 1 2 4597 4826 4897 DFRQ_5VX1 $T=-32360 403200 0 0 $X=-32790 $Y=402560
X64284 1 2 4870 4826 4903 DFRQ_5VX1 $T=-32360 412160 0 0 $X=-32790 $Y=411520
X64285 1 2 4845 4826 4896 DFRQ_5VX1 $T=-30680 241920 0 0 $X=-31110 $Y=241280
X64286 1 2 4833 4645 4864 DFRQ_5VX1 $T=-30680 295680 0 0 $X=-31110 $Y=295040
X64287 1 2 4846 4909 4961 DFRQ_5VX1 $T=-30680 322560 1 0 $X=-31110 $Y=317440
X64288 1 2 4881 4914 4482 DFRQ_5VX1 $T=-30120 268800 0 0 $X=-30550 $Y=268160
X64289 1 2 8921 4645 4865 DFRQ_5VX1 $T=-30120 313600 1 0 $X=-30550 $Y=308480
X64290 1 2 4883 4826 8929 DFRQ_5VX1 $T=-30120 385280 0 0 $X=-30550 $Y=384640
X64291 1 2 8923 4909 4440 DFRQ_5VX1 $T=-29560 358400 1 0 $X=-29990 $Y=353280
X64292 1 2 4786 4645 4966 DFRQ_5VX1 $T=-29000 286720 1 0 $X=-29430 $Y=281600
X64293 1 2 4858 5050 4947 DFRQ_5VX1 $T=-28440 385280 1 0 $X=-28870 $Y=380160
X64294 1 2 4766 4645 4795 DFRQ_5VX1 $T=-27880 277760 0 0 $X=-28310 $Y=277120
X64295 1 2 4878 4909 4545 DFRQ_5VX1 $T=-27880 340480 1 0 $X=-28310 $Y=335360
X64296 1 2 8931 4826 4969 DFRQ_5VX1 $T=-26760 376320 0 0 $X=-27190 $Y=375680
X64297 1 2 4877 4909 5193 DFRQ_5VX1 $T=-25640 331520 1 0 $X=-26070 $Y=326400
X64298 1 2 8935 4909 4836 DFRQ_5VX1 $T=-24520 349440 1 0 $X=-24950 $Y=344320
X64299 1 2 4868 4909 4778 DFRQ_5VX1 $T=-24520 349440 0 0 $X=-24950 $Y=348800
X64300 1 2 4950 4909 5018 DFRQ_5VX1 $T=-21720 331520 0 0 $X=-22150 $Y=330880
X64301 1 2 4954 4826 4994 DFRQ_5VX1 $T=-21160 232960 0 0 $X=-21590 $Y=232320
X64302 1 2 4902 5050 4838 DFRQ_5VX1 $T=-20600 367360 1 0 $X=-21030 $Y=362240
X64303 1 2 4932 4914 5025 DFRQ_5VX1 $T=-20040 250880 0 0 $X=-20470 $Y=250240
X64304 1 2 8945 4914 8968 DFRQ_5VX1 $T=-19480 259840 0 0 $X=-19910 $Y=259200
X64305 1 2 4960 4914 4998 DFRQ_5VX1 $T=-17800 250880 1 0 $X=-18230 $Y=245760
X64306 1 2 4995 4826 8946 DFRQ_5VX1 $T=-2680 403200 0 180 $X=-17670 $Y=398080
X64307 1 2 4988 4826 5044 DFRQ_5VX1 $T=-17240 412160 0 0 $X=-17670 $Y=411520
X64308 1 2 4980 5050 5061 DFRQ_5VX1 $T=-16680 358400 0 0 $X=-17110 $Y=357760
X64309 1 2 4981 4826 5000 DFRQ_5VX1 $T=-16680 421120 0 0 $X=-17110 $Y=420480
X64310 1 2 4907 4914 5067 DFRQ_5VX1 $T=-15000 241920 0 0 $X=-15430 $Y=241280
X64311 1 2 4972 5050 8988 DFRQ_5VX1 $T=-13880 385280 0 0 $X=-14310 $Y=384640
X64312 1 2 5002 5050 4928 DFRQ_5VX1 $T=-11640 376320 1 0 $X=-12070 $Y=371200
X64313 1 2 5030 5095 5174 DFRQ_5VX1 $T=-10520 224000 0 0 $X=-10950 $Y=223360
X64314 1 2 5090 5524 743 DFRQ_5VX1 $T=5160 89600 1 180 $X=-9830 $Y=88960
X64315 1 2 5040 5064 4682 DFRQ_5VX1 $T=-9400 206080 0 0 $X=-9830 $Y=205440
X64316 1 2 4837 4914 5321 DFRQ_5VX1 $T=-8840 259840 1 0 $X=-9270 $Y=254720
X64317 1 2 9803 5064 5132 DFRQ_5VX1 $T=-7160 206080 1 0 $X=-7590 $Y=200960
X64318 1 2 5065 5095 5146 DFRQ_5VX1 $T=-6040 232960 0 0 $X=-6470 $Y=232320
X64319 1 2 5077 5095 9012 DFRQ_5VX1 $T=-4920 215040 0 0 $X=-5350 $Y=214400
X64320 1 2 5120 5095 4993 DFRQ_5VX1 $T=9640 224000 0 180 $X=-5350 $Y=218880
X64321 1 2 4692 5050 9004 DFRQ_5VX1 $T=-4920 385280 1 0 $X=-5350 $Y=380160
X64322 1 2 5015 5159 5057 DFRQ_5VX1 $T=-4920 394240 1 0 $X=-5350 $Y=389120
X64323 1 2 8990 5140 5109 DFRQ_5VX1 $T=-2680 250880 1 0 $X=-3110 $Y=245760
X64324 1 2 9008 5461 3990 DFRQ_5VX1 $T=13560 71680 0 180 $X=-1430 $Y=66560
X64325 1 2 5066 5140 5175 DFRQ_5VX1 $T=120 241920 0 0 $X=-310 $Y=241280
X64326 1 2 5126 5159 9025 DFRQ_5VX1 $T=1240 412160 1 0 $X=810 $Y=407040
X64327 1 2 4580 5095 5282 DFRQ_5VX1 $T=4040 224000 0 0 $X=3610 $Y=223360
X64328 1 2 5070 5159 767 DFRQ_5VX1 $T=4040 403200 1 0 $X=3610 $Y=398080
X64329 1 2 5037 5095 9049 DFRQ_5VX1 $T=8520 232960 0 0 $X=8090 $Y=232320
X64330 1 2 4425 5064 5260 DFRQ_5VX1 $T=9080 215040 1 0 $X=8650 $Y=209920
X64331 1 2 5160 5159 5267 DFRQ_5VX1 $T=10200 412160 0 0 $X=9770 $Y=411520
X64332 1 2 5222 5245 5318 DFRQ_5VX1 $T=14680 313600 0 0 $X=14250 $Y=312960
X64333 1 2 4530 5064 5220 DFRQ_5VX1 $T=30360 232960 0 180 $X=15370 $Y=227840
X64334 1 2 5099 5159 5350 DFRQ_5VX1 $T=16360 412160 1 0 $X=15930 $Y=407040
X64335 1 2 5238 5064 5292 DFRQ_5VX1 $T=16920 206080 0 0 $X=16490 $Y=205440
X64336 1 2 5283 5140 5358 DFRQ_5VX1 $T=20840 250880 1 0 $X=20410 $Y=245760
X64337 1 2 5294 5245 5677 DFRQ_5VX1 $T=21960 259840 0 0 $X=21530 $Y=259200
X64338 1 2 5295 5245 5368 DFRQ_5VX1 $T=21960 295680 1 0 $X=21530 $Y=290560
X64339 1 2 5305 5245 5384 DFRQ_5VX1 $T=23080 268800 0 0 $X=22650 $Y=268160
X64340 1 2 4843 5245 5401 DFRQ_5VX1 $T=23080 286720 0 0 $X=22650 $Y=286080
X64341 1 2 4820 5140 4955 DFRQ_5VX1 $T=23640 250880 0 0 $X=23210 $Y=250240
X64342 1 2 5327 5363 6117 DFRQ_5VX1 $T=25320 331520 1 0 $X=24890 $Y=326400
X64343 1 2 8994 5159 5423 DFRQ_5VX1 $T=25320 412160 0 0 $X=24890 $Y=411520
X64344 1 2 5293 5140 5413 DFRQ_5VX1 $T=26440 241920 0 0 $X=26010 $Y=241280
X64345 1 2 5340 5363 5742 DFRQ_5VX1 $T=27000 313600 1 0 $X=26570 $Y=308480
X64346 1 2 5339 5363 5430 DFRQ_5VX1 $T=27560 304640 0 0 $X=27130 $Y=304000
X64347 1 2 5349 5363 5369 DFRQ_5VX1 $T=27560 322560 1 0 $X=27130 $Y=317440
X64348 1 2 5354 5363 5631 DFRQ_5VX1 $T=29240 313600 0 0 $X=28810 $Y=312960
X64349 1 2 6445 5363 5439 DFRQ_5VX1 $T=29240 331520 0 0 $X=28810 $Y=330880
X64350 1 2 9065 5363 6116 DFRQ_5VX1 $T=30360 340480 0 0 $X=29930 $Y=339840
X64351 1 2 5373 5396 5425 DFRQ_5VX1 $T=31480 188160 1 0 $X=31050 $Y=183040
X64352 1 2 4620 9070 9083 DFRQ_5VX1 $T=31480 232960 0 0 $X=31050 $Y=232320
X64353 1 2 5252 5363 5486 DFRQ_5VX1 $T=32600 349440 1 0 $X=32170 $Y=344320
X64354 1 2 5480 5396 9863 DFRQ_5VX1 $T=33160 206080 0 0 $X=32730 $Y=205440
X64355 1 2 5285 5521 5487 DFRQ_5VX1 $T=34280 358400 1 0 $X=33850 $Y=353280
X64356 1 2 5446 5521 5514 DFRQ_5VX1 $T=34280 367360 0 0 $X=33850 $Y=366720
X64357 1 2 5299 5521 5499 DFRQ_5VX1 $T=34840 349440 0 0 $X=34410 $Y=348800
X64358 1 2 5414 5521 5513 DFRQ_5VX1 $T=35960 367360 1 0 $X=35530 $Y=362240
X64359 1 2 9084 5461 9119 DFRQ_5VX1 $T=41000 44800 0 0 $X=40570 $Y=44160
X64360 1 2 5395 5396 9121 DFRQ_5VX1 $T=41000 170240 1 0 $X=40570 $Y=165120
X64361 1 2 5460 5549 9111 DFRQ_5VX1 $T=41560 412160 0 0 $X=41130 $Y=411520
X64362 1 2 5456 5619 9972 DFRQ_5VX1 $T=42120 152320 1 0 $X=41690 $Y=147200
X64363 1 2 5523 5461 5123 DFRQ_5VX1 $T=57240 62720 0 180 $X=42250 $Y=57600
X64364 1 2 9086 9070 9973 DFRQ_5VX1 $T=42680 224000 0 0 $X=42250 $Y=223360
X64365 1 2 9091 5619 9120 DFRQ_5VX1 $T=43240 125440 0 0 $X=42810 $Y=124800
X64366 1 2 5478 5461 5532 DFRQ_5VX1 $T=44360 71680 1 0 $X=43930 $Y=66560
X64367 1 2 5492 9070 9974 DFRQ_5VX1 $T=44920 232960 1 0 $X=44490 $Y=227840
X64368 1 2 5496 5524 5533 DFRQ_5VX1 $T=45480 89600 0 0 $X=45050 $Y=88960
X64369 1 2 5498 5396 5506 DFRQ_5VX1 $T=45480 179200 0 0 $X=45050 $Y=178560
X64370 1 2 5501 5693 418 DFRQ_5VX1 $T=46040 17920 0 0 $X=45610 $Y=17280
X64371 1 2 5508 9070 5580 DFRQ_5VX1 $T=46600 232960 0 0 $X=46170 $Y=232320
X64372 1 2 5553 5396 9085 DFRQ_5VX1 $T=61720 197120 0 180 $X=46730 $Y=192000
X64373 1 2 5558 5619 9094 DFRQ_5VX1 $T=62280 116480 1 180 $X=47290 $Y=115840
X64374 1 2 5519 5396 9132 DFRQ_5VX1 $T=47720 161280 0 0 $X=47290 $Y=160640
X64375 1 2 9110 5549 5616 DFRQ_5VX1 $T=49400 403200 1 0 $X=48970 $Y=398080
X64376 1 2 5529 9070 5481 DFRQ_5VX1 $T=49960 241920 1 0 $X=49530 $Y=236800
X64377 1 2 9114 5676 5614 DFRQ_5VX1 $T=50520 206080 0 0 $X=50090 $Y=205440
X64378 1 2 5595 5524 770 DFRQ_5VX1 $T=65640 98560 1 180 $X=50650 $Y=97920
X64379 1 2 5596 5619 9103 DFRQ_5VX1 $T=65640 143360 0 180 $X=50650 $Y=138240
X64380 1 2 5493 5549 9139 DFRQ_5VX1 $T=51640 394240 0 0 $X=51210 $Y=393600
X64381 1 2 5610 5461 5247 DFRQ_5VX1 $T=67880 35840 1 180 $X=52890 $Y=35200
X64382 1 2 9106 9070 5652 DFRQ_5VX1 $T=53880 250880 0 0 $X=53450 $Y=250240
X64383 1 2 5564 9131 5671 DFRQ_5VX1 $T=54440 295680 0 0 $X=54010 $Y=295040
X64384 1 2 5371 5688 9144 DFRQ_5VX1 $T=55560 62720 0 0 $X=55130 $Y=62080
X64385 1 2 5574 9131 5661 DFRQ_5VX1 $T=55560 259840 0 0 $X=55130 $Y=259200
X64386 1 2 5582 9131 5670 DFRQ_5VX1 $T=56120 286720 0 0 $X=55690 $Y=286080
X64387 1 2 5586 5619 5674 DFRQ_5VX1 $T=56680 116480 1 0 $X=56250 $Y=111360
X64388 1 2 5236 5688 9127 DFRQ_5VX1 $T=71800 71680 1 180 $X=56810 $Y=71040
X64389 1 2 5604 5524 5694 DFRQ_5VX1 $T=58360 107520 1 0 $X=57930 $Y=102400
X64390 1 2 9865 5776 5635 DFRQ_5VX1 $T=60040 134400 1 0 $X=59610 $Y=129280
X64391 1 2 5642 5549 5720 DFRQ_5VX1 $T=60040 412160 1 0 $X=59610 $Y=407040
X64392 1 2 5622 5524 5708 DFRQ_5VX1 $T=60600 89600 0 0 $X=60170 $Y=88960
X64393 1 2 5625 5676 5709 DFRQ_5VX1 $T=60600 224000 1 0 $X=60170 $Y=218880
X64394 1 2 5628 5693 428 DFRQ_5VX1 $T=61160 44800 0 0 $X=60730 $Y=44160
X64395 1 2 9137 5619 9152 DFRQ_5VX1 $T=61160 152320 0 0 $X=60730 $Y=151680
X64396 1 2 9150 9143 5599 DFRQ_5VX1 $T=75720 179200 1 180 $X=60730 $Y=178560
X64397 1 2 9134 9143 5714 DFRQ_5VX1 $T=61160 188160 0 0 $X=60730 $Y=187520
X64398 1 2 5630 9131 5718 DFRQ_5VX1 $T=61160 277760 0 0 $X=60730 $Y=277120
X64399 1 2 5636 5676 5717 DFRQ_5VX1 $T=61720 232960 0 0 $X=61290 $Y=232320
X64400 1 2 5637 9131 5983 DFRQ_5VX1 $T=62280 268800 0 0 $X=61850 $Y=268160
X64401 1 2 5701 5911 9133 DFRQ_5VX1 $T=77400 170240 0 180 $X=62410 $Y=165120
X64402 1 2 5648 5693 5767 DFRQ_5VX1 $T=63960 26880 1 0 $X=63530 $Y=21760
X64403 1 2 5650 5688 432 DFRQ_5VX1 $T=63960 71680 1 0 $X=63530 $Y=66560
X64404 1 2 5651 5688 5771 DFRQ_5VX1 $T=63960 89600 1 0 $X=63530 $Y=84480
X64405 1 2 5655 5549 5754 DFRQ_5VX1 $T=63960 412160 0 0 $X=63530 $Y=411520
X64406 1 2 5659 5676 5750 DFRQ_5VX1 $T=64520 224000 0 0 $X=64090 $Y=223360
X64407 1 2 5662 9131 6464 DFRQ_5VX1 $T=64520 313600 1 0 $X=64090 $Y=308480
X64408 1 2 423 5693 433 DFRQ_5VX1 $T=65080 26880 0 0 $X=64650 $Y=26240
X64409 1 2 5666 5757 5758 DFRQ_5VX1 $T=65080 125440 1 0 $X=64650 $Y=120320
X64410 1 2 5680 5521 5762 DFRQ_5VX1 $T=66200 349440 0 0 $X=65770 $Y=348800
X64411 1 2 5682 5776 5764 DFRQ_5VX1 $T=66760 143360 1 0 $X=66330 $Y=138240
X64412 1 2 9138 5818 5702 DFRQ_5VX1 $T=66760 206080 1 0 $X=66330 $Y=200960
X64413 1 2 5687 9157 5788 DFRQ_5VX1 $T=66760 340480 1 0 $X=66330 $Y=335360
X64414 1 2 5689 5693 437 DFRQ_5VX1 $T=67320 35840 1 0 $X=66890 $Y=30720
X64415 1 2 5663 9157 5800 DFRQ_5VX1 $T=67880 331520 1 0 $X=67450 $Y=326400
X64416 1 2 5116 5688 439 DFRQ_5VX1 $T=68440 62720 1 0 $X=68010 $Y=57600
X64417 1 2 5755 5688 9975 DFRQ_5VX1 $T=83560 53760 1 180 $X=68570 $Y=53120
X64418 1 2 5713 5911 5798 DFRQ_5VX1 $T=70120 170240 0 0 $X=69690 $Y=169600
X64419 1 2 9156 9157 5899 DFRQ_5VX1 $T=70680 340480 0 0 $X=70250 $Y=339840
X64420 1 2 431 5693 441 DFRQ_5VX1 $T=71800 17920 0 0 $X=71370 $Y=17280
X64421 1 2 5729 5757 5804 DFRQ_5VX1 $T=71800 116480 1 0 $X=71370 $Y=111360
X64422 1 2 5732 5676 9976 DFRQ_5VX1 $T=71800 232960 1 0 $X=71370 $Y=227840
X64423 1 2 4053 5688 5828 DFRQ_5VX1 $T=72360 80640 0 0 $X=71930 $Y=80000
X64424 1 2 5735 5757 5763 DFRQ_5VX1 $T=72920 107520 1 0 $X=72490 $Y=102400
X64425 1 2 5738 5911 5813 DFRQ_5VX1 $T=72920 161280 0 0 $X=72490 $Y=160640
X64426 1 2 4524 5776 5824 DFRQ_5VX1 $T=73480 134400 0 0 $X=73050 $Y=133760
X64427 1 2 5744 5757 9171 DFRQ_5VX1 $T=74040 98560 1 0 $X=73610 $Y=93440
X64428 1 2 4747 5776 5950 DFRQ_5VX1 $T=75160 152320 1 0 $X=74730 $Y=147200
X64429 1 2 5573 5676 5811 DFRQ_5VX1 $T=75720 224000 1 0 $X=75290 $Y=218880
X64430 1 2 5768 9143 5862 DFRQ_5VX1 $T=76280 197120 1 0 $X=75850 $Y=192000
X64431 1 2 5723 5818 9179 DFRQ_5VX1 $T=76280 232960 0 0 $X=75850 $Y=232320
X64432 1 2 5772 9143 5872 DFRQ_5VX1 $T=76840 179200 0 0 $X=76410 $Y=178560
X64433 1 2 5775 5549 5801 DFRQ_5VX1 $T=76840 403200 1 0 $X=76410 $Y=398080
X64434 1 2 5779 5521 9183 DFRQ_5VX1 $T=77400 358400 0 0 $X=76970 $Y=357760
X64435 1 2 5845 5818 5783 DFRQ_5VX1 $T=93640 224000 1 180 $X=78650 $Y=223360
X64436 1 2 5577 5757 5797 DFRQ_5VX1 $T=79640 125440 1 0 $X=79210 $Y=120320
X64437 1 2 5793 5818 5898 DFRQ_5VX1 $T=79640 215040 1 0 $X=79210 $Y=209920
X64438 1 2 5814 5818 5897 DFRQ_5VX1 $T=81880 206080 1 0 $X=81450 $Y=200960
X64439 1 2 5817 5776 9185 DFRQ_5VX1 $T=82440 134400 1 0 $X=82010 $Y=129280
X64440 1 2 5830 5776 5921 DFRQ_5VX1 $T=83560 143360 0 0 $X=83130 $Y=142720
X64441 1 2 5838 5911 9190 DFRQ_5VX1 $T=84680 170240 0 0 $X=84250 $Y=169600
X64442 1 2 5853 5818 5913 DFRQ_5VX1 $T=86360 215040 0 0 $X=85930 $Y=214400
X64443 1 2 5104 5757 5965 DFRQ_5VX1 $T=87480 107520 1 0 $X=87050 $Y=102400
X64444 1 2 4888 5911 5946 DFRQ_5VX1 $T=87480 161280 0 0 $X=87050 $Y=160640
X64445 1 2 5873 5931 5943 DFRQ_5VX1 $T=87480 313600 0 0 $X=87050 $Y=312960
X64446 1 2 5875 5933 6009 DFRQ_5VX1 $T=88040 367360 1 0 $X=87610 $Y=362240
X64447 1 2 5886 5910 5970 DFRQ_5VX1 $T=89720 143360 1 0 $X=89290 $Y=138240
X64448 1 2 4791 5911 5976 DFRQ_5VX1 $T=89720 179200 1 0 $X=89290 $Y=174080
X64449 1 2 9182 5931 6689 DFRQ_5VX1 $T=89720 295680 0 0 $X=89290 $Y=295040
X64450 1 2 5896 5910 777 DFRQ_5VX1 $T=90840 161280 1 0 $X=90410 $Y=156160
X64451 1 2 4729 9143 6022 DFRQ_5VX1 $T=90840 197120 1 0 $X=90410 $Y=192000
X64452 1 2 9187 5931 5923 DFRQ_5VX1 $T=91400 331520 1 0 $X=90970 $Y=326400
X64453 1 2 5903 5933 9868 DFRQ_5VX1 $T=91400 403200 1 0 $X=90970 $Y=398080
X64454 1 2 4750 9143 6077 DFRQ_5VX1 $T=91960 188160 1 0 $X=91530 $Y=183040
X64455 1 2 5928 5933 6032 DFRQ_5VX1 $T=94200 412160 1 0 $X=93770 $Y=407040
X64456 1 2 5930 5931 5971 DFRQ_5VX1 $T=94760 304640 0 0 $X=94330 $Y=304000
X64457 1 2 6010 9157 9227 DFRQ_5VX1 $T=95880 340480 0 0 $X=95450 $Y=339840
X64458 1 2 6061 5933 9222 DFRQ_5VX1 $T=95880 394240 0 0 $X=95450 $Y=393600
X64459 1 2 5953 5931 6016 DFRQ_5VX1 $T=97000 331520 0 0 $X=96570 $Y=330880
X64460 1 2 5914 6127 6035 DFRQ_5VX1 $T=97560 224000 0 0 $X=97130 $Y=223360
X64461 1 2 5942 6127 6093 DFRQ_5VX1 $T=101480 215040 0 0 $X=101050 $Y=214400
X64462 1 2 5988 5910 6075 DFRQ_5VX1 $T=102040 161280 0 0 $X=101610 $Y=160640
X64463 1 2 6000 5931 9977 DFRQ_5VX1 $T=102600 322560 1 0 $X=102170 $Y=317440
X64464 1 2 5996 5910 6083 DFRQ_5VX1 $T=103160 170240 1 0 $X=102730 $Y=165120
X64465 1 2 5978 6158 6078 DFRQ_5VX1 $T=103160 206080 0 0 $X=102730 $Y=205440
X64466 1 2 6006 5910 6096 DFRQ_5VX1 $T=104280 143360 1 0 $X=103850 $Y=138240
X64467 1 2 6007 6127 6099 DFRQ_5VX1 $T=104280 232960 1 0 $X=103850 $Y=227840
X64468 1 2 6014 6076 9242 DFRQ_5VX1 $T=104840 179200 1 0 $X=104410 $Y=174080
X64469 1 2 5781 5933 6048 DFRQ_5VX1 $T=105960 403200 0 0 $X=105530 $Y=402560
X64470 1 2 6028 6158 9239 DFRQ_5VX1 $T=106520 197120 0 0 $X=106090 $Y=196480
X64471 1 2 6088 5910 5975 DFRQ_5VX1 $T=121640 152320 1 180 $X=106650 $Y=151680
X64472 1 2 6034 6127 6195 DFRQ_5VX1 $T=107640 232960 0 0 $X=107210 $Y=232320
X64473 1 2 6040 6076 6120 DFRQ_5VX1 $T=108200 188160 1 0 $X=107770 $Y=183040
X64474 1 2 6033 6127 6103 DFRQ_5VX1 $T=108200 224000 1 0 $X=107770 $Y=218880
X64475 1 2 6047 6127 6146 DFRQ_5VX1 $T=108760 241920 0 0 $X=108330 $Y=241280
X64476 1 2 6019 6104 6937 DFRQ_5VX1 $T=111000 259840 1 0 $X=110570 $Y=254720
X64477 1 2 6079 6104 6866 DFRQ_5VX1 $T=111560 268800 1 0 $X=111130 $Y=263680
X64478 1 2 6208 6158 9871 DFRQ_5VX1 $T=133400 206080 1 180 $X=118410 $Y=205440
X64479 1 2 6126 6158 9250 DFRQ_5VX1 $T=136200 197120 1 180 $X=121210 $Y=196480
X64480 1 2 6220 6076 9247 DFRQ_5VX1 $T=137320 179200 1 180 $X=122330 $Y=178560
X64481 1 2 6181 6158 6222 DFRQ_5VX1 $T=123320 206080 1 0 $X=122890 $Y=200960
X64482 1 2 6182 6158 6152 DFRQ_5VX1 $T=123320 215040 0 0 $X=122890 $Y=214400
X64483 1 2 6174 6213 9268 DFRQ_5VX1 $T=123320 295680 1 0 $X=122890 $Y=290560
X64484 1 2 7248 6076 9271 DFRQ_5VX1 $T=123880 170240 0 0 $X=123450 $Y=169600
X64485 1 2 5979 6213 6224 DFRQ_5VX1 $T=123880 304640 1 0 $X=123450 $Y=299520
X64486 1 2 6197 6213 6349 DFRQ_5VX1 $T=123880 313600 0 0 $X=123450 $Y=312960
X64487 1 2 6176 9157 9278 DFRQ_5VX1 $T=123880 349440 0 0 $X=123450 $Y=348800
X64488 1 2 9290 6474 9978 DFRQ_5VX1 $T=151880 125440 1 0 $X=151450 $Y=120320
X64489 1 2 6290 6076 9316 DFRQ_5VX1 $T=151880 179200 1 0 $X=151450 $Y=174080
X64490 1 2 6357 6076 6874 DFRQ_5VX1 $T=166440 179200 1 180 $X=151450 $Y=178560
X64491 1 2 7036 6332 6280 DFRQ_5VX1 $T=151880 224000 1 0 $X=151450 $Y=218880
X64492 1 2 6264 6213 6378 DFRQ_5VX1 $T=151880 304640 1 0 $X=151450 $Y=299520
X64493 1 2 6297 9299 9311 DFRQ_5VX1 $T=152440 152320 1 0 $X=152010 $Y=147200
X64494 1 2 6298 9299 6381 DFRQ_5VX1 $T=152440 170240 1 0 $X=152010 $Y=165120
X64495 1 2 9303 4826 9286 DFRQ_5VX1 $T=167000 215040 0 180 $X=152010 $Y=209920
X64496 1 2 9874 6332 6397 DFRQ_5VX1 $T=152440 224000 0 0 $X=152010 $Y=223360
X64497 1 2 6301 6336 9313 DFRQ_5VX1 $T=152440 313600 0 0 $X=152010 $Y=312960
X64498 1 2 6583 6336 6350 DFRQ_5VX1 $T=152440 322560 1 0 $X=152010 $Y=317440
X64499 1 2 6302 6336 6275 DFRQ_5VX1 $T=152440 340480 0 0 $X=152010 $Y=339840
X64500 1 2 6303 9243 6391 DFRQ_5VX1 $T=152440 367360 1 0 $X=152010 $Y=362240
X64501 1 2 6310 6336 6268 DFRQ_5VX1 $T=153000 331520 1 0 $X=152570 $Y=326400
X64502 1 2 6311 6336 6402 DFRQ_5VX1 $T=153000 331520 0 0 $X=152570 $Y=330880
X64503 1 2 6281 6104 6418 DFRQ_5VX1 $T=155800 259840 1 0 $X=155370 $Y=254720
X64504 1 2 9318 4826 9298 DFRQ_5VX1 $T=172600 197120 1 180 $X=157610 $Y=196480
X64505 1 2 6291 9299 6799 DFRQ_5VX1 $T=158600 188160 0 0 $X=158170 $Y=187520
X64506 1 2 6362 6336 6465 DFRQ_5VX1 $T=158600 349440 1 0 $X=158170 $Y=344320
X64507 1 2 9307 6386 6451 DFRQ_5VX1 $T=159720 62720 0 0 $X=159290 $Y=62080
X64508 1 2 6373 6104 6292 DFRQ_5VX1 $T=160280 268800 1 0 $X=159850 $Y=263680
X64509 1 2 6376 6386 9876 DFRQ_5VX1 $T=178760 80640 1 180 $X=163770 $Y=80000
X64510 1 2 6295 6474 9310 DFRQ_5VX1 $T=178760 107520 1 180 $X=163770 $Y=106880
X64511 1 2 6405 6433 6484 DFRQ_5VX1 $T=164760 35840 0 0 $X=164330 $Y=35200
X64512 1 2 9878 6474 9346 DFRQ_5VX1 $T=164760 98560 0 0 $X=164330 $Y=97920
X64513 1 2 6466 493 6380 DFRQ_5VX1 $T=181000 26880 0 180 $X=166010 $Y=21760
X64514 1 2 6468 6441 6388 DFRQ_5VX1 $T=181000 143360 1 180 $X=166010 $Y=142720
X64515 1 2 6476 9299 6396 DFRQ_5VX1 $T=181560 170240 0 180 $X=166570 $Y=165120
X64516 1 2 6427 9299 6437 DFRQ_5VX1 $T=167000 188160 1 0 $X=166570 $Y=183040
X64517 1 2 9880 6336 9324 DFRQ_5VX1 $T=181560 340480 1 180 $X=166570 $Y=339840
X64518 1 2 6439 6459 6449 DFRQ_5VX1 $T=168120 277760 1 0 $X=167690 $Y=272640
X64519 1 2 6423 6441 6434 DFRQ_5VX1 $T=168680 134400 1 0 $X=168250 $Y=129280
X64520 1 2 6438 6332 6513 DFRQ_5VX1 $T=168680 206080 0 0 $X=168250 $Y=205440
X64521 1 2 7046 6459 6443 DFRQ_5VX1 $T=168680 268800 0 0 $X=168250 $Y=268160
X64522 1 2 6442 6474 6497 DFRQ_5VX1 $T=169240 107520 1 0 $X=168810 $Y=102400
X64523 1 2 6448 6470 9348 DFRQ_5VX1 $T=169240 206080 1 0 $X=168810 $Y=200960
X64524 1 2 496 493 491 DFRQ_5VX1 $T=184360 17920 0 180 $X=169370 $Y=12800
X64525 1 2 7247 9299 9321 DFRQ_5VX1 $T=184360 152320 1 180 $X=169370 $Y=151680
X64526 1 2 6457 6474 6534 DFRQ_5VX1 $T=170360 116480 0 0 $X=169930 $Y=115840
X64527 1 2 6461 9243 6520 DFRQ_5VX1 $T=170920 358400 0 0 $X=170490 $Y=357760
X64528 1 2 6517 6386 9328 DFRQ_5VX1 $T=186600 89600 0 180 $X=171610 $Y=84480
X64529 1 2 6462 6474 6533 DFRQ_5VX1 $T=172040 116480 1 0 $X=171610 $Y=111360
X64530 1 2 6450 6459 6547 DFRQ_5VX1 $T=172040 286720 1 0 $X=171610 $Y=281600
X64531 1 2 6519 9243 9326 DFRQ_5VX1 $T=187160 376320 1 180 $X=172170 $Y=375680
X64532 1 2 6353 6433 9352 DFRQ_5VX1 $T=173720 53760 1 0 $X=173290 $Y=48640
X64533 1 2 6522 6386 6452 DFRQ_5VX1 $T=188280 71680 1 180 $X=173290 $Y=71040
X64534 1 2 9335 6591 500 DFRQ_5VX1 $T=173720 188160 0 0 $X=173290 $Y=187520
X64535 1 2 6527 6433 6375 DFRQ_5VX1 $T=188840 62720 0 180 $X=173850 $Y=57600
X64536 1 2 6528 6474 9330 DFRQ_5VX1 $T=188840 125440 0 180 $X=173850 $Y=120320
X64537 1 2 6490 9243 6512 DFRQ_5VX1 $T=174280 376320 1 0 $X=173850 $Y=371200
X64538 1 2 6487 6459 6518 DFRQ_5VX1 $T=174840 277760 0 0 $X=174410 $Y=277120
X64539 1 2 6542 493 6359 DFRQ_5VX1 $T=190520 26880 1 180 $X=175530 $Y=26240
X64540 1 2 6558 6433 6406 DFRQ_5VX1 $T=191640 44800 0 180 $X=176650 $Y=39680
X64541 1 2 784 9359 6581 DFRQ_5VX1 $T=177640 161280 0 0 $X=177210 $Y=160640
X64542 1 2 6577 6441 6504 DFRQ_5VX1 $T=194440 143360 0 180 $X=179450 $Y=138240
X64543 1 2 9357 6470 6505 DFRQ_5VX1 $T=195000 197120 1 180 $X=180010 $Y=196480
X64544 1 2 6535 6470 6630 DFRQ_5VX1 $T=181000 215040 1 0 $X=180570 $Y=209920
X64545 1 2 6508 6213 6561 DFRQ_5VX1 $T=181560 295680 0 0 $X=181130 $Y=295040
X64546 1 2 6564 493 509 DFRQ_5VX1 $T=184360 17920 1 0 $X=183930 $Y=12800
X64547 1 2 6567 9359 6647 DFRQ_5VX1 $T=184360 152320 0 0 $X=183930 $Y=151680
X64548 1 2 6568 6591 6631 DFRQ_5VX1 $T=184360 179200 1 0 $X=183930 $Y=174080
X64549 1 2 9344 6470 7049 DFRQ_5VX1 $T=184360 197120 1 0 $X=183930 $Y=192000
X64550 1 2 6579 6386 6475 DFRQ_5VX1 $T=186600 89600 1 0 $X=186170 $Y=84480
X64551 1 2 6586 9369 6646 DFRQ_5VX1 $T=187160 116480 1 0 $X=186730 $Y=111360
X64552 1 2 6589 9243 6642 DFRQ_5VX1 $T=187160 367360 1 0 $X=186730 $Y=362240
X64553 1 2 6598 6386 6322 DFRQ_5VX1 $T=188280 71680 0 0 $X=187850 $Y=71040
X64554 1 2 6644 6433 504 DFRQ_5VX1 $T=204520 62720 0 180 $X=189530 $Y=57600
X64555 1 2 6645 9369 6572 DFRQ_5VX1 $T=204520 80640 0 180 $X=189530 $Y=75520
X64556 1 2 9364 6332 6847 DFRQ_5VX1 $T=189960 224000 0 0 $X=189530 $Y=223360
X64557 1 2 6619 6441 6688 DFRQ_5VX1 $T=191080 134400 0 0 $X=190650 $Y=133760
X64558 1 2 7321 9369 6686 DFRQ_5VX1 $T=192200 107520 1 0 $X=191770 $Y=102400
X64559 1 2 6624 6433 518 DFRQ_5VX1 $T=192760 35840 0 0 $X=192330 $Y=35200
X64560 1 2 6674 9359 6594 DFRQ_5VX1 $T=207320 161280 1 180 $X=192330 $Y=160640
X64561 1 2 6627 6591 6704 DFRQ_5VX1 $T=192760 170240 0 0 $X=192330 $Y=169600
X64562 1 2 6668 6332 6499 DFRQ_5VX1 $T=207320 215040 1 180 $X=192330 $Y=214400
X64563 1 2 6625 6441 6698 DFRQ_5VX1 $T=193320 125440 0 0 $X=192890 $Y=124800
X64564 1 2 6663 6648 9360 DFRQ_5VX1 $T=207880 206080 1 180 $X=192890 $Y=205440
X64565 1 2 6675 6332 6601 DFRQ_5VX1 $T=207880 224000 0 180 $X=192890 $Y=218880
X64566 1 2 4841 9359 6705 DFRQ_5VX1 $T=193880 143360 0 0 $X=193450 $Y=142720
X64567 1 2 6678 6470 6600 DFRQ_5VX1 $T=208440 206080 0 180 $X=193450 $Y=200960
X64568 1 2 6682 9369 6355 DFRQ_5VX1 $T=209000 98560 0 180 $X=194010 $Y=93440
X64569 1 2 6621 6441 6717 DFRQ_5VX1 $T=194440 143360 1 0 $X=194010 $Y=138240
X64570 1 2 6640 9359 6711 DFRQ_5VX1 $T=194440 161280 1 0 $X=194010 $Y=156160
X64571 1 2 6635 6591 6712 DFRQ_5VX1 $T=194440 188160 0 0 $X=194010 $Y=187520
X64572 1 2 6695 9359 6455 DFRQ_5VX1 $T=209560 152320 0 180 $X=194570 $Y=147200
X64573 1 2 6634 6591 9954 DFRQ_5VX1 $T=195000 188160 1 0 $X=194570 $Y=183040
X64574 1 2 6637 6459 6713 DFRQ_5VX1 $T=195000 313600 0 0 $X=194570 $Y=312960
X64575 1 2 6696 6591 6628 DFRQ_5VX1 $T=210680 179200 1 180 $X=195690 $Y=178560
X64576 1 2 6656 6470 9939 DFRQ_5VX1 $T=196680 197120 0 0 $X=196250 $Y=196480
X64577 1 2 519 515 513 DFRQ_5VX1 $T=213480 17920 0 180 $X=198490 $Y=12800
X64578 1 2 6719 6648 9366 DFRQ_5VX1 $T=213480 215040 0 180 $X=198490 $Y=209920
X64579 1 2 7237 9369 6751 DFRQ_5VX1 $T=201720 116480 1 0 $X=201290 $Y=111360
X64580 1 2 6734 6648 6669 DFRQ_5VX1 $T=216280 232960 0 180 $X=201290 $Y=227840
X64581 1 2 6708 515 9410 DFRQ_5VX1 $T=203960 26880 1 0 $X=203530 $Y=21760
X64582 1 2 6750 9369 6693 DFRQ_5VX1 $T=219080 62720 1 180 $X=204090 $Y=62080
X64583 1 2 6714 6738 9411 DFRQ_5VX1 $T=205080 53760 0 0 $X=204650 $Y=53120
X64584 1 2 6766 6738 6643 DFRQ_5VX1 $T=223000 35840 1 180 $X=208010 $Y=35200
X64585 1 2 6756 6825 9391 DFRQ_5VX1 $T=223000 215040 1 180 $X=208010 $Y=214400
X64586 1 2 6742 6648 6894 DFRQ_5VX1 $T=208440 224000 1 0 $X=208010 $Y=218880
X64587 1 2 7243 6738 6729 DFRQ_5VX1 $T=224680 98560 0 180 $X=209690 $Y=93440
X64588 1 2 6748 6648 9436 DFRQ_5VX1 $T=210120 232960 0 0 $X=209690 $Y=232320
X64589 1 2 6791 6763 6909 DFRQ_5VX1 $T=226360 107520 0 180 $X=211370 $Y=102400
X64590 1 2 6789 6648 9399 DFRQ_5VX1 $T=226360 224000 1 180 $X=211370 $Y=223360
X64591 1 2 522 515 6837 DFRQ_5VX1 $T=213480 17920 1 0 $X=213050 $Y=12800
X64592 1 2 6828 6763 6716 DFRQ_5VX1 $T=230840 116480 0 180 $X=215850 $Y=111360
X64593 1 2 6793 6813 6860 DFRQ_5VX1 $T=217400 232960 1 0 $X=216970 $Y=227840
X64594 1 2 6800 6825 6859 DFRQ_5VX1 $T=218520 215040 1 0 $X=218090 $Y=209920
X64595 1 2 6804 6738 6862 DFRQ_5VX1 $T=219080 62720 0 0 $X=218650 $Y=62080
X64596 1 2 6851 6763 6776 DFRQ_5VX1 $T=234200 116480 1 180 $X=219210 $Y=115840
X64597 1 2 6864 6738 6779 DFRQ_5VX1 $T=237560 44800 0 180 $X=222570 $Y=39680
X64598 1 2 6877 6825 6841 DFRQ_5VX1 $T=240360 206080 0 180 $X=225370 $Y=200960
X64599 1 2 6870 6825 6834 DFRQ_5VX1 $T=240360 215040 1 180 $X=225370 $Y=214400
X64600 1 2 6878 6813 7053 DFRQ_5VX1 $T=240920 224000 1 180 $X=225930 $Y=223360
X64601 1 2 6884 6763 9435 DFRQ_5VX1 $T=242040 98560 0 180 $X=227050 $Y=93440
X64602 1 2 6889 6763 9886 DFRQ_5VX1 $T=244280 89600 1 180 $X=229290 $Y=88960
X64603 1 2 6879 6825 6827 DFRQ_5VX1 $T=244280 206080 1 180 $X=229290 $Y=205440
X64604 1 2 6891 6813 7242 DFRQ_5VX1 $T=244280 232960 1 180 $X=229290 $Y=232320
X64605 1 2 6895 6813 7135 DFRQ_5VX1 $T=245960 241920 1 180 $X=230970 $Y=241280
X64606 1 2 6835 6813 9441 DFRQ_5VX1 $T=246520 232960 0 180 $X=231530 $Y=227840
X64607 1 2 6900 6763 6838 DFRQ_5VX1 $T=247080 98560 1 180 $X=232090 $Y=97920
X64608 1 2 6902 6825 6846 DFRQ_5VX1 $T=247640 215040 0 180 $X=232650 $Y=209920
X64609 1 2 6911 6912 6876 DFRQ_5VX1 $T=249880 116480 1 180 $X=234890 $Y=115840
X64610 1 2 6921 7016 9979 DFRQ_5VX1 $T=252120 107520 0 180 $X=237130 $Y=102400
X64611 1 2 6927 6771 9453 DFRQ_5VX1 $T=252120 179200 1 180 $X=237130 $Y=178560
X64612 1 2 6923 6912 9456 DFRQ_5VX1 $T=253240 125440 1 180 $X=238250 $Y=124800
X64613 1 2 6924 6912 6890 DFRQ_5VX1 $T=253240 143360 1 180 $X=238250 $Y=142720
X64614 1 2 7000 6771 6820 DFRQ_5VX1 $T=255480 206080 0 180 $X=240490 $Y=200960
X64615 1 2 6934 6925 6978 DFRQ_5VX1 $T=256040 152320 1 180 $X=241050 $Y=151680
X64616 1 2 6948 6925 6898 DFRQ_5VX1 $T=257160 170240 0 180 $X=242170 $Y=165120
X64617 1 2 6958 6771 9460 DFRQ_5VX1 $T=259400 215040 1 180 $X=244410 $Y=214400
X64618 1 2 6967 7016 9955 DFRQ_5VX1 $T=261080 107520 1 180 $X=246090 $Y=106880
X64619 1 2 6963 6925 6916 DFRQ_5VX1 $T=261080 161280 1 180 $X=246090 $Y=160640
X64620 1 2 6964 6771 9426 DFRQ_5VX1 $T=262760 188160 1 180 $X=247770 $Y=187520
X64621 1 2 6980 6771 5760 DFRQ_5VX1 $T=263880 215040 0 180 $X=248890 $Y=209920
X64622 1 2 6991 6912 9887 DFRQ_5VX1 $T=265560 143360 0 180 $X=250570 $Y=138240
X64623 1 2 7009 6912 6960 DFRQ_5VX1 $T=268920 125440 0 180 $X=253930 $Y=120320
X64624 1 2 7019 6912 6942 DFRQ_5VX1 $T=270040 134400 0 180 $X=255050 $Y=129280
X64625 1 2 7028 7016 6983 DFRQ_5VX1 $T=272840 89600 1 180 $X=257850 $Y=88960
X64626 1 2 7481 7016 794 DFRQ_5VX1 $T=272840 98560 0 180 $X=257850 $Y=93440
X64627 1 2 7043 7016 9468 DFRQ_5VX1 $T=273400 116480 0 180 $X=258410 $Y=111360
X64628 1 2 7059 9478 9980 DFRQ_5VX1 $T=277320 107520 0 180 $X=262330 $Y=102400
X64629 1 2 7068 6925 9473 DFRQ_5VX1 $T=279560 170240 0 180 $X=264570 $Y=165120
X64630 1 2 7074 6925 9474 DFRQ_5VX1 $T=280120 143360 0 180 $X=265130 $Y=138240
X64631 1 2 7087 6925 9471 DFRQ_5VX1 $T=281240 152320 1 180 $X=266250 $Y=151680
X64632 1 2 7100 7170 6935 DFRQ_5VX1 $T=284040 215040 0 180 $X=269050 $Y=209920
X64633 1 2 7102 9478 9481 DFRQ_5VX1 $T=284600 125440 0 180 $X=269610 $Y=120320
X64634 1 2 7142 9478 9490 DFRQ_5VX1 $T=292440 98560 0 180 $X=277450 $Y=93440
X64635 1 2 7116 9478 9515 DFRQ_5VX1 $T=279000 80640 0 0 $X=278570 $Y=80000
X64636 1 2 7177 9478 7105 DFRQ_5VX1 $T=299160 116480 1 180 $X=284170 $Y=115840
X64637 1 2 7192 7170 7108 DFRQ_5VX1 $T=300840 206080 1 180 $X=285850 $Y=205440
X64638 1 2 7201 7170 7111 DFRQ_5VX1 $T=303080 188160 1 180 $X=288090 $Y=187520
X64639 1 2 7206 7189 9508 DFRQ_5VX1 $T=304200 71680 0 180 $X=289210 $Y=66560
X64640 1 2 7256 7170 7159 DFRQ_5VX1 $T=316520 206080 1 180 $X=301530 $Y=205440
X64641 1 2 7264 7369 7220 DFRQ_5VX1 $T=317640 188160 1 180 $X=302650 $Y=187520
X64642 1 2 7265 7170 797 DFRQ_5VX1 $T=317640 197120 0 180 $X=302650 $Y=192000
X64643 1 2 7413 7170 9525 DFRQ_5VX1 $T=323800 206080 0 180 $X=308810 $Y=200960
X64644 1 2 9560 7349 7017 DFRQ_5VX1 $T=331080 161280 0 180 $X=316090 $Y=156160
X64645 1 2 7317 7369 7076 DFRQ_5VX1 $T=331080 179200 1 180 $X=316090 $Y=178560
X64646 1 2 7304 7319 7274 DFRQ_5VX1 $T=318760 134400 1 0 $X=318330 $Y=129280
X64647 1 2 7325 7369 7300 DFRQ_5VX1 $T=333320 179200 0 180 $X=318330 $Y=174080
X64648 1 2 7328 7349 7289 DFRQ_5VX1 $T=333880 161280 1 180 $X=318890 $Y=160640
X64649 1 2 7333 7319 7174 DFRQ_5VX1 $T=337800 116480 0 180 $X=322810 $Y=111360
X64650 1 2 7351 7319 6952 DFRQ_5VX1 $T=338360 116480 1 180 $X=323370 $Y=115840
X64651 1 2 9570 7189 7313 DFRQ_5VX1 $T=340600 71680 1 180 $X=325610 $Y=71040
X64652 1 2 7363 7369 9556 DFRQ_5VX1 $T=340600 188160 0 180 $X=325610 $Y=183040
X64653 1 2 9572 7349 7010 DFRQ_5VX1 $T=341160 143360 0 180 $X=326170 $Y=138240
X64654 1 2 9574 7189 9562 DFRQ_5VX1 $T=342280 44800 1 180 $X=327290 $Y=44160
X64655 1 2 9573 7319 7309 DFRQ_5VX1 $T=342280 98560 1 180 $X=327290 $Y=97920
X64656 1 2 7361 7319 7273 DFRQ_5VX1 $T=343400 89600 0 180 $X=328410 $Y=84480
X64657 1 2 7392 7349 7012 DFRQ_5VX1 $T=343960 170240 1 180 $X=328970 $Y=169600
X64658 1 2 9577 7189 7331 DFRQ_5VX1 $T=345080 71680 0 180 $X=330090 $Y=66560
X64659 1 2 7381 7189 7347 DFRQ_5VX1 $T=345640 53760 1 180 $X=330650 $Y=53120
X64660 1 2 9569 7349 7400 DFRQ_5VX1 $T=331080 152320 1 0 $X=330650 $Y=147200
X64661 1 2 9579 7369 6998 DFRQ_5VX1 $T=346200 179200 1 180 $X=331210 $Y=178560
X64662 1 2 7383 7369 9565 DFRQ_5VX1 $T=346200 197120 0 180 $X=331210 $Y=192000
X64663 1 2 7401 7349 7294 DFRQ_5VX1 $T=349560 161280 1 180 $X=334570 $Y=160640
X64664 1 2 7461 611 7379 DFRQ_5VX1 $T=354600 17920 1 180 $X=339610 $Y=17280
X64665 1 2 7437 611 9576 DFRQ_5VX1 $T=356280 35840 1 180 $X=341290 $Y=35200
X64666 1 2 7436 6985 7387 DFRQ_5VX1 $T=356280 215040 0 180 $X=341290 $Y=209920
X64667 1 2 9594 611 9580 DFRQ_5VX1 $T=357400 26880 1 180 $X=342410 $Y=26240
X64668 1 2 7448 6985 7502 DFRQ_5VX1 $T=349000 224000 1 0 $X=348570 $Y=218880
X64669 1 2 7506 6985 7464 DFRQ_5VX1 $T=370280 206080 1 180 $X=355290 $Y=205440
X64670 1 2 621 611 9592 DFRQ_5VX1 $T=371400 17920 0 180 $X=356410 $Y=12800
X64671 1 2 7532 6985 7362 DFRQ_5VX1 $T=376440 197120 1 180 $X=361450 $Y=196480
X64672 1 2 9629 6985 9610 DFRQ_5VX1 $T=378120 224000 0 180 $X=363130 $Y=218880
X64673 1 2 7547 6985 7582 DFRQ_5VX1 $T=373080 197120 1 0 $X=372650 $Y=192000
X64674 1 2 7612 6985 9620 DFRQ_5VX1 $T=387640 206080 0 180 $X=372650 $Y=200960
X64675 1 2 9666 7063 9644 DFRQ_5VX1 $T=417880 206080 1 180 $X=402890 $Y=205440
X64676 1 2 7677 7063 7640 DFRQ_5VX1 $T=430760 215040 0 180 $X=415770 $Y=209920
X64677 1 2 7689 7101 9692 DFRQ_5VX1 $T=425160 161280 0 0 $X=424730 $Y=160640
X64678 1 2 9690 7063 9686 DFRQ_5VX1 $T=445880 215040 0 180 $X=430890 $Y=209920
X64679 1 2 7734 7101 9981 DFRQ_5VX1 $T=447000 170240 0 180 $X=432010 $Y=165120
X64680 1 2 7723 7101 9723 DFRQ_5VX1 $T=434680 143360 1 0 $X=434250 $Y=138240
X64681 1 2 9695 7101 7747 DFRQ_5VX1 $T=435800 152320 1 0 $X=435370 $Y=147200
X64682 1 2 9709 7101 7722 DFRQ_5VX1 $T=452600 125440 1 180 $X=437610 $Y=124800
X64683 1 2 7754 7101 7727 DFRQ_5VX1 $T=453720 116480 1 180 $X=438730 $Y=115840
X64684 1 2 7738 7063 9983 DFRQ_5VX1 $T=439160 188160 0 0 $X=438730 $Y=187520
X64685 1 2 7795 7063 9698 DFRQ_5VX1 $T=455400 197120 1 180 $X=440410 $Y=196480
X64686 1 2 7750 7757 9726 DFRQ_5VX1 $T=443080 107520 1 0 $X=442650 $Y=102400
X64687 1 2 9730 7757 9732 DFRQ_5VX1 $T=444760 89600 0 0 $X=444330 $Y=88960
X64688 1 2 9728 7757 7760 DFRQ_5VX1 $T=452600 98560 1 0 $X=452170 $Y=93440
X64689 1 2 9734 7757 9982 DFRQ_5VX1 $T=467720 107520 1 180 $X=452730 $Y=106880
X64690 1 2 7776 7190 9736 DFRQ_5VX1 $T=454280 206080 1 0 $X=453850 $Y=200960
X64691 1 2 7797 7190 7816 DFRQ_5VX1 $T=459880 179200 1 0 $X=459450 $Y=174080
X64692 1 2 9739 7820 7822 DFRQ_5VX1 $T=463800 161280 1 0 $X=463370 $Y=156160
X64693 1 2 7881 7190 9747 DFRQ_5VX1 $T=463800 188160 0 0 $X=463370 $Y=187520
X64694 1 2 7910 7820 7810 DFRQ_5VX1 $T=464360 170240 1 0 $X=463930 $Y=165120
X64695 1 2 9741 7820 9744 DFRQ_5VX1 $T=484520 143360 1 180 $X=469530 $Y=142720
X64696 1 2 7827 7820 7843 DFRQ_5VX1 $T=470520 143360 1 0 $X=470090 $Y=138240
X64697 1 2 7834 7757 7892 DFRQ_5VX1 $T=473880 107520 1 0 $X=473450 $Y=102400
X64698 1 2 7837 7847 7796 DFRQ_5VX1 $T=475560 125440 1 0 $X=475130 $Y=120320
X64699 1 2 7839 7847 9771 DFRQ_5VX1 $T=476120 116480 1 0 $X=475690 $Y=111360
X64700 1 2 7861 7190 9752 DFRQ_5VX1 $T=492360 170240 1 180 $X=477370 $Y=169600
X64701 1 2 7897 7190 7836 DFRQ_5VX1 $T=492920 188160 0 180 $X=477930 $Y=183040
X64702 1 2 7869 7820 9754 DFRQ_5VX1 $T=495160 170240 0 180 $X=480170 $Y=165120
X64703 1 2 7853 7820 7859 DFRQ_5VX1 $T=481720 152320 0 0 $X=481290 $Y=151680
X64704 1 2 9759 7757 9774 DFRQ_5VX1 $T=482280 89600 0 0 $X=481850 $Y=88960
X64705 1 2 7878 7866 7831 DFRQ_5VX1 $T=497960 62720 1 180 $X=482970 $Y=62080
X64706 1 2 9764 7847 7877 DFRQ_5VX1 $T=483960 98560 0 0 $X=483530 $Y=97920
X64707 1 2 9765 7866 7879 DFRQ_5VX1 $T=484520 80640 1 0 $X=484090 $Y=75520
X64708 1 2 7887 7866 9762 DFRQ_5VX1 $T=501880 44800 1 180 $X=486890 $Y=44160
X64709 1 2 7889 7847 7858 DFRQ_5VX1 $T=502440 134400 1 180 $X=487450 $Y=133760
X64710 1 2 7884 7847 7891 DFRQ_5VX1 $T=491240 116480 0 0 $X=490810 $Y=115840
X64711 1 2 9778 7866 7913 DFRQ_5VX1 $T=496840 62720 1 0 $X=496410 $Y=57600
X64712 1 2 7907 7847 7888 DFRQ_5VX1 $T=511400 98560 0 180 $X=496410 $Y=93440
X64713 1 2 7880 7866 9776 DFRQ_5VX1 $T=511960 89600 0 180 $X=496970 $Y=84480
X64714 1 2 7899 7866 9787 DFRQ_5VX1 $T=498520 80640 0 0 $X=498090 $Y=80000
X64715 1 2 7914 690 7894 DFRQ_5VX1 $T=514200 35840 1 180 $X=499210 $Y=35200
X64716 1 2 9788 690 688 DFRQ_5VX1 $T=515320 17920 0 180 $X=500330 $Y=12800
X64717 1 2 7916 7866 9782 DFRQ_5VX1 $T=515880 71680 0 180 $X=500890 $Y=66560
X64718 1 2 7912 690 9784 DFRQ_5VX1 $T=518680 44800 1 180 $X=503690 $Y=44160
X64719 1 2 7915 690 7898 DFRQ_5VX1 $T=523160 26880 1 180 $X=508170 $Y=26240
X64720 1 2 1075 1070 1174 1074 1079 AN211_5VX1 $T=-533000 232960 1 0 $X=-533430 $Y=227840
X64721 1 2 1776 8162 1902 1796 1771 AN211_5VX1 $T=-422680 125440 0 0 $X=-423110 $Y=124800
X64722 1 2 8413 2783 2878 2863 2843 AN211_5VX1 $T=-275960 313600 1 0 $X=-276390 $Y=308480
X64723 1 2 3879 3889 3910 3896 3872 AN211_5VX1 $T=-152760 215040 1 0 $X=-153190 $Y=209920
X64724 1 2 5196 9013 5130 9027 5154 AN211_5VX1 $T=13560 304640 1 180 $X=8090 $Y=304000
X64725 1 2 6471 6463 6500 6477 6482 AN211_5VX1 $T=177080 250880 0 0 $X=176650 $Y=250240
X64726 1 2 7522 7495 7500 7515 7511 AN211_5VX1 $T=371400 98560 0 180 $X=365930 $Y=93440
X64727 1 2 6833 9437 6869 540 EO3_5VX2 $T=230280 197120 0 0 $X=229850 $Y=196480
X64728 1 2 4563 4571 IN_5VX0 $T=-64840 143360 0 0 $X=-65270 $Y=142720
X64729 1 2 876 910 907 891 823 AO22_5VX1 $T=-571080 179200 0 180 $X=-577670 $Y=174080
X64730 1 2 857 910 907 900 825 AO22_5VX1 $T=-568280 215040 0 180 $X=-574870 $Y=209920
X64731 1 2 705 910 907 904 819 AO22_5VX1 $T=-567720 161280 0 180 $X=-574310 $Y=156160
X64732 1 2 7941 910 907 915 831 AO22_5VX1 $T=-567720 232960 1 180 $X=-574310 $Y=232320
X64733 1 2 7940 910 907 906 820 AO22_5VX1 $T=-567160 188160 1 180 $X=-573750 $Y=187520
X64734 1 2 924 910 907 706 818 AO22_5VX1 $T=-564360 134400 0 180 $X=-570950 $Y=129280
X64735 1 2 941 910 907 929 824 AO22_5VX1 $T=-560440 161280 0 180 $X=-567030 $Y=156160
X64736 1 2 916 910 907 932 808 AO22_5VX1 $T=-559880 250880 1 180 $X=-566470 $Y=250240
X64737 1 2 911 910 907 938 821 AO22_5VX1 $T=-558760 224000 0 180 $X=-565350 $Y=218880
X64738 1 2 7947 910 907 944 918 AO22_5VX1 $T=-564360 259840 1 0 $X=-564790 $Y=254720
X64739 1 2 884 910 907 957 919 AO22_5VX1 $T=-557080 241920 0 180 $X=-563670 $Y=236800
X64740 1 2 903 910 907 985 852 AO22_5VX1 $T=-562120 134400 1 0 $X=-562550 $Y=129280
X64741 1 2 914 910 907 956 813 AO22_5VX1 $T=-561000 143360 1 0 $X=-561430 $Y=138240
X64742 1 2 7951 910 907 942 966 AO22_5VX1 $T=-559320 125440 1 0 $X=-559750 $Y=120320
X64743 1 2 982 910 907 962 988 AO22_5VX1 $T=-544200 277760 0 180 $X=-550790 $Y=272640
X64744 1 2 950 910 907 980 838 AO22_5VX1 $T=-547000 125440 0 0 $X=-547430 $Y=124800
X64745 1 2 959 910 907 1023 885 AO22_5VX1 $T=-547000 268800 1 0 $X=-547430 $Y=263680
X64746 1 2 990 910 907 994 948 AO22_5VX1 $T=-547000 277760 0 0 $X=-547430 $Y=277120
X64747 1 2 1081 910 907 1090 1059 AO22_5VX1 $T=-525720 295680 0 180 $X=-532310 $Y=290560
X64748 1 2 1064 910 907 1108 889 AO22_5VX1 $T=-525160 286720 0 180 $X=-531750 $Y=281600
X64749 1 2 8004 910 907 1111 8014 AO22_5VX1 $T=-524600 304640 1 0 $X=-525030 $Y=299520
X64750 1 2 1191 910 907 1202 1029 AO22_5VX1 $T=-504440 295680 1 180 $X=-511030 $Y=295040
X64751 1 2 8058 910 907 1238 9815 AO22_5VX1 $T=-498840 322560 1 180 $X=-505430 $Y=321920
X64752 1 2 1237 910 907 1216 8056 AO22_5VX1 $T=-502760 304640 0 0 $X=-503190 $Y=304000
X64753 1 2 8064 910 907 1301 1348 AO22_5VX1 $T=-489880 304640 0 0 $X=-490310 $Y=304000
X64754 1 2 1368 910 907 1339 1311 AO22_5VX1 $T=-483160 322560 1 180 $X=-489750 $Y=321920
X64755 1 2 1398 910 907 1411 9817 AO22_5VX1 $T=-477000 322560 1 0 $X=-477430 $Y=317440
X64756 1 2 1433 910 907 1454 1470 AO22_5VX1 $T=-470840 340480 1 0 $X=-471270 $Y=335360
X64757 1 2 8123 910 907 1510 1450 AO22_5VX1 $T=-454600 313600 1 180 $X=-461190 $Y=312960
X64758 1 2 1548 910 907 1599 1638 AO22_5VX1 $T=-449000 322560 1 0 $X=-449430 $Y=317440
X64759 1 2 1618 910 907 1594 1582 AO22_5VX1 $T=-442280 313600 0 180 $X=-448870 $Y=308480
X64760 1 2 1601 910 907 1623 1668 AO22_5VX1 $T=-445640 331520 0 0 $X=-446070 $Y=330880
X64761 1 2 1556 910 907 1768 1658 AO22_5VX1 $T=-443960 331520 1 0 $X=-444390 $Y=326400
X64762 1 2 2293 724 725 2514 2187 AO22_5VX1 $T=-317960 259840 0 180 $X=-324550 $Y=254720
X64763 1 2 2292 724 725 2524 2549 AO22_5VX1 $T=-323560 224000 1 0 $X=-323990 $Y=218880
X64764 1 2 2252 724 725 2515 1855 AO22_5VX1 $T=-316280 286720 1 180 $X=-322870 $Y=286080
X64765 1 2 2503 724 725 2560 2637 AO22_5VX1 $T=-315720 241920 1 180 $X=-322310 $Y=241280
X64766 1 2 2376 724 725 2525 2486 AO22_5VX1 $T=-315720 259840 1 180 $X=-322310 $Y=259200
X64767 1 2 9985 724 725 2593 2127 AO22_5VX1 $T=-319640 304640 1 0 $X=-320070 $Y=299520
X64768 1 2 2488 724 725 8382 2553 AO22_5VX1 $T=-317960 340480 0 0 $X=-318390 $Y=339840
X64769 1 2 2532 724 725 2561 2244 AO22_5VX1 $T=-311240 268800 1 180 $X=-317830 $Y=268160
X64770 1 2 2443 724 725 2563 2544 AO22_5VX1 $T=-311240 295680 0 180 $X=-317830 $Y=290560
X64771 1 2 2374 724 725 2606 2294 AO22_5VX1 $T=-311240 313600 1 180 $X=-317830 $Y=312960
X64772 1 2 2387 724 725 2587 2286 AO22_5VX1 $T=-317400 322560 0 0 $X=-317830 $Y=321920
X64773 1 2 2493 724 725 2564 2457 AO22_5VX1 $T=-311240 331520 1 180 $X=-317830 $Y=330880
X64774 1 2 2602 724 725 2573 2558 AO22_5VX1 $T=-309560 224000 0 180 $X=-316150 $Y=218880
X64775 1 2 2554 724 725 2651 2296 AO22_5VX1 $T=-297800 349440 1 180 $X=-304390 $Y=348800
X64776 1 2 2608 724 725 2676 2302 AO22_5VX1 $T=-302840 358400 0 0 $X=-303270 $Y=357760
X64777 1 2 8385 724 725 2686 8374 AO22_5VX1 $T=-294440 224000 0 180 $X=-301030 $Y=218880
X64778 1 2 2663 724 725 2716 2697 AO22_5VX1 $T=-291640 206080 1 180 $X=-298230 $Y=205440
X64779 1 2 2677 724 725 2752 2287 AO22_5VX1 $T=-288840 358400 1 180 $X=-295430 $Y=357760
X64780 1 2 2712 724 725 8397 2334 AO22_5VX1 $T=-286600 376320 1 180 $X=-293190 $Y=375680
X64781 1 2 2791 724 725 2764 2451 AO22_5VX1 $T=-283240 394240 0 180 $X=-289830 $Y=389120
X64782 1 2 726 724 725 8414 2862 AO22_5VX1 $T=-280440 206080 0 0 $X=-280870 $Y=205440
X64783 1 2 2821 724 725 2885 2408 AO22_5VX1 $T=-265880 385280 1 180 $X=-272470 $Y=384640
X64784 1 2 2919 724 725 2938 2546 AO22_5VX1 $T=-264200 394240 1 0 $X=-264630 $Y=389120
X64785 1 2 2948 724 725 2959 3010 AO22_5VX1 $T=-259160 403200 0 0 $X=-259590 $Y=402560
X64786 1 2 3016 724 725 3006 8488 AO22_5VX1 $T=-251880 385280 0 0 $X=-252310 $Y=384640
X64787 1 2 3146 724 725 3121 2481 AO22_5VX1 $T=-236760 412160 0 180 $X=-243350 $Y=407040
X64788 1 2 3145 724 725 3165 2931 AO22_5VX1 $T=-231160 394240 0 0 $X=-231590 $Y=393600
X64789 1 2 8540 724 725 3207 2826 AO22_5VX1 $T=-223320 412160 0 180 $X=-229910 $Y=407040
X64790 1 2 3371 724 725 3338 3268 AO22_5VX1 $T=-205960 394240 1 180 $X=-212550 $Y=393600
X64791 1 2 8582 724 725 3399 3417 AO22_5VX1 $T=-204280 403200 0 0 $X=-204710 $Y=402560
X64792 1 2 3339 724 725 3657 3482 AO22_5VX1 $T=-196440 412160 0 0 $X=-196870 $Y=411520
X64793 1 2 3451 724 725 3494 3502 AO22_5VX1 $T=-195880 412160 1 0 $X=-196310 $Y=407040
X64794 1 2 8601 724 725 3523 3242 AO22_5VX1 $T=-195880 421120 1 0 $X=-196310 $Y=416000
X64795 1 2 2449 4509 4525 4676 4252 AO22_5VX1 $T=-72120 277760 0 0 $X=-72550 $Y=277120
X64796 1 2 4669 4509 4525 4753 4251 AO22_5VX1 $T=-68760 286720 1 0 $X=-69190 $Y=281600
X64797 1 2 2501 4509 4525 4602 4184 AO22_5VX1 $T=-57000 313600 0 180 $X=-63590 $Y=308480
X64798 1 2 4594 4509 4525 4618 4634 AO22_5VX1 $T=-62600 286720 1 0 $X=-63030 $Y=281600
X64799 1 2 2627 4509 4525 4608 3840 AO22_5VX1 $T=-55880 322560 1 180 $X=-62470 $Y=321920
X64800 1 2 2358 4509 4525 4619 4112 AO22_5VX1 $T=-55320 295680 0 180 $X=-61910 $Y=290560
X64801 1 2 2476 4509 4525 8869 3836 AO22_5VX1 $T=-53080 340480 1 180 $X=-59670 $Y=339840
X64802 1 2 2400 4509 4525 4668 4675 AO22_5VX1 $T=-57000 241920 1 0 $X=-57430 $Y=236800
X64803 1 2 2434 4509 4525 4659 8871 AO22_5VX1 $T=-49720 250880 0 180 $X=-56310 $Y=245760
X64804 1 2 2620 4509 4525 4684 4147 AO22_5VX1 $T=-46920 394240 1 180 $X=-53510 $Y=393600
X64805 1 2 4448 4509 4525 4793 4463 AO22_5VX1 $T=-52520 286720 0 0 $X=-52950 $Y=286080
X64806 1 2 2628 4509 4525 4691 3531 AO22_5VX1 $T=-45240 394240 0 180 $X=-51830 $Y=389120
X64807 1 2 4529 4509 4525 4816 8886 AO22_5VX1 $T=-50840 340480 0 0 $X=-51270 $Y=339840
X64808 1 2 3098 4509 4525 4710 4681 AO22_5VX1 $T=-42440 358400 1 180 $X=-49030 $Y=357760
X64809 1 2 4515 4509 4525 4723 5166 AO22_5VX1 $T=-48040 331520 1 0 $X=-48470 $Y=326400
X64810 1 2 4705 4509 4525 4737 4146 AO22_5VX1 $T=-46360 376320 1 0 $X=-46790 $Y=371200
X64811 1 2 8897 4509 4525 4777 4315 AO22_5VX1 $T=-38520 304640 0 180 $X=-45110 $Y=299520
X64812 1 2 4392 4509 4525 4736 4587 AO22_5VX1 $T=-38520 313600 0 180 $X=-45110 $Y=308480
X64813 1 2 4696 4509 4525 4848 8900 AO22_5VX1 $T=-44680 340480 1 0 $X=-45110 $Y=335360
X64814 1 2 4397 4509 4525 4761 8904 AO22_5VX1 $T=-43000 241920 0 0 $X=-43430 $Y=241280
X64815 1 2 8906 4509 4525 4835 4412 AO22_5VX1 $T=-33480 358400 1 180 $X=-40070 $Y=357760
X64816 1 2 8907 4509 4525 4812 4763 AO22_5VX1 $T=-33480 376320 1 180 $X=-40070 $Y=375680
X64817 1 2 8892 4509 4525 4794 4767 AO22_5VX1 $T=-32920 322560 0 180 $X=-39510 $Y=317440
X64818 1 2 2773 4509 4525 4785 4246 AO22_5VX1 $T=-30680 224000 1 180 $X=-37270 $Y=223360
X64819 1 2 4173 4509 4525 4815 4828 AO22_5VX1 $T=-36840 241920 0 0 $X=-37270 $Y=241280
X64820 1 2 4735 4509 4525 4896 4498 AO22_5VX1 $T=-28440 224000 1 0 $X=-28870 $Y=218880
X64821 1 2 4920 4509 4525 4897 4413 AO22_5VX1 $T=-21160 394240 1 180 $X=-27750 $Y=393600
X64822 1 2 8916 4509 4525 8929 4891 AO22_5VX1 $T=-19480 394240 0 180 $X=-26070 $Y=389120
X64823 1 2 4933 4509 4525 4903 8924 AO22_5VX1 $T=-19480 412160 0 180 $X=-26070 $Y=407040
X64824 1 2 8930 4509 4525 4969 4962 AO22_5VX1 $T=-22840 367360 0 0 $X=-23270 $Y=366720
X64825 1 2 4927 4509 4525 4994 4853 AO22_5VX1 $T=-15000 232960 1 0 $X=-15430 $Y=227840
X64826 1 2 8946 4509 4525 5044 5012 AO22_5VX1 $T=-15000 412160 1 0 $X=-15430 $Y=407040
X64827 1 2 9986 4509 4525 5000 5016 AO22_5VX1 $T=-14440 421120 1 0 $X=-14870 $Y=416000
X64828 1 2 1127 907 899 NO2_5VX2 $T=-508920 313600 1 180 $X=-514390 $Y=312960
X64829 1 2 2666 725 2499 NO2_5VX2 $T=-303960 376320 0 0 $X=-304390 $Y=375680
X64830 1 2 4677 4525 4343 NO2_5VX2 $T=-55880 358400 0 0 $X=-56310 $Y=357760
X64831 1 2 1117 1127 910 AND2_5VX2 $T=-521240 322560 0 180 $X=-526710 $Y=317440
X64832 1 2 8373 2666 724 AND2_5VX2 $T=-298920 385280 1 180 $X=-304390 $Y=384640
X64833 1 2 4651 4677 4509 AND2_5VX2 $T=-53080 358400 1 0 $X=-53510 $Y=353280
X64834 1 2 8598 3556 3548 DFRQ_5VX2 $T=-200360 241920 1 0 $X=-200790 $Y=236800
X64835 1 2 3549 3556 3666 DFRQ_5VX2 $T=-189160 241920 0 0 $X=-189590 $Y=241280
X64836 1 2 9861 5140 9068 DFRQ_5VX2 $T=23640 241920 1 0 $X=23210 $Y=236800
X64837 1 2 6005 6104 6160 DFRQ_5VX2 $T=111000 277760 0 0 $X=110570 $Y=277120
X64838 1 2 8490 3094 9970 DFRQ_5VX4 $T=-249080 206080 0 0 $X=-249510 $Y=205440
X64839 1 2 3205 3169 3285 DFRQ_5VX4 $T=-232280 259840 1 0 $X=-232710 $Y=254720
X64840 1 2 5273 5245 5378 DFRQ_5VX4 $T=19720 277760 1 0 $X=19290 $Y=272640
X64841 1 2 9742 4826 679 DFRQ_5VX4 $T=466040 206080 0 0 $X=465610 $Y=205440
X64842 1 2 7833 4826 681 DFRQ_5VX4 $T=475000 206080 1 0 $X=474570 $Y=200960
X64843 1 2 7814 4826 687 DFRQ_5VX4 $T=483960 197120 0 0 $X=483530 $Y=196480
X64844 1 2 9761 4826 691 DFRQ_5VX4 $T=493480 179200 0 0 $X=493050 $Y=178560
X64845 1 2 7860 4826 693 DFRQ_5VX4 $T=499640 143360 1 0 $X=499210 $Y=138240
X64846 1 2 7876 4826 694 DFRQ_5VX4 $T=502440 134400 0 0 $X=502010 $Y=133760
X64847 1 2 7867 4826 695 DFRQ_5VX4 $T=505240 125440 1 0 $X=504810 $Y=120320
X64848 1 2 7901 4826 697 DFRQ_5VX4 $T=506360 116480 0 0 $X=505930 $Y=115840
X64849 1 2 7903 4826 696 DFRQ_5VX4 $T=507480 107520 0 0 $X=507050 $Y=106880
X64850 1 2 7883 4826 698 DFRQ_5VX4 $T=508600 107520 1 0 $X=508170 $Y=102400
X64851 1 2 7908 4826 701 DFRQ_5VX4 $T=510280 98560 0 0 $X=509850 $Y=97920
D0 2 1 p_dnw5 AREA=6.07923e-09 PJ=0.00246485 perimeter=0.00246485 $X=-611830 $Y=19900 $dt=1
D1 2 1 p_dnw5 AREA=6.07657e-09 PJ=0.00246471 perimeter=0.00246471 $X=-611830 $Y=28860 $dt=1
D2 2 1 p_dnw5 AREA=6.06267e-09 PJ=0.00246737 perimeter=0.00246737 $X=-611830 $Y=37820 $dt=1
D3 2 1 p_dnw5 AREA=6.07591e-09 PJ=0.00246485 perimeter=0.00246485 $X=-611830 $Y=46780 $dt=1
D4 2 1 p_dnw5 AREA=6.07233e-09 PJ=0.00246564 perimeter=0.00246564 $X=-611830 $Y=55740 $dt=1
D5 2 1 p_dnw5 AREA=6.06407e-09 PJ=0.00246769 perimeter=0.00246769 $X=-611830 $Y=64700 $dt=1
D6 2 1 p_dnw5 AREA=6.05392e-09 PJ=0.00246993 perimeter=0.00246993 $X=-611830 $Y=73660 $dt=1
D7 2 1 p_dnw5 AREA=6.05177e-09 PJ=0.00247182 perimeter=0.00247182 $X=-611830 $Y=82620 $dt=1
D8 2 1 p_dnw5 AREA=6.09142e-09 PJ=0.00246481 perimeter=0.00246481 $X=-611830 $Y=100540 $dt=1
D9 2 1 p_dnw5 AREA=6.07622e-09 PJ=0.00246613 perimeter=0.00246613 $X=-611830 $Y=109500 $dt=1
D10 2 1 p_dnw5 AREA=6.07174e-09 PJ=0.00246679 perimeter=0.00246679 $X=-611830 $Y=118460 $dt=1
D11 2 1 p_dnw5 AREA=6.06534e-09 PJ=0.00246963 perimeter=0.00246963 $X=-611830 $Y=136380 $dt=1
D12 2 1 p_dnw5 AREA=6.05957e-09 PJ=0.0024673 perimeter=0.0024673 $X=-611830 $Y=163260 $dt=1
D13 2 1 p_dnw5 AREA=6.05739e-09 PJ=0.00247159 perimeter=0.00247159 $X=-611830 $Y=172220 $dt=1
D14 2 1 p_dnw5 AREA=6.05594e-09 PJ=0.00247134 perimeter=0.00247134 $X=-611830 $Y=181180 $dt=1
D15 2 1 p_dnw5 AREA=6.06024e-09 PJ=0.00246925 perimeter=0.00246925 $X=-611830 $Y=199100 $dt=1
D16 2 1 p_dnw5 AREA=6.04254e-09 PJ=0.00247329 perimeter=0.00247329 $X=-611830 $Y=208060 $dt=1
D17 2 1 p_dnw5 AREA=6.03131e-09 PJ=0.00247367 perimeter=0.00247367 $X=-611830 $Y=217020 $dt=1
D18 2 1 p_dnw5 AREA=6.01898e-09 PJ=0.00247498 perimeter=0.00247498 $X=-611830 $Y=225980 $dt=1
D19 2 1 p_dnw5 AREA=6.01221e-09 PJ=0.00247488 perimeter=0.00247488 $X=-611830 $Y=234940 $dt=1
D20 2 1 p_dnw5 AREA=6.03559e-09 PJ=0.00247017 perimeter=0.00247017 $X=-611830 $Y=243900 $dt=1
D21 2 1 p_dnw5 AREA=6.0263e-09 PJ=0.00247322 perimeter=0.00247322 $X=-611830 $Y=252860 $dt=1
D22 2 1 p_dnw5 AREA=6.03704e-09 PJ=0.0024711 perimeter=0.0024711 $X=-611830 $Y=261820 $dt=1
D23 2 1 p_dnw5 AREA=6.03407e-09 PJ=0.00247202 perimeter=0.00247202 $X=-611830 $Y=270780 $dt=1
D24 2 1 p_dnw5 AREA=6.05152e-09 PJ=0.00246782 perimeter=0.00246782 $X=-611830 $Y=279740 $dt=1
D25 2 1 p_dnw5 AREA=6.03532e-09 PJ=0.00247217 perimeter=0.00247217 $X=-611830 $Y=288700 $dt=1
D26 2 1 p_dnw5 AREA=6.03971e-09 PJ=0.00247116 perimeter=0.00247116 $X=-611830 $Y=297660 $dt=1
D27 2 1 p_dnw5 AREA=6.03563e-09 PJ=0.00247221 perimeter=0.00247221 $X=-611830 $Y=306620 $dt=1
D28 2 1 p_dnw5 AREA=6.02969e-09 PJ=0.00247284 perimeter=0.00247284 $X=-611830 $Y=315580 $dt=1
D29 2 1 p_dnw5 AREA=6.04265e-09 PJ=0.002469 perimeter=0.002469 $X=-611830 $Y=324540 $dt=1
D30 2 1 p_dnw5 AREA=6.00985e-09 PJ=0.00247682 perimeter=0.00247682 $X=-611830 $Y=333500 $dt=1
D31 2 1 p_dnw5 AREA=6.00371e-09 PJ=0.00247727 perimeter=0.00247727 $X=-611830 $Y=342460 $dt=1
D32 2 1 p_dnw5 AREA=6.01291e-09 PJ=0.00247411 perimeter=0.00247411 $X=-611830 $Y=351420 $dt=1
D33 2 1 p_dnw5 AREA=6.01992e-09 PJ=0.00247559 perimeter=0.00247559 $X=-611830 $Y=360380 $dt=1
D34 2 1 p_dnw5 AREA=6.02364e-09 PJ=0.00247461 perimeter=0.00247461 $X=-611830 $Y=369340 $dt=1
D35 2 1 p_dnw5 AREA=6.02618e-09 PJ=0.00247144 perimeter=0.00247144 $X=-611830 $Y=378300 $dt=1
D36 2 1 p_dnw5 AREA=6.02093e-09 PJ=0.00247294 perimeter=0.00247294 $X=-611830 $Y=387260 $dt=1
D37 2 1 p_dnw5 AREA=6.00174e-09 PJ=0.00247819 perimeter=0.00247819 $X=-611830 $Y=396220 $dt=1
D38 2 1 p_dnw5 AREA=5.99638e-09 PJ=0.00247845 perimeter=0.00247845 $X=-611830 $Y=405180 $dt=1
D39 2 1 p_dnw5 AREA=5.96698e-09 PJ=0.00248105 perimeter=0.00248105 $X=-611830 $Y=414140 $dt=1
D40 2 1 p_dnw5 AREA=3.75723e-09 PJ=0.00246575 perimeter=0.00246575 $X=-611830 $Y=423100 $dt=1
D41 2 1 p_dnw5 AREA=6.06266e-09 PJ=0.00246889 perimeter=0.00246889 $X=-135170 $Y=91150 $dt=1
D42 2 1 p_dnw5 AREA=6.05116e-09 PJ=0.00247439 perimeter=0.00247439 $X=-95410 $Y=126990 $dt=1
D43 2 1 p_dnw5 AREA=6.0599e-09 PJ=0.00246908 perimeter=0.00246908 $X=-67950 $Y=144910 $dt=1
D44 2 1 p_dnw5 AREA=6.05717e-09 PJ=0.00247052 perimeter=0.00247052 $X=-66830 $Y=189710 $dt=1
D45 2 1 p_dnw5 AREA=6.0517e-09 PJ=0.00247081 perimeter=0.00247081 $X=2050 $Y=153870 $dt=1
.ends MASCO__P3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: filter_top                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt filter_top clk clk_div_3 gnd! in<0> in<10> in<1> in<2> in<3> in<4> in<5>
+ in<6> in<7> in<8> in<9> out<0> out<10> out<1> out<2> out<3> out<4>
+ out<5> out<6> out<7> out<8> out<9> reset vdd5!
** N=1453 EP=27 FDC=247603
X0 gnd! vdd5! 3 4 5 6 7 8 9 10
+ 11 reset 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30
+ 31 32 33 34 35 36 37 38 39 40
+ 41 42 43 44 45 46 47 48 49 50
+ 51 52 53 54 55 56 57 58 59 60
+ 61 62 63 64 65 66 67 68 69 70
+ 71 72 73 74 75 76 77 78 79 80
+ 81 82 83 84 85 86 87 88 89 90
+ 91 92 93 94 95 96 97 98 99 100
+ 101 102 103 104 105 106 107 108 109 110
+ 111 112 113 114 115 116 117 118 119 120
+ 121 122 123 124 125 126 127 128 129 130
+ 131 132 133 134 135 136 137 138 139 140
+ 141 142 143 144 145 146 147 148 149 150
+ 151 152 153 154 155 156 157 158 159 160
+ 161 162 163 164 165 166 167 168 169 170
+ 171 172 173 174 175 176 177 178 179 180
+ 181 182 183 184 185 186 187 188 189 190
+ 191 192 193 194 195 196 197 198 199 200
+ 201 202 203 204 205 206 207 208 209 210
+ 211 212 213 214 215 216 217 218 219 220
+ 221 222 223 224 225 226 227 228 229 230
+ 231 232 233 234 235 236 237 238 239 240
+ 241 242 243 244 245 246 247 248 249 250
+ 251 252 253 254 255 256 257 258 259 260
+ 261 262 263 264 265 266 267 268 269 270
+ 271 272 273 274 275 276 277 278 279 280
+ 281 282 283 284 285 286 287 288 289 290
+ 291 292 293 294 295 296 297 298 299 300
+ 301 302 303 304 305 306 307 308 309 310
+ 311 312 313 314 315 316 317 318 319 320
+ 321 322 323 324 325 326 327 328 329 330
+ 331 332 333 334 335 336 337 338 339 340
+ 341 342 343 344 345 346 347 348 349 350
+ 351 352 353 354 355 356 357 358 359 360
+ 361 362 363 364 365 366 367 368 369 370
+ 371 372 373 374 375 376 377 378 379 380
+ 381 382 383 384 385 386 387 388 389 390
+ 391 392 393 394 395 396 397 398 399 400
+ 401 402 403 404 405 406 407 408 409 410
+ 411 412 413 414 415 416 417 418 419 420
+ 421 422 423 424 425 426 427 428 429 430
+ 431 432 433 434 435 436 437 438 439 440
+ 441 442 443 444 445 446 447 448 449 450
+ 451 452 453 454 455 456 457 458 459 460
+ 461 462 463 464 465 466 467 468 469 470
+ 471 472 473 474 475 476 477 478 479 480
+ 481 482 483 484 485 486 487 488 489 490
+ 491 492 493 494 495 496 497 498 499 500
+ 501 502 503 504 505 506 507 508 509 510
+ 511 512 513 514 515 516 517 518 519 520
+ 521 522 523 524 525 526 527 528 529 530
+ 531 532 533 534 535 536 537 538 539 540
+ 541 542 543 544 545 546 547 548 549 550
+ 551 552 553 554 555 556 557 558 559 560
+ 561 562 563 564 565 566 567 568 569 570
+ 571 572 573 574 575 576 577 578 579 580
+ 581 582 583 584 585 586 587 588 589 590
+ 591 592 593 594 595 596 597 598 599 600
+ 601 602 603 604 605 606 607 608 609 610
+ 611 612 613 614 615 616 617 618 619 620
+ 621 622 623 624 625 626 627 628 629 630
+ 631 632 633 634 635 636 637 638 639 640
+ 641 642 643 644 645 646 647 648 649 650
+ 651 652 653 654 655 656 657 658 659 660
+ 661 662 663 664 665 666 667 668 669 670
+ 671 672 673 674 675 676 677 678 679 680
+ 681 682 683 684 685 686 687 688 689 690
+ 691 692 693 694 695 696 697 698 699 700
+ 701 702 703 704 705 706 707 708 709 710
+ 711 712 713 714 715 716 717 718 719 720
+ 721 722 723 724 725 726 727 728 729 730
+ 731 732 733 734 735 736 737 738 739 740
+ 741 742 743 744 745 746 747 MASCO__P1 $T=0 0 0 0 $X=-636740 $Y=-450750
X1 in<0> in<1> gnd! vdd5! in<2> reset 764 765 766 767
+ 768 769 770 771 772 773 774 775 776 777
+ 778 779 780 781 782 783 784 785 786 787
+ 788 789 790 791 792 793 794 795 796 797
+ 798 799 800 801 802 803 804 805 806 807
+ 808 809 810 811 812 813 814 815 816 817
+ 14 818 16 7 819 820 821 822 823 824
+ 19 825 21 20 826 827 190 182 828 829
+ 830 23 831 832 833 834 32 835 26 25
+ 24 836 837 838 839 840 17 31 841 34
+ 842 843 38 35 37 844 845 846 847 848
+ 849 850 851 852 853 854 43 855 856 857
+ 858 859 860 44 861 862 863 864 50 48
+ 865 866 867 33 49 47 51 36 868 55
+ 63 52 869 870 871 59 872 873 61 874
+ 875 58 60 876 877 878 879 880 881 73
+ 882 76 883 884 885 66 64 886 887 53
+ 888 69 889 77 75 89 890 90 80 891
+ 892 54 893 92 894 87 clk_div_3 115 91 895
+ 98 82 896 897 898 94 899 110 900 901
+ 902 903 904 905 129 106 105 906 907 99
+ 97 107 908 111 909 104 910 911 133 135
+ 122 121 39 128 912 913 914 6 915 916
+ 917 918 919 920 921 922 923 140 924 925
+ 926 125 4 927 11 928 929 930 931 932
+ 933 934 935 936 108 937 46 143 938 939
+ 940 162 142 139 941 148 137 160 942 22
+ 177 144 147 169 124 56 943 136 944 29
+ 945 149 179 946 154 947 170 948 155 40
+ 949 950 158 28 951 952 953 165 27 954
+ 42 955 191 956 153 957 145 183 41 958
+ 959 960 961 168 962 963 62 964 167 102
+ 965 157 966 967 151 968 969 171 174 164
+ 970 176 100 971 173 972 973 974 181 975
+ 178 184 976 10 185 977 978 979 980 981
+ 18 982 187 753 983 984 985 986 192 188
+ 987 988 989 189 990 991 992 993 994 995
+ 996 997 998 999 209 1000 204 70 197 68
+ 195 193 112 15 150 211 65 1001 117 1002
+ 1003 1004 116 57 1005 126 213 1006 235 161
+ 72 45 1007 205 1008 186 232 9 86 1009
+ 88 141 138 132 130 67 1010 159 194 1011
+ 212 1012 1013 1014 214 1015 215 210 1016 1017
+ 101 225 1018 1019 1020 1021 13 223 219 1022
+ 1023 1024 1025 231 224 83 207 1026 1027 208
+ 442 227 114 279 229 8 247 1028 352 123
+ 180 120 220 1029 241 440 233 362 1030 238
+ 84 113 234 230 1031 409 1032 1033 507 1034
+ 260 1035 236 78 198 391 81 1036 1037 163
+ 71 329 1038 253 1039 322 237 1040 1041 217
+ 239 296 1042 79 248 206 30 127 250 96
+ 333 1043 1044 216 156 199 118 443 74 361
+ 131 103 330 271 119 175 172 222 1045 243
+ 218 240 1046 1047 221 1048 1049 202 1050 1051
+ 1052 200 242 166 244 316 310 1053 385 245
+ 93 201 95 85 286 1054 1055 1056 228 1057
+ 1058 294 109 134 249 246 287 347 262 1059
+ 1060 196 275 252 1061 1062 1063 251 257 359
+ 261 1064 1065 255 203 1066 265 269 1067 267
+ 1068 1069 1070 280 272 1071 1072 1073 1074 1075
+ 1076 446 1077 1078 1079 1080 1081 1082 1083 1084
+ 1085 291 273 1086 1087 1088 226 1089 259 1090
+ 1091 1092 1093 1094 1095 1096 258 1097 1098 1099
+ 1100 268 278 367 345 1101 1102 1103 289 1104
+ 283 284 431 1105 282 1106 1107 1108 295 270
+ 301 307 288 1109 1110 1111 306 300 363 293
+ 1112 1113 281 1114 277 308 1115 1116 1117 1118
+ 305 264 1119 274 1120 297 1121 285 303 299
+ 1122 435 508 448 1123 1124 312 314 311 292
+ 358 1125 290 436 323 1126 313 1127 266 375
+ 1128 1129 1130 320 1131 276 315 298 318 334
+ 1132 324 466 1133 1134 433 1135 1136 254 402
+ 579 420 416 325 263 1137 326 429 478 390
+ 1138 335 419 1139 377 399 1140 340 382 376
+ 406 1141 328 341 319 1142 1143 403 1144 468
+ 627 455 336 461 1145 1146 387 485 317 379
+ 327 1147 1148 321 1149 349 1150 487 357 332
+ 529 1151 519 512 504 427 339 331 369 1152
+ 441 309 1153 364 1154 532 346 344 1155 1156
+ 454 437 1157 343 342 453 356 1158 1159 354
+ 351 1160 556 355 1161 348 1162 366 495 548
+ 539 1163 360 1164 337 1165 368 1166 1167 497
+ 1168 338 636 1169 1170 480 535 378 371 1171
+ 473 500 392 465 381 484 542 547 373 1172
+ 1173 589 1174 562 464 1175 1176 372 384 1177
+ 1178 452 451 588 1179 1180 1181 582 606 413
+ 581 1182 444 462 350 445 1183 383 353 386
+ 1184 432 256 479 434 302 598 380 1185 1186
+ 1187 388 602 1188 1189 398 501 1190 554 1191
+ 597 518 1192 401 394 1193 569 1194 616 397
+ 374 1195 1196 1197 1198 1199 396 1200 1201 400
+ 1202 1203 1204 405 1205 404 395 499 1206 1207
+ 421 1208 408 407 1209 411 1210 560 1211 1212
+ 1213 418 410 417 414 1214 1215 1216 610 1217
+ 559 304 1218 1219 1220 1221 415 1222 424 422
+ 423 425 1223 1224 1225 438 428 1226 1227 1228
+ 426 1229 1230 1231 1232 1233 1234 447 668 1235
+ 596 577 600 1236 1237 450 521 502 515 1238
+ 490 594 449 1239 541 460 1240 1241 1242 631
+ 630 459 1243 1244 645 644 1245 601 536 633
+ 591 611 662 1246 551 641 1247 469 609 587
+ 553 655 640 1248 503 1249 522 457 393 492
+ 599 545 1250 370 552 1251 475 632 1252 624
+ 463 412 1253 1254 477 621 638 456 1255 471
+ 467 561 470 558 576 474 647 458 476 575
+ 486 483 533 1256 1257 505 620 430 482 472
+ 571 389 489 1258 488 494 526 481 491 439
+ 365 1259 528 1260 604 1261 523 1262 574 1263
+ 689 1264 1265 1266 1267 538 1268 496 1269 493
+ 1270 1271 1272 498 1273 607 595 1274 690 546
+ 534 543 1275 540 635 509 506 1276 563 557
+ 590 549 513 1277 1278 544 1279 628 637 1280
+ 530 643 580 527 573 555 626 520 713 1281
+ 1282 537 531 608 1283 567 1284 566 1285 1286
+ 584 649 1287 1288 550 1289 1290 1291 1292 1293
+ 570 1294 585 1295 1296 593 572 1297 1298 568
+ 1299 565 1300 586 1301 1302 564 583 1303 578
+ 1304 639 511 1305 678 1306 1307 1308 1309 1310
+ 1311 592 1312 1313 524 1314 617 517 1315 1316
+ 1317 603 1318 1319 1320 612 1321 1322 1323 615
+ 1324 676 510 516 623 1325 697 613 614 619
+ 1326 1327 1328 1329 1330 618 1331 622 1332 629
+ 1333 514 1334 625 646 1335 1336 1337 1338 1339
+ 1340 525 1341 634 1342 650 648 664 642 1343
+ 657 653 669 658 1344 1345 1346 1347 652 1348
+ 1349 654 660 659 651 661 1350 665 1351 1352
+ 666 1353 673 1354 1355 670 1356 1357 1358 1359
+ 1360 674 1361 1362 672 1363 1364 679 1365 605
+ 675 663 1366 1367 688 671 677 1368 656 684
+ 1369 682 691 1370 1371 1372 686 681 1373 683
+ 722 680 667 1374 1375 687 1376 685 1377 696
+ 701 1378 698 694 700 1379 703 704 1380 1381
+ 1382 702 1383 1384 1385 1386 1387 705 1388 1389
+ 1390 706 1391 711 1392 1393 712 708 1394 1395
+ 1396 1397 707 1398 1399 695 1400 718 716 709
+ 715 720 719 1401 699 1402 714 710 1403 1404
+ 1405 721 724 717 1406 1407 723 1408 727 726
+ 1409 728 1410 1411 1412 731 1413 692 1414 725
+ 1415 730 729 1416 736 1417 733 734 693 1418
+ 1419 737 738 735 739 1420 1421 1422 732 1423
+ 741 743 1424 1425 740 746 1426 1427 1428 1429
+ 747 745 742 744 1430 1431 MASCO__P2 $T=0 0 0 0 $X=-636740 $Y=-273920
X2 vdd5! gnd! in<5> 769 in<6> 765 764 766 in<4> in<7>
+ in<3> in<10> in<9> in<8> reset 770 807 788 878 787
+ 875 773 790 791 793 792 789 794 816 812
+ 798 799 797 802 850 784 851 835 801 806
+ 815 810 828 820 841 805 824 823 819 826
+ 849 833 832 830 838 839 821 837 795 855
+ 843 846 847 853 858 848 872 868 780 861
+ 854 866 809 860 865 803 876 857 871 869
+ 889 856 874 clk 852 778 825 831 883 893
+ 862 877 888 957 844 808 959 776 892 800
+ 781 894 822 785 817 873 890 966 818 811
+ 786 895 1028 906 951 887 937 897 905 904
+ 901 902 909 910 907 914 900 912 911 908
+ 804 915 917 919 916 934 921 924 779 796
+ 840 928 931 775 930 954 923 936 933 782
+ 842 886 918 927 768 929 941 961 827 814
+ 953 932 938 948 945 949 834 958 864 950
+ 955 940 962 991 973 867 968 859 863 967
+ 960 942 885 975 988 963 777 946 943 879
+ 1000 970 1008 774 971 1017 870 1019 1013 881
+ 969 972 974 884 813 767 981 977 979 829
+ 984 983 987 771 985 1021 989 986 990 980
+ 992 772 993 882 998 999 5 1026 845 1001
+ 995 1016 783 1005 1103 1015 1024 3 994 1009
+ 1012 1010 896 891 952 1110 1108 920 903 925
+ 935 997 1003 1020 1031 922 939 978 1022 1119
+ 899 880 1007 1025 956 1030 1011 1042 965 1032
+ 1035 1033 1169 926 1034 913 1037 1046 836 1041
+ 1192 947 1038 1044 1071 1069 982 1036 1100 753
+ 1014 1047 196 1045 146 1006 1002 1053 1048 1049
+ 1056 1095 1126 1043 1018 944 898 1055 1054 1058
+ 1057 976 1050 964 1206 1199 446 1080 1065 1063
+ 1090 1085 1082 1097 1064 1059 1066 1086 1060 1098
+ 1067 1081 1109 1093 996 1072 1104 1091 1102 1023
+ 1084 1111 1073 1094 1088 1079 1107 1087 1089 1070
+ 1083 1099 1092 1027 152 1141 1074 1068 1105 1077
+ 1101 1145 1127 1078 1130 1113 1075 1114 1112 1039
+ 1121 1122 1117 1040 1124 1118 1142 1123 1128 1135
+ 1131 1115 1004 1137 1129 1140 1116 1132 1134 1136
+ 1029 1139 1138 1133 1144 1146 1183 1052 1148 1143
+ 1152 1155 1147 1062 1154 1161 1159 1149 1156 1162
+ 1051 1160 1287 1153 1178 1158 1163 1151 1182 1189
+ 1172 1187 1170 1237 1120 1184 1076 1186 1061 1185
+ 1106 1188 1125 1096 1208 1191 1179 1167 1197 1165
+ 1202 1190 1212 1193 1200 1204 1194 1205 1211 1217
+ 1173 1209 1201 1358 1215 1196 1240 1219 1210 1214
+ 1216 1232 1218 1231 1222 1221 1224 1228 1223 1230
+ 1229 1225 1238 1227 1420 1233 1166 1243 1273 1226
+ 1234 1168 1242 1247 1253 1241 1379 1236 1254 1157
+ 1259 1349 1260 1203 1372 1263 1198 1180 1220 1207
+ 1195 1267 1264 1270 1235 1276 1250 1272 1363 1261
+ 1275 1262 1342 1336 1324 1299 1298 1323 1297 1284
+ 1177 1330 1286 1293 1171 1288 1291 1302 1295 1304
+ 1300 1294 1277 1307 1310 1340 1280 1292 1303 1314
+ 1301 1290 1296 1309 1285 1313 1174 1213 1316 1306
+ 1305 1271 1312 1328 1311 1255 1315 1176 1322 1321
+ 1318 1164 1266 1308 1317 1319 1326 1269 1412 1331
+ 1329 1320 1341 1265 1175 1245 1334 1246 1333 1339
+ 1181 1337 1347 1343 1251 1346 1345 1338 1348 1354
+ 1351 1356 1353 1344 1352 1359 1350 1370 1357 1355
+ 1361 1362 1248 1367 1239 1368 1282 1365 1369 1244
+ 1371 1256 1278 1258 1268 1373 1376 1374 1281 1375
+ 1274 1381 1283 1382 1378 1150 1377 1380 1384 1386
+ 1364 1391 1398 1388 1395 1389 1390 1383 1410 1387
+ 1332 1397 1393 1394 1327 1399 1392 1385 1400 1396
+ 1415 1257 1407 1402 1406 1335 1403 1401 1405 1249
+ 1409 1408 1414 1418 1413 1419 1416 1411 1289 1404
+ 1421 1422 1417 out<10> 689 out<9> 1424 1425 1426 1423
+ 1427 out<8> 1429 1428 1430 out<7> 1279 out<6> out<5> out<4>
+ out<2> out<3> out<1> 1360 1252 out<0> 1325 1431 1366 MASCO__P3 $T=0 0 0 0 $X=-636740 $Y=12800
D0 gnd! vdd5! p_dnw5 AREA=6.06643e-09 PJ=0.00246644 perimeter=0.00246644 $X=-611830 $Y=-275780 $dt=1
D1 gnd! vdd5! p_dnw5 AREA=6.06928e-09 PJ=0.00246747 perimeter=0.00246747 $X=-611830 $Y=10940 $dt=1
.ends filter_top
